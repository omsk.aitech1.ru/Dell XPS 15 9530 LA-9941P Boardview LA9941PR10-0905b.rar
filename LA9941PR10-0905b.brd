# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N112583855: length 4
  TOP w0.203: U15.35 20.89,39.99 20.83,40.05 18.05,40.05 RA7.2
N112583857: length 10.8
  TOP w0.102: v1(20.49,50.81) 20.99,50.81 21.27,51.09 v2(21.27,51.23)
  TOP w0.203: v1(20.61,45.54) 21.25,44.9 21.25,44.21 21.47,43.99 U15.25
  TOP w0.508: v1(20.49,50.81) 20,50.81 CA5.1 ; v1(20.61,45.54) CA6.1
  BOTTOM w0.508: v1(20.61,45.54) 20.61,46.19 20.24,46.55 LA1.2 20.24,50.57 v1(20.49,50.81)
N112583906: length 2.7
  TOP w0.203: U15.10 28.77,43.19 v1(28.85,43.11)
  BOTTOM w0.102: v1(28.85,43.11) 28.85,43.02 v2(29.42,42.45)
  BOTTOM w0.508: v1(28.85,43.11) 28.74,43 CA21.2
N112583945: length 3.7
  TOP w0.102: CA16.2 v2(24.51,35.21)
  TOP w0.203: U15.41 24.36,38.81 24.36,37.84
  TOP w0.254: CA16.2 24.36,36.74 24.36,37.84
N112583953: length 2.5
  TOP w0.102: v2(23.84,46.36) 24.11,46.09 v1(24.11,45.8)
  TOP w0.203: v1(24.11,45.8) 23.95,45.64 U15.21
  BOTTOM w0.102: CA15.2 24.11,45.34 v1(24.11,45.8)
N112583955: length 3.5
  TOP w0.102: v1(22.2,45.48) 22.58,45.48 22.76,45.3 22.76,44.77 U15.24
  BOTTOM w0.102: CA15.1 22.52,45.16 v1(22.2,45.48) 22.2,45.29 21.98,45.07 21.14,45.07 v2(21.12,45.09)
N113011856: length 5.7
  BOTTOM w0.102: RU56.1 138.3,69.4 138.49,69.21 v2(138.49,68.61) 138.49,67.47 136.62,65.6 QU7.3
N113014039: length 3.2
  TOP w0.102: RE341.2 180.02,15.06 180.85,15.88 v2(181.13,15.88) DE305.2
N113014056: length 2.2
  TOP w0.102: DE303.2 RE340.2 v2(181.05,18.74)
N113014135: length 4.2
  TOP w0.102: v2(173.29,13.76) 172.74,13.22 RE321.2 170.55,12.24 170.45,12.24 DE304.1
N113172796: length 59.8
  TOP w0.102: v8(54.21,35.34) 53.55,36 v1(53.1,36)
  IN2 w0.102: v1(53.1,36) 52.82,36.28 49.99,36.28 49.62,36.65 45.12,36.65 39.5,42.27 37.83,42.27 36.61,43.49 33.88,43.49 29.44,47.94 29.44,51.81 28.74,52.5 28.74,56.85 26.27,59.31 26.27,63.34 24.95,64.66 24.95,68.41 v1(25.16,68.61)
  BOTTOM w0.102: JFAN1.3 v1(53.1,36) ; v1(25.16,68.61) 26.35,68.61 27.34,69.61 DE4.1 28.64,68.66 RE53.2
N113206218: length 6.9
  TOP w0.102: CA17.2 30.76,39.1 RA9.1 RA10.1 29.59,38.23 29.09,37.74 v1(29.09,37.5) 29.09,37.26 RA11.1
  BOTTOM w0.102: RA5.2 CA32.1 29.73,38.13 v1(29.09,37.5) 29.37,37.5 v2(29.68,37.19)
N113470198: length 6.9
  BOTTOM w0.254: RA43.2 18.35,35.61 v2(17.46,36.5) 17.26,36.7 17.26,38.6 16.78,39.08 QA3.3 16.78,40.25 16.64,40.39 16.28,40.39 16.13,40.24 QA3.2
N113470202: length 4.5
  BOTTOM w0.254: RA101.2 RA42.1 ; RA42.1 RA102.2 ; RA42.1 16.57,35.95 16.13,36.39 v2(16.13,36.48) QA3.5
N113473311: length 4.4
  TOP w0.102: v2(4.18,35.06) 4.86,35.06 5.17,34.75 RA44.2 5.46,34.72 6.34,33.84 RA55.1 6.8,34.3 QA4.3
N113473853: length 2.9
  TOP w0.102: QA4.2 6.96,34.95 6.77,34.75 RA55.2 6.34,34.75 5.9,35.19 5.9,35.24 CA22.1
N113477170: length 3.1
  BOTTOM w0.102: v2(8.39,34.32) 8.42,34.3 9.77,34.3 CA28.2 11.03,34.77 UA2.B3
N113477928: length 3.8
  BOTTOM w0.102: RA99.2 RA100.2 12.94,34.42 12.75,34.62 UA2.B1 12.18,33.58 11.78,33.18 v2(11.61,33.18)
N113626745: length 3.4
  TOP w0.089: QV23.1 213.29,125.36 213.19,125.25 213.19,125.16
  TOP w0.102: 213.19,125.16 212.8,124.77 v2(212.57,124.77) 211.96,124.77 RV372.2 210.72,125.15 RV370.2
N113629630: length 2.9
  TOP w0.102: U4.4 96.39,42.05 96.67,41.77 v2(96.67,41.44) 96.67,41.24 96.26,40.84 CT21.1
N113637608: length 5.2
  TOP w0.102: RV385.2 QV24.1 251.05,77.96 250.76,77.67 250.76,76.45 RV383.2 250.58,75.41 v2(250.95,75.04)
N113676531: length 19.2
  TOP w0.102: RV396.2 252.77,112.12 v1(252.73,112.09) ; RV398.2 v1(255.73,99.58) 255.93,99.37 v2(255.93,98.41) 255.93,98.37 254.76,97.2 QV25.1
  IN4 w0.089: 253.44,111.98 253.88,111.55
  IN4 w0.102: v1(252.73,112.09) 253.34,112.09 253.44,111.98 ; 253.88,111.55 254.19,111.23 254.19,104.89 255.1,103.98 255.1,99.89 255.42,99.58 v1(255.73,99.58)
N113699173: length 1.6
  TOP w0.089: v1(212.14,100.28) 212.46,100.6 RV345.2
  BOTTOM w0.089: UV1.AC28 211.72,100.7 v1(212.14,100.28)
N113760009: length 6.8
  TOP w0.102: v2(248.55,50.07) 248.65,50.17 RZ484.1 249.73,51.19 249.66,51.26 QZ18.1 248.73,52.71 247.83,51.81 QZ25.2
N113846970: length 2.9
  TOP w0.102: v2(189.12,20.26) DE306.1 RE322.2
N114071099: length 5.3
  TOP w0.102: QV7.2 QV7.5 221.33,18.36 221.49,18.21 221.93,18.21 v2(221.98,18.26) 221.98,19.12 RV416.1 RV419.1
N114300903: length 4.6
  TOP w0.102: v2(205.15,21.57) 204.72,21.14 204.72,20.28 204.87,20.13 U1.28 206.9,20.13 R72.2
N114414277: length 4.6
  TOP w0.508: CZ602.1 258.79,52.9 RZ602.2 258.74,52.59 v1(259.25,52.08)
  BOTTOM w0.102: v2(260.06,52.84) 259.3,52.08 v1(259.25,52.08)
  BOTTOM w0.508: v1(259.25,52.08) 258.76,51.6 UZ600.1
N115378415: length 3
  TOP w0.102: v8(26.78,106.18) R66.1
  TOP w0.508: R66.1 25.45,106.19 23.83,106.19 SW1.5
N115378546: length 259.8
  TOP w0.102: SW1.4 SW1.6 18.98,106.15 18.58,106.56 v1(18.58,107.58)
  IN2 w0.102: v4(156.2,12.39) 155.67,12.39 152.37,15.68 149.6,15.68 148.92,16.35 147.67,16.35 147.46,16.14 143.6,16.14 141.08,18.65 128.67,18.65 128.26,18.25 126.89,18.25 126.01,17.37 117.21,17.37 115.91,18.68 107.84,18.68 100.73,25.79 97.59,25.79 97.26,25.46 93.19,25.46 91.07,27.58 83.16,27.58 82.95,27.37 74.96,27.37 74.94,27.34 59.62,27.34 57.95,29.01 42.94,29.01 42.1,29.85 39.81,29.85 38.82,28.86 31.19,28.86 27.15,24.82 24.01,24.82 v4(23.58,24.39)
  IN3 w0.102: v1(18.58,107.58) 17.84,106.84 17.84,94.01 19.62,92.24 19.62,88.58 23.47,84.73 23.47,81.26 23.23,81.03 22.32,81.03 21.4,80.1 21.4,75.54 22.74,74.2 22.74,69.76 26.22,66.28 26.22,58.23 25.23,57.24 25.23,55.52 22.28,52.56 19.9,52.56 v4(18.17,50.83)
  IN4 w0.102: v4(18.17,50.83) 19,50.83 22.46,47.38 25.45,47.38 26.15,46.68 26.15,44.1 28.81,41.44 29.42,41.44 30.31,40.54 30.31,37.27 29.81,36.76 29.81,31.18 28.63,30.01 23.7,30.01 22.72,29.02 22.72,25.26 v4(23.58,24.39)
  GND3 w0.102: v7(156.48,12.73) 156.2,12.46 v4(156.2,12.39)
  BOTTOM w0.102: QZ20.1 156.65,13.55 157.01,13.19 157.01,12.94 156.81,12.73 v7(156.48,12.73)
N116140097: length 6.2
  BOTTOM w0.102: JEDP1.36 74.55,37.87 73.8,37.12 RV480.2 73.8,35.44 v2(73.44,35.09)
N116140123: length 13.8
  BOTTOM w0.102: v2(90.05,33.03) 89.88,33.21 89.22,33.21 88.82,33.6 RV481.2 88.07,34.04 86.88,35.24 86.72,35.24 84.07,37.89 81.7,37.89 81.05,38.54 JEDP1.23
N116140149: length 9
  BOTTOM w0.102: JEDP1.18 83.55,40.21 83.93,39.83 83.93,38.31 86.7,35.54 87.41,35.54 v2(87.9,35.06) 88.02,34.93 RV482.2
N116494866: length 1.6
  TOP w0.102: PC607.2 183.41,120.72 v2(182.68,119.98)
N116495432: length 1.9
  BOTTOM w0.102: PR716.2 111.63,103.63 v2(111.15,104.11)
N116496514: length 1.5
  TOP w0.102: v2(170.52,121.12) 170.13,120.73 PC822.1
N116508096: length 3.3
  TOP w0.102: PU801.1 182.53,124.75 182.88,125.1 183.07,125.1 v2(183.25,125.28)
  TOP w0.254: PR853.2 183.45,123.05 182.53,123.98 PU801.1
N116579401: length 2.1
  TOP w0.089: v1(268.54,24.46) 268.15,24.06 268.15,23.44 T46.1
  BOTTOM w0.089: U7.U7 268.27,24.19 v1(268.54,24.46)
N116608481: length 2.6
  TOP w0.102: RA11.2 CA30.2 30.81,35.87 31.28,36.34 31.64,36.34 31.88,36.58 v2(31.89,36.58)
N117057142: length 3.3
  TOP w0.102: v8(26.81,108.85) 26.22,109.43 R67.1
  TOP w0.508: R67.1 23.85,109.43 SW1.3
N117059899: length 7.8
  TOP w0.102: v1(19.11,114.87) 19.01,114.87 v8(18.5,114.36)
  BOTTOM w0.102: JTS.5 19.53,112.19 19.32,112.4 19.32,113.9 19.21,114 DV20.2 ; v1(19.11,114.87) 18.69,114.44 DV20.2 ; DV20.2 DV17.2 18.69,111.7 18.5,111.51 RV5.2
N117846833: length 3
  BOTTOM w0.102: v2(21.63,16.37) 21.55,16.44 21.55,17.05 21.75,17.25 R12.2 21.65,17.76 Q15.5 Q15.6
N117847159: length 3.2
  BOTTOM w0.102: v2(25.64,15.5) 25.21,15.93 Q16.5 Q16.6 24.01,14.61 R21.2
N117847657: length 4.2
  BOTTOM w0.102: Q17.5 Q17.6 27.28,16.68 27.11,16.52 27.11,15.43 v2(27.04,15.35) R18.2
N117847900: length 3.1
  TOP w0.102: v2(23.05,13.39) 23.73,13.39 R25.2 23.65,14.42 Q18.6 Q18.5
N117848353: length 3
  TOP w0.102: v2(14.62,17.28) 14.95,16.95 R27.2 15.95,16.24 Q19.5 Q19.6
N117848549: length 2.9
  TOP w0.102: v2(30.62,19.03) R33.2 29.08,18.56 Q20.6 Q20.5
N117915684: length 2.9
  TOP w0.203: PR340.2 45.17,33.7 46.35,33.7 46.88,33.17 PU300.6
N117915720: length 2.7
  TOP w0.203: PU300.7 46.81,32.77 46.29,33.29 v2(45.87,33.29) PR337.2
N118699787: length 3.9
  BOTTOM w0.102: DV13.3 88.86,30.85 89.31,30.85 90.15,31.68 v2(90.82,31.68) RV11.2
N118700499: length 2.4
  BOTTOM w0.102: DV10.3 86.7,29.62 v2(86.7,29.47) 86.7,28.61 RV12.2
N118700526: length 1.4
  TOP w0.076: 162.93,13.6 162.93,13.7 163.21,13.98 163.21,14.59 UE1.D1
  TOP w0.102: 162.93,13.6 T126.1
N118750823: length 68.2
  TOP w0.102: v1(147.24,15.71) 147.43,15.9 UE36.23
  IN2 w0.102: v1(120.76,15.41) 121.33,15.98 125.12,15.98 127.18,18.05 128.71,18.05 128.91,18.25 141.02,18.25 144.11,15.17 146.7,15.17 v1(147.24,15.71)
  BOTTOM w0.102: RE469.1 102.91,33.46 103.87,32.49 103.87,31.63 108.72,26.78 108.72,25.2 109.1,24.82 110.48,24.82 v2(113.33,21.97) 115,20.3 115,16.67 116.77,14.89 118.07,14.89 118.59,15.41 v1(120.76,15.41)

## Copper pours and planes (outline as drawn)
1.35V_B+ on TOP (solid shape): 131.5,19.98 132.2,19.98 132.2,20.51 132.7,20.51 132.7,19.98 133.4,19.98 133.4,20.51 133.97,20.51 134.15,20.33 134.15,15.04 134.11,15 131.63,15 130.95,14.31 128.82,14.31 128.69,14.44 128.69,15.05 129.08,15.44 129.08,17.08 129.11,17.14 129.12,17.21 129.5,17.59 129.5,20.1 129.91,20.51 131.5,20.51
1.35V_B+ on BOTTOM (solid shape): 131.86,17.32 131.86,15.25 131.1,14.49 128.82,14.49 128.69,14.62 128.69,17.31 129.11,17.74 131.45,17.74
+0.675VS on TOP (solid shape): 173.53,34.87 173.53,33.4 173.4,33.27 172.52,33.27 172.24,33.55 172.24,34.86 172.3,34.92 173.48,34.92
+0.675VS on TOP (solid shape): 173.69,26.5 173.69,25.07 173.64,25.02 172.61,25.02 172.52,25.11 172.52,26.43 172.63,26.54 173.65,26.54
+0.675VS on TOP (solid shape): 247.27,32.88 247.27,26.59 246.99,26.31 246.33,26.31 246.24,26.4 246.24,27.91 245.58,28.58 245.58,29.27 246.37,30.06 246.37,32.96 246.56,33.15 247,33.15
+0.675VS on BOTTOM (solid shape): 172.68,34.78 172.68,28.92 173,28.6 173,25.09 172.77,24.86 172.23,24.86 172.01,25.09 172.01,27.99 171.12,28.88 171.12,31.95 171.7,32.53 171.7,35.25 171.78,35.32 172.13,35.32
+0.675VS on BOTTOM (solid shape): 247.36,32.85 247.36,27.84 247.19,27.67 246.01,27.67 245.56,28.13 245.56,32.04 245.59,32.05 245.78,32.16 245.86,32.36 245.86,32.38 246.7,33.21 247,33.21
+0.675VS on BOTTOM (solid shape): 132.68,30.26 132.68,27.96 132.66,27.95 132.66,26.1 132.67,26.04 132.68,25.97 132.68,25.01 133.34,24.35 133.34,20.71 133.05,20.42 128.92,20.42 128.77,20.57 128.77,20.91 128.8,20.93 129.3,20.93 129.34,20.97 129.34,22.25 129.32,22.26 128.79,22.26 128.78,22.28 128.78,24.1 128.98,24.31 130.01,24.31 130.6,24.89 130.6,30.11 130.93,30.44 132.5,30.44
+0.675VS on IN2 (solid shape): 173.51,27.4 173.51,25.59 173.33,25.41 172.63,25.41 172.45,25.59 172.45,27.37 172.71,27.62 173.29,27.62
+0.675VS on IN2 (solid shape): 246.81,28.68 246.81,27.09 246.58,26.86 245.85,26.86 245.48,27.23 245.48,28.93 245.71,29.16 246.33,29.16
+0.675VS on IN3 (solid shape): 132.95,30.29 132.95,28.48 132.9,28.42 131.84,28.42 131.64,28.63 131.64,30.32 131.79,30.47 132.78,30.47
+0.675VS on IN3 (solid shape): 173.11,26.34 173.11,25.37 173.08,25.33 171.64,25.33 171.18,25.79 171.18,26.28 171.35,26.45 173,26.45
+0.675VSP on TOP (solid shape): 128.31,21.98 128.31,21.26 127.25,20.2 127.25,18.25 127.13,18.14 126.12,18.14 126.1,18.16 126.1,18.26 126.51,18.67 126.51,19.51 125.49,20.53 125.49,21.32 126.1,21.93 126.96,21.93 127.11,22.08 128.2,22.08
+0.675VSP on BOTTOM (solid shape): 128.62,22.64 128.62,22.14 128.64,22.12 129.14,22.12 129.16,22.09 129.16,21.91 129.14,21.89 128.65,21.89 128.63,21.87 128.63,21.35 128.66,21.32 129.14,21.32 129.18,21.28 129.18,21.13 129.13,21.08 128.66,21.08 128.63,21.06 128.63,20.62 128.4,20.39 125.05,20.39 124.88,20.56 124.88,21.65 125.03,21.81 126.25,21.81 127.12,22.68 128.59,22.68
+1.2V_5505SWR on TOP (solid shape): 28.99,33.45 33.34,33.45 33.76,33.03 33.76,32.14 33.57,31.95 31.92,31.95 31.6,32.27 29.82,32.27 29.57,32.02 29.57,30.87 29.31,30.61 28.23,30.61 27.98,30.87 27.98,33.41 28.22,33.65 28.79,33.65
+1.5V_RUN_B+ on TOP (solid shape): 188.05,124.79 188.05,123.53 188.02,123.5 184.83,123.5 184.79,123.45 183.91,123.45 183.68,123.45 183.53,123.6 183.53,124.59 183.75,124.82 184.31,124.82 184.54,125.05 187.79,125.05
+1.5V_RUN_B+ on BOTTOM (solid shape): 188.5,127.98 188.5,127.73 188.96,127.27 188.96,126.09 188.91,126.04 186.87,126.04 186.5,125.67 186.5,123.6 186.32,123.43 183.04,123.43 182.95,123.51 182.95,124.64 183.04,124.72 184.49,124.72 185.2,125.44 185.2,128.13 185.35,128.28 188.2,128.28
+1.5V_VSNS on TOP (solid shape): 190.92,117.87 190.92,114.61 190.23,114.61 189.97,114.35 189.97,109.93 189.77,109.74 189.76,109.73 189.47,109.62 189.18,109.49 189.17,109.49 188.78,109.49 188.46,109.16 187.64,109.16 187.45,109.35 187.45,110.82 187.13,111.13 185.29,111.13 184.85,111.58 184.85,116.81 186.28,118.25 190.54,118.25
+1.5V_VSNS on BOTTOM (solid shape): 192.78,118.44 192.78,115.16 192.76,115.14 192.76,113.61 192.57,113.42 191.05,113.42 190.16,112.53 190.16,109.29 189.97,109.1 187.89,109.1 187.51,109.48 187.51,112.22 186.43,113.3 186.43,118.44 186.69,118.69 192.53,118.69
+1.05VM_VCCASW on TOP (solid shape): 268.47,31 268.47,30.43 268.15,30.11 268.15,28.27 268.03,28.15 267.14,28.15 267.01,28.27 267.01,28.53 267.33,28.84 267.33,29.61 267.01,29.92 267.01,30.94 267.14,31.07 268.41,31.07
+1.05VM_VCCASW on TOP (solid shape): 272.16,45.22 272.16,44.01 271.91,43.76 268.24,43.76 268.24,44.29 267.81,44.29 267.81,43.74 267.32,43.74 267.19,43.87 267.19,45.34 267.37,45.52 271.86,45.52
+1.05VM_VCCASW on IN3 (solid shape): outline of 1199 points within 266.95,28.07 274,44.82
+1.05VM_VCCSUS1 on IN4 (solid shape): outline of 359 points within 266.66,21.16 269.02,26.89
+1.05VM_VCCSUS2 on TOP (solid shape): 267.96,41.1 267.96,39.12 267.9,39.02 267.79,39.05 267.23,38.81 267.79,38.57 267.9,38.59 267.96,38.5 267.96,38.11 267.71,37.85 267.07,37.85 266.76,38.17 266.76,41.1 266.88,41.23 267.84,41.23
+1.5VS on TOP (solid shape): 34.03,103.26 34.03,101.54 33.97,101.48 33.15,101.48 32.45,102.17 32.45,103.1 32.68,103.32 33.97,103.32
+1.5VS on TOP (solid shape): 256.82,52.22 256.82,48.8 256.85,48.76 256.85,46.82 256.41,46.37 255.55,46.37 251.28,42.11 251.28,39.01 251.61,38.69 252.62,38.69 252.71,38.59 252.71,37.23 252.67,37.19 251.77,37.19 251.49,36.92 251.03,36.92 249.69,38.26 249.69,43.1 249.94,43.35 251.22,43.35 251.25,43.38 251.3,43.38 251.3,43.43 251.31,43.44 251.31,44.3 256.17,49.16 256.17,49.51 256.17,49.51 256.17,50.33 256.17,50.33 256.17,51.93 255.99,52.11 255.99,52.33 256.12,52.46 256.58,52.46
+1.5VS on IN1 (solid shape): 256.51,52.35 256.51,48.72 256.32,48.53 255.97,48.53 255.73,48.76 255.73,52.31 255.91,52.49 256.37,52.49
+1.5VS on IN1 (solid shape): outline of 373 points within 24.6,95.83 33.85,103.73
+1.5VS on IN2 (solid shape): 34.16,101.89 34.16,100.95 33.76,100.54 33.3,100.54 32.31,101.53 32.31,102.81 32.5,103 33.04,103
+1.5VS on IN2 (solid shape): 256.72,53.05 256.72,51.49 256.49,51.26 255.27,51.26 255.11,51.42 255.11,52.96 255.4,53.25 256.52,53.25
+1.5VS on IN2 (solid shape): outline of 244 points within 69.01,38.7 91.06,40.88
+1.5VS_G9141 on TOP (solid shape): 256.07,51.83 256.07,49.21 251.21,44.35 251.21,44.32 251.18,44.29 251.18,43.54 251.15,43.5 250.89,43.5 250.89,44.04 250.45,44.04 250.45,43.5 249.86,43.5 249.7,43.66 249.7,45.54 253.53,49.38 255.13,49.38 255.29,49.54 255.29,50.62 255.12,50.79 255.12,51.98 255.25,52.11 255.8,52.11
+1.5VS_G9141 on BOTTOM (solid shape): 256.57,51.5 256.57,49.63 256.09,49.16 256.02,49.1 255.96,49.03 255.53,48.6 255.2,48.6 254.98,48.82 254.98,49.18 255.64,49.83 255.64,49.85 255.78,49.99 255.78,51.51 255.91,51.64 256.43,51.64
+1.05VS_VCCCORE on TOP (solid shape): 265.89,32.91 265.89,31.94 265.93,31.89 267.46,31.89 267.65,31.7 267.65,31.32 267.52,31.2 266.38,31.2 266.23,31.05 266.23,29.92 266.1,29.8 264.84,29.8 264.71,29.67 264.71,28.65 264.92,28.44 264.92,28.34 264.72,28.15 264.47,28.15 264.37,28.25 264.37,28.9 264.17,29.1 263.5,29.1 263.26,29.34 263.26,30.69 263.78,30.69 263.78,31.08 263.26,31.08 263.26,31.86 263.41,32.01 264.54,32.01 265.46,32.93 265.51,32.96 265.56,33.01 265.79,33.01
+1.05VS_VCCCORE on BOTTOM (solid shape): 266.04,32.81 266.05,32.8 266.11,32.68 266.23,32.61 266.24,32.61 266.45,32.4 267,32.4 267.23,32.18 267.23,31.95 265.94,30.66 265.94,29.66 265.45,29.17 265.45,29.04 265.1,28.68 265.02,28.62 264.93,28.45 264.92,28.37 264.92,28.35 264.77,28.19 264.77,28.18 264.74,28.16 264.53,28.16 264.13,28.56 264.13,31.52 264.45,31.83 264.49,31.87 264.53,31.91 265.35,32.74 265.35,32.87 265.38,32.9 265.5,32.95 265.59,33.04 265.81,33.04
+1.05VS_VCCCORE on IN3 (solid shape): 266.37,32.52 266.88,32.52 267.1,32.3 267.1,31.93 266.85,31.68 266.85,31.49 266,30.64 266,29.49 265.23,28.72 265.21,28.72 265.08,28.68 264.98,28.58 264.18,28.58 264.1,28.66 264.1,31.4 264.94,32.23 264.94,32.38 265.57,33.01 265.87,33.01
+1.5VSDGPU on TOP (solid shape): 227.43,110.06 227.43,109.87 227.44,109.86 227.44,107.21 226.72,106.49 226.72,105.84 226.64,105.75 226.15,105.75 226.04,105.87 226.04,106.44 226.15,106.53 226.21,106.66 226.22,106.67 226.32,106.77 226.32,109.9 226.16,110.06 226.16,110.44 226.29,110.57 226.92,110.57
+1.5VSDGPU on TOP (solid shape): 213.57,100.08 213.8,99.99 214.03,100.08 215.2,100.08 215.37,99.97 215.57,99.97 215.77,99.77 215.77,98.75 215.71,98.69 214.76,98.69 214.69,98.75 214.69,99.13 214.56,99.26 213.68,99.26 213.49,99.07 213.49,98.5 212.34,98.5 212.22,98.62 210.06,98.62 209.36,99.32 209.36,99.58 209.48,99.7 211.83,99.7 212.03,99.9 212.32,99.9 212.5,100.08
+1.5VSDGPU on TOP (solid shape): 196.15,110.58 196.15,109.2 195.74,108.8 194.45,108.8 193.88,109.23 193.26,109.57 193.25,109.57 193.21,109.61 193.15,109.61 193.14,109.62 192.41,109.86 191.66,109.97 191.64,109.97 191.62,109.99 190.29,109.99 190.16,110.12 190.16,111.67 190.59,111.67 190.67,111.75 190.67,112.6 190.16,112.6 190.16,112.89 190.71,112.89 190.71,113.65 190.16,113.65 190.16,114.16 190.18,114.18 192.55,114.18
+1.5VSDGPU on TOP (solid shape): 199.62,128.22 199.62,126.44 199.05,125.87 199.05,125.55 198.92,125.43 198.35,125.43 198.29,125.49 198.29,125.93 198.1,126.12 196.64,126.12 196.51,126.25 196.51,126.5 198.31,126.5 198.31,126.45 198.32,126.39 198.33,126.34 198.36,126.29 198.39,126.25 198.42,126.21 198.46,126.18 198.51,126.15 198.56,126.13 198.61,126.12 198.67,126.12 198.72,126.12 198.77,126.13 198.82,126.15 198.87,126.18 198.91,126.21 198.94,126.25 198.97,126.29 199,126.34 199.01,126.39 199.02,126.45 199.02,126.5 199.01,126.55 199,126.6 198.97,126.65 198.94,126.69 198.91,126.73 198.87,126.77 198.82,126.79 198.77,126.81 198.72,126.82 198.67,126.83 198.61,126.82 198.56,126.81 198.51,126.79 198.46,126.77 198.42,126.73 198.39,126.69 198.36,126.65 198.33,126.6 198.32,126.55 198.31,126.5 196.51,126.5 196.51,128.16 196.7,128.35 199.49,128.35
+1.5VSDGPU on TOP (solid shape): outline of 184 points within 220.22,83.32 224.09,90.5
+1.05VSDGPU on TOP (solid shape): outline of 212 points within 199.83,71.83 210.17,83.35
+1.5VSDGPU on TOP (solid shape): outline of 500 points within 217.6,98.96 221.91,104.01
+1.05VSDGPU on TOP (solid shape): outline of 587 points within 199.63,88.4 210.88,106.59
+1.5VSDGPU on BOTTOM (solid shape): 194.13,112.11 196.26,112.11 197.24,111.13 197.24,109.2 197.01,108.97 192.8,108.97 192.79,108.98 190.67,108.98 190.29,109.35 190.29,109.91 190.84,109.91 190.84,110.61 190.29,110.61 190.29,111.11 190.84,111.11 190.84,111.81 190.29,111.81 190.29,112.41 190.98,113.11 193.14,113.11
+1.05VSDGPU on BOTTOM (solid shape): 207.4,72.52 207.4,67.8 207.1,67.5 204.46,67.5 204.18,67.22 204.18,66.2 204.33,66.05 205.98,66.05 206.4,65.63 206.4,62.05 205.5,61.15 200.65,61.15 200.65,63.14 199.88,63.9 199.88,64.14 198.94,65.08 198.94,68.3 204.3,68.3 204.3,68.24 204.31,68.19 204.33,68.14 204.35,68.09 204.38,68.05 204.42,68.01 204.46,67.98 204.5,67.95 204.55,67.93 204.61,67.92 204.66,67.91 204.71,67.92 204.76,67.93 204.81,67.95 204.86,67.98 204.9,68.01 204.94,68.05 204.97,68.09 204.99,68.14 205.01,68.19 205.01,68.24 205.01,68.3 205.01,68.35 204.99,68.4 204.97,68.45 204.94,68.49 204.9,68.53 204.86,68.56 204.81,68.59 204.76,68.61 204.71,68.62 204.66,68.63 204.61,68.62 204.55,68.61 204.5,68.59 204.46,68.56 204.42,68.53 204.38,68.49 204.35,68.45 204.33,68.4 204.31,68.35 204.3,68.3 198.94,68.3 198.94,73.79 199.71,74.56 205.37,74.56
+1.5VSDGPU on BOTTOM (solid shape): 209.49,99.91 209.83,99.91 210.01,100.09 210.17,100.09 210.33,99.93 210.68,99.93 210.84,100.09 211.79,100.09 211.94,99.94 212.34,99.94 212.49,100.09 212.68,100.09 212.87,99.9 213.12,99.9 213.32,100.09 213.56,100.09 213.8,99.99 214.05,100.09 214.27,100.09 214.46,99.9 214.71,99.9 214.9,100.09 215.16,100.09 215.35,99.9 215.66,99.9 215.86,100.09 215.94,100.09 216.46,99.57 216.81,99.57 216.82,99.58 216.94,99.58 217.46,100.09 217.63,100.09 217.79,99.93 218.11,99.93 218.27,100.09 218.56,100.09 218.56,100.09 218.6,100.05 218.65,100.02 218.87,99.97 219.08,100.07 219.09,100.08 219.12,100.09 219.28,100.09 219.41,99.96 219.79,99.96 219.92,100.09 220.15,100.09 220.16,100.07 220.2,100.03 220.31,99.93 220.61,99.93 220.77,100.09 221.82,100.09 221.89,100.03 221.89,99.52 221.26,98.88 209,98.88 208.11,99.77 208.11,99.96 208.24,100.09 209.3,100.09
+1.05VSDGPU on BOTTOM (solid shape): outline of 330 points within 203.86,87.45 210.36,101.38
+1.05VSDGPU on IN1 (solid shape): outline of 3938 points within 198.79,81.72 214.41,102.86
+1.05VSDGPU on IN3 (solid shape): outline of 419 points within 194.55,72.68 204.53,86.98
+1.5VSDGPU on IN3 (solid shape): outline of 31900 points within 191.07,75.37 254.52,128.05
+1.35V on TOP (solid shape): outline of 16873 points within 130.81,18.77 231.71,68.71
+1.35V on BOTTOM (solid shape): 166.69,67.57 166.69,62.36 166.3,61.98 163.38,61.98 163,62.36 163,65.79 163.51,66.3 163.51,67.36 163.51,67.41 163.51,67.45 163.51,67.89 163.96,68.33 165.92,68.33
+1.35V on BOTTOM (solid shape): outline of 140 points within 133.54,20.03 148.35,24.93
+1.35V_CPU_VDDQ on TOP (solid shape): outline of 7070 points within 150.56,68.84 177.16,83.26
+1.35V_CPU_VDDQ on BOTTOM (solid shape): 172.37,70.96 172.5,70.77 172.72,70.69 172.97,70.69 173.1,70.56 173.1,70.11 173.33,69.88 174.01,69.88 174.12,69.77 174.12,62.68 173.99,62.56 170.69,62.56 170.37,62.87 170.37,70.49 170.88,71 172.36,71
+1.35V_CPU_VDDQ on IN3 (solid shape): 153.68,77.08 153.68,76.54 153.28,76.13 153.23,76.14 153.17,76.13 153.12,76.12 153.07,76.1 153.03,76.08 152.99,76.04 152.95,76 152.93,75.96 152.91,75.91 152.89,75.86 152.89,75.8 152.89,75.75 152.79,75.65 152.06,75.65 151.93,75.78 151.93,75.83 151.92,75.88 151.9,75.93 151.88,75.98 151.85,76.02 151.82,76.05 151.78,76.09 151.75,76.1 151.75,76.53 152.08,76.53 152.08,76.48 152.09,76.43 152.1,76.38 152.13,76.33 152.16,76.29 152.19,76.25 152.24,76.22 152.28,76.2 152.33,76.18 152.38,76.18 152.44,76.18 152.49,76.18 152.54,76.2 152.58,76.22 152.62,76.25 152.66,76.29 152.69,76.33 152.72,76.38 152.73,76.43 152.74,76.48 152.74,76.53 152.73,76.58 152.72,76.63 152.69,76.68 152.66,76.72 152.62,76.76 152.58,76.79 152.54,76.81 152.49,76.83 152.44,76.84 152.38,76.84 152.33,76.83 152.28,76.81 152.24,76.79 152.19,76.76 152.16,76.72 152.13,76.68 152.1,76.63 152.09,76.58 152.08,76.53 151.75,76.53 151.75,76.57 152.49,77.3 153.46,77.3
+1.35V_CPU_VDDQ on IN4 (solid shape): outline of 2691 points within 154.34,76.31 172.81,82.13
+1.35V_MEN_P on TOP (solid shape): 142.08,17.78 142.08,11.16 141.85,10.93 138.29,10.93 138.09,11.14 138.09,17.63 138.44,17.98 141.87,17.98
+1.35V_MEN_P on TOP (solid shape): 129.3,20.2 129.3,18.91 129.23,18.84 128.98,18.84 128.96,18.86 128.96,19.4 128.93,19.43 128.5,19.43 128.47,19.4 128.47,18.89 128.45,18.86 128.19,18.86 128.19,18.87 127.66,18.87 127.47,19.05 127.47,20.15 127.65,20.33 129.16,20.33
+1.35V_MEN_P on BOTTOM (solid shape): outline of 144 points within 138.09,10.91 144.84,19.85
+3.3V_RUN_VDD33 on TOP (solid shape): 218.69,83.83 222.06,83.83 222.38,83.51 222.38,83.32 222.63,83.07 224.28,83.07 224.34,83 224.34,82.37 224.29,82.32 222.77,82.32 222.51,82.53 222.19,82.43 218.25,82.43 217.8,82.88 217.8,83.89 217.87,83.95 218.57,83.95
+3.3V_RUN_VDD33 on BOTTOM (solid shape): 223.82,83.77 223.82,83.58 223.7,83.46 222.4,83.46 222.22,83.28 222.01,83.28 221.84,83.44 221.54,83.44 221.37,83.28 221.23,83.28 220.81,83.7 220.81,83.71 220.62,83.9 220.62,84.66 220.77,84.81 221.4,84.81 221.86,85.27 222.33,85.27
+3V_MSATA on TOP (solid shape): 280.67,41.41 281.14,40.94 281.15,40.94 281.35,40.74 282.47,40.74 282.62,40.58 282.62,39.58 283.78,38.43 283.78,38.04 283.6,37.87 282.38,37.87 280.21,40.04 280.02,40.04 279.76,40.29 279.76,40.64 279.78,40.66 280.31,40.66 280.34,40.68 280.34,41.11 280.29,41.16 279.82,41.16 279.77,41.2 279.77,41.4 279.81,41.44 280.65,41.44
+3V_MSATA on BOTTOM (solid shape): 282.25,41 282.25,39.59 282.11,39.45 281.27,39.45 280.91,39.81 280.25,39.81 279.69,40.37 279.69,40.42 280.53,41.26 282,41.26
+3V_MSATA on BOTTOM (solid shape): 280.88,34.11 282.11,34.11 282.27,33.94 282.27,32.79 282.17,32.69 280.86,32.69 280.4,33.15 280.39,33.16 280.36,33.23 280.31,33.29 280.11,33.49 280.11,34.26 280.21,34.36 280.63,34.36
+3V_MSATA on IN2 (solid shape): 282.3,15.29 283.65,15.29 283.78,15.16 283.78,14.23 283.58,14.03 281.93,14.03 281.92,14.03 281.76,14.07 281.6,14.03 281.59,14.03 280.11,14.03 279.91,14.23 279.91,15.21 280.18,15.49 282.1,15.49
+3V_MSATA on IN2 (solid shape): outline of 409 points within 279.91,26.09 283.78,40.07
+3V_NFC on BOTTOM (solid shape): 124.6,21.27 124.6,20.52 124.45,20.37 122.83,20.37 122.5,20.03 122.5,18.37 122.44,18.31 121.69,18.31 121.59,18.42 121.59,21 121.94,21.35 124.52,21.35
+3V_PCH on TOP (solid shape): 276.19,30.3 276.19,29.54 275.69,29.04 275.69,27.13 275.44,26.87 274.87,26.87 274.81,26.93 274.81,28.67 274.81,29.83 275.47,30.49 275.99,30.49
+3V_PCH on TOP (solid shape): 273.57,16.11 273.57,15.6 273.49,15.53 272.41,15.53 272.23,15.34 272.23,15.09 272.03,14.9 271.12,14.9 270.91,14.98 270.71,14.9 270.35,14.9 270.28,14.93 270.22,14.94 270.2,14.94 270.13,15.02 270.13,16.05 270.28,16.2 273.48,16.2
+3V_PCH on TOP (solid shape): outline of 89 points within 276.77,13.95 279.64,16.49
+3V_PCH on TOP (solid shape): outline of 109 points within 269.49,9.2 275.52,12.52
+3V_PCH on TOP (solid shape): outline of 128 points within 260.92,13.23 267.47,16.9
+3V_PCH on BOTTOM (solid shape): 242.89,15.73 242.89,15.04 242.78,14.94 242.45,14.94 242.02,15.37 239.41,15.37 239.28,15.5 239.28,16.09 239.33,16.14 242.48,16.14
+3V_PCH on BOTTOM (solid shape): 226.03,16.44 226.03,15.36 225.85,15.17 225.24,15.17 225.18,15.23 225.18,15.74 225.15,15.77 224.72,15.77 224.67,15.72 224.67,15.21 224.64,15.18 224.33,15.18 224.19,15.32 224.19,15.6 224.2,15.61 224.24,15.78 224.2,15.95 224.19,15.96 224.19,16.35 224.37,16.53 225.94,16.53
+3V_PCH on BOTTOM (solid shape): 265.63,17.04 268.85,17.04 269.33,16.57 269.5,16.57 269.69,16.49 269.88,16.57 271.38,16.57 271.59,16.36 271.59,15.73 272.88,14.43 273.05,14.33 273.26,14.31 273.28,14.32 273.94,13.66 273.94,11.18 273.82,11.06 272.4,11.06 272.09,11.37 272.09,13.54 270.75,14.87 267.44,14.87 267.02,15.29 264.09,15.29 264.02,15.23 260.41,15.23 260.39,15.25 260.39,15.87 260.4,15.87 263.84,15.87 264.03,16.07 264.03,16.94 263.85,17.12 263.32,17.12 263.3,17.14 263.3,17.66 265.02,17.66
+3V_PCH on IN1 (solid shape): outline of 140 points within 275.3,29.93 276.89,33.71
+3V_PCH_APL on BOTTOM (solid shape): 225.02,15.57 225.02,15.03 225.03,15.01 225.75,15.01 225.89,14.87 225.89,13.44 225.55,13.1 223.38,13.1 222.16,14.32 222.16,15.46 222.21,15.51 223.55,15.51 223.63,15.43 223.63,15.18 223.81,14.99 224.79,14.99 224.84,15.04 224.84,15.56 224.86,15.58 225,15.58
+3V_PS8723 on BOTTOM (solid shape): outline of 93 points within 25.12,60.08 30.71,64.99
+3V_VCCPSPI on TOP (solid shape): 264.53,16.06 264.53,15.08 264.43,14.98 263.35,14.98 263.16,15.17 263.16,16.1 263.27,16.21 264.37,16.21
+3VALW on TOP (solid shape): outline of 566 points within 142.49,82.92 150.44,85.06
+3VALW on BOTTOM (solid shape): 35.75,27.69 35.75,25.53 35.62,25.41 34.73,25.41 34.73,26.04 32.7,26.04 32.7,25.41 32.19,25.41 32.19,27.57 32.45,27.82 35.62,27.82
+3VALW on BOTTOM (solid shape): 35.56,43.19 35.56,41.66 35.05,41.16 32.89,41.16 32.76,41.28 32.76,41.98 33.02,42.24 33.02,43.12 33.15,43.25 35.49,43.25
+3VALW on BOTTOM (solid shape): 261,9.04 260.94,8.98 259.65,8.98 259.59,9.04 259.59,10.27 259.66,10.47 259.6,10.67 259.59,10.69 259.59,10.78 261,10.78
+3VALW on BOTTOM (solid shape): 193.68,12.33 193.86,12.28 194.05,12.33 211.82,12.33 211.84,12.31 211.87,11.92 211.95,11.53 211.95,11.52 211.95,11.01 211.71,10.77 193.11,10.77 192.75,11.13 192.75,12.02 193.03,12.31 193.07,12.33
+3VALW on BOTTOM (solid shape): 219.24,16.42 220.99,16.42 221.88,15.53 221.88,14.44 222.29,14.03 222.29,11.39 222.13,11.23 221.22,11.23 221.02,11.44 221.02,13.7 220.85,13.87 220.85,13.88 220.84,13.88 220.78,13.94 219.06,13.94 218.25,15.13 217.05,15.93 217.04,15.93 216.83,16.14 216.83,17.28 217.12,17.58 218.08,17.58
+3VALW on BOTTOM (solid shape): 26.59,64.97 26.59,62.61 26.16,62.18 23.89,62.18 23.78,62.29 23.78,62.73 23.88,62.83 25.11,62.83 25.11,62.78 25.11,62.72 25.13,62.67 25.15,62.62 25.18,62.58 25.22,62.54 25.26,62.51 25.31,62.48 25.36,62.46 25.41,62.45 25.46,62.45 25.52,62.45 25.57,62.46 25.62,62.48 25.66,62.51 25.7,62.54 25.74,62.58 25.77,62.62 25.79,62.67 25.81,62.72 25.82,62.78 25.82,62.83 25.81,62.88 25.79,62.93 25.77,62.98 25.74,63.02 25.7,63.06 25.66,63.1 25.62,63.12 25.57,63.14 25.52,63.16 25.46,63.16 25.41,63.16 25.36,63.14 25.31,63.12 25.26,63.1 25.22,63.06 25.18,63.02 25.15,62.98 25.13,62.93 25.11,62.88 25.11,62.83 23.88,62.83 24.05,62.98 24.19,63.09 24.33,63.21 24.46,63.34 24.59,63.47 24.71,63.61 24.82,63.75 24.88,63.83 25.45,64.4 25.45,65.03 25.53,65.1 26.46,65.1
+3VALW on BOTTOM (solid shape): outline of 83 points within 154.85,10.78 165.06,13.09
+3VALW on IN1 (solid shape): outline of 220 points within 146.32,10.81 155.03,16.92
+3VALW on IN1 (solid shape): outline of 460 points within 219.7,11.36 250.8,16.95
+3VALW on IN2 (solid shape): outline of 9308 points within 32.45,10.8 148.5,28.11
+3VALW on IN3 (solid shape): outline of 133 points within 21.32,52.94 25.08,63.91
+3VALW on IN3 (solid shape): outline of 467 points within 248.09,9.22 261.61,13.19
+3VALW on IN4 (solid shape): 272.94,23.91 272.94,23.85 272.92,23.83 272.78,23.6 272.86,23.35 272.89,23.28 272.86,23.21 272.77,22.95 272.9,22.71 272.94,22.64 272.91,22.57 273.2,22.02 273.36,22.61 273.32,22.68 273.34,22.76 273.37,22.79 273.4,22.85 274.19,22.85 274.27,22.82 274.3,22.74 274.55,22.48 274.8,22.74 274.8,22.77 274.88,22.85 275.3,22.85 275.37,22.82 275.4,22.74 275.55,22.44 275.88,22.42 275.91,22.44 276.06,22.29 276.06,21.91 275.91,21.76 275.88,21.77 275.55,21.69 275.47,21.35 275.48,21.32 275.38,21.23 274.27,21.23 273.79,21.71 272.79,21.71 272.26,22.23 271.98,22.23 271.73,22.48 271.7,22.56 271.76,22.64 271.93,22.86 271.86,23.14 271.84,23.2 271.87,23.27 271.85,23.73 271.38,23.72 271.27,23.69 271.21,23.79 271.21,24.52 271.31,24.63 272.22,24.63
+3VALW on IN4 (solid shape): outline of 760 points within 20.36,26.27 36.13,53.55
+3VALW on GND3 (solid shape): 155.21,12.73 155.21,11.01 155.05,10.85 153.81,10.85 153.63,11.03 153.63,12.73 153.81,12.91 155.03,12.91
+3VALW_EC on TOP (solid shape): 168.9,24.58 168.9,23.13 168.86,23.09 168.36,23.09 168.18,23.27 168.18,23.87 168.02,24.03 166.53,24.03 166.47,24.08 166.47,24.6 166.53,24.66 168.82,24.66
+3VALW_EC on TOP (solid shape): outline of 147 points within 151.07,13.93 159.95,25.22
+3VALW_EC on BOTTOM (solid shape): outline of 299 points within 162.51,14.31 167.3,25.07
+3VALW_EC on IN1 (solid shape): 167.63,19.37 167.63,18.04 166.93,17.34 166.27,17.34 166.18,17.39 166.18,17.49 165.79,17.94 165.89,17.36 165.94,17.32 165.92,17.27 165.88,17.23 165.83,17.19 165.56,16.91 165.29,16.91 165.06,17.14 165.07,17.2 165.07,17.24 165.02,17.38 164.9,17.49 164.9,17.54 164.92,17.55 164.98,17.75 164.9,17.94 164.9,18.13 164.96,18.19 165.01,18.14 165.01,18.13 165.05,18.05 165.11,17.98 165.5,17.99 165.57,18.37 165.57,18.46 165.65,18.52 165.78,18.52 166.37,19.1 166.46,19.13 166.53,19.07 166.55,19.03 166.58,18.99 166.6,18.92 166.5,18.66 166.57,18.46 166.59,18.39 166.56,18.32 166.5,18.02 166.74,17.82 167.05,17.97 167.02,18.32 167,18.38 167.11,18.65 167.03,18.85 167.01,18.92 167.04,18.98 167.08,19.34 166.75,19.48 166.66,19.5 166.62,19.58 166.62,19.8 166.75,19.93 167.07,19.93
+3VALW_EC on IN3 (solid shape): outline of 103 points within 147.49,15.48 156.87,17.33
+3VALWP on TOP (solid shape): 35.45,21.39 35.45,18.73 35.07,18.35 31.33,18.35 31.1,18.58 31.1,21.45 31.3,21.65 35.19,21.65
+3VALWP on BOTTOM (solid shape): 35.85,24.8 35.85,18.43 35.73,18.3 31.31,18.3 31.03,18.58 31.03,24.43 31.82,25.23 35.42,25.23
+3VLP on IN1 (solid shape): 172.35,18.48 172.35,18.1 172.27,18.02 171.32,18.02 171.17,18.18 170.34,18.18 169.95,18.35 169.67,18.03 169.64,17.97 169.57,17.94 169.14,17.94 169.14,17.99 168.78,18.33 168.43,17.99 168.42,17.94 168.06,17.94 167.23,17.11 167.04,17.03 166.97,16.85 166.9,16.78 166.85,16.78 166.81,16.78 165.84,16.78 165.71,16.9 165.71,16.95 166.02,17.26 166.96,17.26 167.71,18.01 167.71,18.2 168.1,18.6 172.23,18.6
+3VLP on IN2 (solid shape): outline of 628 points within 138.36,26.65 145.12,31.58
+3VS on TOP (solid shape): 170.98,35.24 170.98,32.65 170.86,32.53 170.31,32.53 170.17,32.66 170.17,35.2 170.29,35.32 170.89,35.32
+3VS on TOP (solid shape): 178.07,16.35 178.07,15.74 177.96,15.64 175.85,15.64 175.77,15.72 175.77,16.46 175.78,16.47 177.94,16.47
+3VS on TOP (solid shape): 34.03,96.65 33.91,96.53 33.02,96.53 32.76,96.78 32.76,97.73 32.95,97.92 33.21,97.92 33.53,98.24 34.03,98.24
+3VS on TOP (solid shape): 254.53,14.51 254.53,13.41 254.44,13.31 251.64,13.31 251.32,13.63 251.32,14.34 251.47,14.49 252.78,14.49 252.94,14.64 254.4,14.64
+3VS on TOP (solid shape): 260.72,15.71 260.72,15.04 260.64,14.97 259.47,14.97 259.47,14.97 258.75,14.97 258.53,15.2 258.53,15.76 258.58,15.81 260.62,15.81
+3VS on TOP (solid shape): 214.06,70.15 214.06,67.17 214.05,67.16 214.02,67 214.05,66.84 214.06,66.83 214.06,65.03 213.95,64.91 212.76,64.91 212.58,65.1 212.58,68.86 212.75,69.03 212.75,70.15 212.93,70.33 213.88,70.33
+3VS on TOP (solid shape): 232.85,61.16 232.85,60.02 232.63,59.79 227.8,59.79 227.26,59.25 227.26,58.24 227.2,58.17 225.93,58.17 225.68,58.43 225.68,60.52 225.87,60.71 229.87,60.71 230.25,61.09 230.25,61.6 230.57,61.92 232.09,61.92
+3VS on TOP (solid shape): 258,53.05 258,49.03 257.57,48.6 257.16,48.6 256.92,48.84 256.92,52.27 256.58,52.61 255.9,52.61 255.7,52.41 254.83,52.41 254.75,52.49 254.75,53.02 254.82,53.1 255.42,53.1 255.67,53.34 257.7,53.34
+3VS on TOP (solid shape): 20.3,55.26 20.33,55.19 20.3,55.11 20.21,54.81 20.4,54.56 20.42,54.54 20.42,52.72 19.91,52.21 19.22,52.21 19.09,52.34 19.09,55.26 19.15,55.32 20.23,55.32
+3VS on TOP (solid shape): 270.72,31.98 270.84,31.98 270.92,31.94 270.94,31.86 271.02,31.54 271.34,31.45 271.37,31.45 271.61,31.21 271.83,31.21 272.01,31.03 272.01,30.61 271.92,30.52 271.25,30.52 271.23,30.53 271.13,30.57 271.03,30.57 271,30.57 270.43,31.14 270.43,31.9 270.52,31.99 270.7,31.99
+3VS on TOP (solid shape): 276.27,43.46 277.93,42.84 279.62,42.32 279.62,41 279.64,40.98 280.12,40.98 280.16,40.95 280.16,40.83 280.14,40.81 279.62,40.81 279.6,40.8 279.6,40.28 280.01,39.88 280.01,38.33 279.75,38.07 278.41,38.07 278.35,38.13 278.35,38.74 278.39,38.78 279.02,38.78 279.08,38.84 279.08,39.24 279.09,39.32 279.08,39.4 279.08,39.82 277.36,41.55 274.26,41.55 274.14,41.67 274.14,43.33 274.27,43.46 276.26,43.46
+3VS on TOP (solid shape): 281.21,29.87 281.21,27.42 280.73,26.94 280.14,26.94 279.99,27.09 279.99,27.14 280,27.15 280.03,27.29 280,27.42 279.99,27.43 279.99,27.68 280.3,27.99 280.3,28.13 280.31,28.21 280.3,28.3 280.3,28.62 280.3,28.62 280.32,28.71 280.3,28.8 280.3,28.81 280.3,29.1 280.3,29.11 280.33,29.22 280.3,29.33 280.3,29.34 280.3,29.6 280.3,29.61 280.33,29.71 280.3,29.82 280.3,29.83 280.3,30.01 280.34,30.05 281.04,30.05
+3VS on TOP (solid shape): 253.01,9.85 260.78,9.85 261.15,10.22 262.11,10.22 262.49,9.84 262.49,9.23 262.32,9.05 248.27,9.05 247.81,9.51 247.81,9.71 251.5,9.71 251.5,9.66 251.5,9.61 251.52,9.55 251.54,9.51 251.57,9.46 251.61,9.42 251.65,9.39 251.7,9.36 251.75,9.34 251.8,9.33 251.85,9.33 251.91,9.33 251.96,9.34 252.01,9.36 252.05,9.39 252.09,9.42 252.13,9.46 252.16,9.51 252.18,9.55 252.2,9.61 252.21,9.66 252.21,9.71 252.2,9.76 252.18,9.82 252.16,9.86 252.13,9.91 252.09,9.95 252.05,9.98 252.01,10.01 251.96,10.03 251.91,10.04 251.85,10.04 251.8,10.04 251.75,10.03 251.7,10.01 251.65,9.98 251.61,9.95 251.57,9.91 251.54,9.86 251.52,9.82 251.5,9.76 251.5,9.71 247.81,9.71 247.81,10.18 248.14,10.51 252.35,10.51
+3VS on TOP (solid shape): 33.19,29.03 33.19,28.14 33.06,28.02 31.56,28.02 31.56,28.02 31.44,28.04 31.33,28.02 31.32,28.02 29.35,28.02 29.35,28.04 29.11,28.28 29.11,28.3 28.89,28.6 28.52,28.55 28.49,28.53 28.47,28.54 28.13,28.2 27.49,28.2 27.37,28.07 27.37,26.68 27.24,26.55 25.97,26.55 25.67,26.86 25.67,27.08 24.9,27.08 24.9,27.06 24.75,27.06 24.75,27.08 23.99,27.08 23.99,27.06 23.33,27.06 23.23,27.16 23.23,27.24 23.56,27.57 23.94,27.57 24.14,27.77 24.42,27.77 24.45,27.79 24.88,27.79 24.88,27.82 25.03,27.82 25.03,27.79 25.79,27.79 25.79,27.82 25.81,27.82 25.81,28.3 26.33,28.81 26.66,28.81 26.66,28.83 26.81,28.83 26.81,28.81 27.57,28.81 27.57,28.83 27.63,28.83 28.02,29.22 33,29.22
+3VS on TOP (solid shape): 247.71,38.2 247.71,37.19 247.63,37.1 246.66,37.1 245.43,35.86 245.43,34.63 245.35,34.56 244.72,34.56 244.62,34.66 243.96,34.66 243.9,34.71 243.9,35.35 243.92,35.38 243.95,35.4 244.27,35.66 244.13,36.05 244.08,36.13 244.29,36.51 244.08,36.9 244.13,36.98 244.23,37.08 244.28,37.22 244.28,37.24 244.92,37.87 245.91,37.87 246.34,38.3 247.61,38.3
+3VS on TOP (solid shape): 47.45,43.06 47.62,43.06 47.65,43.01 47.67,42.97 47.7,42.94 47.74,42.91 47.78,42.89 47.83,42.88 47.87,42.87 47.92,42.87 47.96,42.88 48,42.89 48.04,42.92 48.08,42.94 48.11,42.98 48.12,43 56.68,43 57.43,42.25 57.43,41.02 51.14,41.02 50.61,40.48 45.09,40.48 40.94,36.33 37.15,36.33 37.02,36.46 37.02,38.67 40.8,38.67 40.8,38.61 40.81,38.56 40.83,38.51 40.85,38.46 40.88,38.42 40.92,38.38 40.96,38.35 41,38.32 41.05,38.3 41.11,38.29 41.16,38.28 41.21,38.29 41.26,38.3 41.31,38.32 41.36,38.35 41.4,38.38 41.44,38.42 41.47,38.46 41.49,38.51 41.51,38.56 41.52,38.61 41.52,38.67 41.51,38.72 41.49,38.77 41.47,38.82 41.44,38.86 41.4,38.9 41.36,38.94 41.31,38.96 41.26,38.98 41.21,38.99 41.16,39 41.11,38.99 41.05,38.98 41,38.96 40.96,38.94 40.92,38.9 40.88,38.86 40.85,38.82 40.83,38.77 40.81,38.72 40.8,38.67 37.02,38.67 37.02,40.46 37.65,41.09 39.3,41.09 41.79,43.58 46.92,43.58
+3VS on TOP (solid shape): outline of 91 points within 247.96,16.34 254.66,27.7
+3VS on TOP (solid shape): outline of 267 points within 27.56,68.33 33.64,73.11
+3VS on BOTTOM (solid shape): 268.32,47.03 268.32,45.63 268.22,45.52 266.66,45.52 266.59,45.59 266.59,47.12 266.67,47.2 268.15,47.2
+3VS on BOTTOM (solid shape): 254.47,13.67 254.47,13.37 254.21,13.11 254.21,12.25 254.16,12.2 253.26,12.2 253.11,12.35 253.11,13.61 253.27,13.78 254.36,13.78
+3VS on BOTTOM (solid shape): 257.87,52.4 257.87,48.73 257.72,48.57 257.29,48.57 257.17,48.69 257.17,52.33 257.36,52.52 257.74,52.52
+3VS on BOTTOM (solid shape): 280.79,28.59 280.79,26.75 280.35,26.31 280.35,24.26 279.72,23.63 279.02,23.63 279.02,25.6 278.83,25.79 278.83,28.33 278.89,28.39 278.89,29.03 280.35,29.03
+3VS on BOTTOM (solid shape): 23.6,101.49 23.6,100.15 23.28,99.83 21.37,99.83 17.37,95.83 16.93,95.83 16.61,96.15 16.61,97.23 21.18,101.8 23.28,101.8
+3VS on BOTTOM (solid shape): 58.67,41.26 59.85,40.08 59.85,37.85 59.79,37.79 58.71,37.79 58.65,37.85 58.65,38.61 58.33,38.93 56.81,38.93 54.85,40.9 54.85,42.39 55.18,42.72 57.21,42.72
+3VS on BOTTOM (solid shape): 279.86,38.98 279.86,36.66 279.59,36.39 278.06,36.39 277.99,36.45 277.99,37.3 278.12,37.42 278.67,37.42 278.68,37.42 278.81,37.42 278.9,37.51 278.9,39.54 278.96,39.61 279.23,39.61
+3VS on BOTTOM (solid shape): 257.29,17.67 257.29,16.27 257.53,16.03 259.97,16.03 259.99,16.01 259.99,15.39 259.75,15.15 256.08,15.15 255.64,15.6 255.64,16.05 255.65,16.07 255.69,16.21 255.65,16.36 255.64,16.37 255.64,17.75 255.69,17.81 257.15,17.81
+3VS on BOTTOM (solid shape): 34.36,70 34.36,63.22 34.2,63.06 33.44,63.06 33.14,63.36 33.14,64.9 33.04,64.99 33.07,65.03 33.07,65.44 32.68,65.58 32.59,65.6 32.55,65.68 32.55,70.05 32.66,70.16 34.2,70.16
+3VS on BOTTOM (solid shape): 31.58,30.79 31.58,30.51 31.58,30.51 31.03,30.51 31.02,30.5 31.02,30.02 31.03,30.01 31.57,30.01 31.58,30 31.58,29.56 31.87,29.26 31.87,28.2 31.75,28.07 31.24,28.07 30.99,28.33 29.56,28.33 29.46,28.23 29.11,28.23 29.11,28.28 28.75,28.63 28.4,28.28 28.39,28.23 26.94,28.23 26.84,28.34 26.84,29.38 26.95,29.49 28.26,29.49 28.87,30.1 29.22,30.1 29.23,30.11 29.4,30.11 30.16,30.87 31.5,30.87
+3VS on BOTTOM (solid shape): outline of 92 points within 17.6,19.2 21.8,21.99
+3VS on BOTTOM (solid shape): outline of 152 points within 20.92,43.72 39.64,49.54
+3VS on BOTTOM (solid shape): outline of 190 points within 206.11,13.96 209.8,19.29
+3VS on IN1 (solid shape): 269.26,34.55 269.34,34.56 269.61,34.56 270.03,34.14 270.03,32.8 270.18,32.65 270.19,32.64 270.27,32.51 270.39,32.43 270.4,32.43 270.92,31.92 270.92,31.56 270.82,31.46 270.17,31.46 269.34,32.29 269.34,33.61 268.99,33.96 268.99,34.46 269.09,34.56 269.19,34.56
+3VS on IN1 (solid shape): outline of 140 points within 256.86,46.44 268.29,52.76
+3VS on IN1 (solid shape): outline of 653 points within 18.16,94.15 36,111.65
+3VS on IN2 (solid shape): 21.68,23.36 21.68,21.4 21.48,21.2 20.77,21.2 20.59,21.37 20.59,23.3 20.77,23.48 21.55,23.48
+3VS on IN2 (solid shape): outline of 146 points within 266.83,42.74 276.23,47.38
+3VS on IN2 (solid shape): outline of 1432 points within 19.06,26.18 39.05,55.64
+3VS on IN3 (solid shape): 33.33,97.83 33.33,95.51 33.14,95.32 31.36,95.32 31.09,95.58 31.09,97.6 31.45,97.96 33.2,97.96
+3VS on IN3 (solid shape): 34.27,71.15 34.27,68.49 34.03,68.25 32.72,68.25 32.38,68.59 32.38,71.27 32.46,71.35 34.07,71.35
+3VS on IN3 (solid shape): outline of 200 points within 258.41,27 264.88,28.78
+3VS on IN4 (solid shape): outline of 200 points within 262.42,33.2 269.67,34.53
+3VS on IN4 (solid shape): outline of 676 points within 258.41,27.43 270.96,32.18
+3VS on VCC: outline of 98 points within 54.4,9.27 289.83,75.45
+3VS_DELAY on TOP (solid shape): 215.82,69.04 215.82,67.41 215.67,67.25 214.74,67.25 214.42,67.57 214.42,68.75 214.46,68.79 215.14,68.79 215.18,68.84 215.18,69.05 215.38,69.24 215.63,69.24
+3VS_DELAY on TOP (solid shape): 224.41,81.54 224.41,80.91 224.15,80.65 224.15,78.24 224.98,77.41 224.98,75.42 224.97,75.41 224.94,75.26 224.97,75.11 224.99,75.07 224.41,74.49 222.38,74.49 222.31,74.56 222.31,75.15 222.04,75.43 222.04,76.09 222.05,76.1 222.05,77.66 222.23,77.85 222.24,77.85 222.39,78 222.37,78.21 222.37,78.22 222.37,79.58 222.74,79.95 222.74,81.07 223.28,81.61 224.34,81.61
+3VS_DELAY on TOP (solid shape): outline of 351 points within 211.24,70.09 220.64,78.81
+3VS_DELAY on BOTTOM (solid shape): 215.66,71.99 215.66,70.89 216.04,70.52 216.49,70.52 217.99,69.01 217.99,67.55 217.12,66.68 217.12,66.21 217.39,65.94 219.74,65.94 219.75,65.93 219.75,64.26 219.54,64.05 217.71,64.05 217.62,64.15 217.62,64.82 217.51,64.93 216.14,64.93 215.56,65.51 215.56,67.08 214.6,68.04 214.6,68.86 214.65,68.95 214.74,68.96 215.24,69.29 214.74,69.61 214.65,69.62 214.6,69.71 214.6,71.86 214.83,72.08 215.57,72.08
+3VS_DELAY on BOTTOM (solid shape): outline of 103 points within 194.48,60.74 197.87,70.37
+3VS_DELAY on IN2 (solid shape): outline of 416 points within 195.17,64.91 218.16,72.21
+3VS_DELAY on IN3 (solid shape): outline of 876 points within 214.64,64.54 225.09,76.66
+3VS_DP on BOTTOM (solid shape): 11.79,98.88 11.79,92.72 11.66,92.6 10.96,92.6 10.39,93.17 10.39,93.68 9.75,94.31 9.51,94.31 9.5,94.31 9.31,94.35 9.12,94.31 9.11,94.31 8.87,94.31 8.48,93.93 7.91,93.93 7.77,94.07 7.77,94.81 7.85,94.88 9.44,94.88 9.94,95.39 9.94,99.2 10.2,99.45 11.21,99.45
+3VS_MDPR on TOP (solid shape): outline of 184 points within 25.63,73.74 33.44,82.12
+3VS_RD on BOTTOM: 31.74,29.56 31.74,30.17 31.73,30.17 31.18,30.17 31.18,30.17 31.18,30.35 31.18,30.35 31.74,30.35 31.74,30.77 31.78,30.82 32.17,30.82 32.49,30.49 34.14,30.49 34.25,30.39 34.25,29.88 34.38,29.74 35.19,29.74 35.35,29.9 35.35,30.37 35.46,30.48 35.96,30.48 36.07,30.37 36.07,28.98 35.77,28.69 33.03,28.69 32.66,29.06 32.23,29.06
+3VS_TPS on BOTTOM (solid shape): 33.34,47.39 33.35,47.39 33.59,47.15 33.59,45.84 33.96,45.46 33.97,45.46 34.09,45.34 35.49,45.34 35.55,45.27 35.55,44.58 35.44,44.47 32.41,44.47 32.37,44.52 32.37,45.03 32.9,45.03 32.9,45.73 32.37,45.73 32.37,46.23 32.9,46.23 32.9,46.93 32.37,46.93 32.37,47.54 32.43,47.6 33.13,47.6
+5V_CHGUSB_1 on TOP (solid shape): 20.17,61.99 21.71,61.99 21.86,61.84 21.86,60.5 21.66,60.31 17.22,60.31 16.62,60.9 16.62,62.9 16.8,63.08 19.08,63.08
+5V_CHGUSB_1 on BOTTOM (solid shape): 26.76,56.01 26.76,54.59 26,53.83 25.84,53.83 25.77,53.91 25.77,54.97 25.61,55.13 25.61,55.94 25.79,56.12 26.66,56.12
+5V_CHGUSB_1 on BOTTOM (solid shape): 20.58,62.44 21.18,62.28 21.8,62.23 21.82,62.23 21.88,62.17 21.88,60.41 21.76,60.29 21.12,60.29 20.41,61 18.89,61 18.63,61.26 18.63,62.35 18.71,62.44 20.57,62.44
+5V_CHGUSB_1 on IN2 (solid shape): outline of 308 points within 12.99,54.94 26.73,62.62
+5V_CHGUSB_1 on IN3 (solid shape): outline of 95 points within 12.89,59.31 21.88,62.87
+5V_CHGUSB_1 on IN4 (solid shape): outline of 95 points within 12.89,59.31 21.88,62.87
+5V_CHGUSB_1 on VCC: 12.89,57.69 12.89,61.98 22.56,61.98 26.86,57.69 26.86,55.1 26.5,54.74 24.3,54.74 21.35,57.69
+5V_CHGUSB_3 on TOP (solid shape): 20.63,76.71 20.63,76.53 20.56,76.47 20.56,74.75 20.47,74.66 19.42,74.66 19.34,74.73 19.34,76.68 19.46,76.8 20.54,76.8
+5V_CHGUSB_3 on BOTTOM (solid shape): 21.37,77.86 21.37,76.91 22.07,76.21 22.07,75.7 22.33,75.45 22.33,73.86 22.26,73.79 20.98,73.79 20.86,73.91 20.86,73.97 20.89,74.04 20.96,74.07 21.19,74.69 20.58,74.43 20.57,74.39 20.53,74.38 19.65,74.38 19.6,74.43 19.6,77.8 19.72,77.93 21.31,77.93
+5V_CHGUSB_3 on BOTTOM (solid shape): 15.47,81.12 15.47,80.06 15.43,79.98 15.34,79.96 14.32,79.28 15.19,78.43 15.29,78.37 15.27,78.25 15.09,78.07 13.24,78.07 12.88,78.42 12.88,78.96 12.89,78.96 12.89,79.62 12.96,79.72 13.07,79.68 14.02,79.57 14.1,80.52 14.08,80.63 14.17,80.69 14.29,80.69 14.86,81.26 15.33,81.26
+5V_CHGUSB_3 on IN2 (solid shape): outline of 230 points within 13.02,73.72 20.59,79.31
+5V_CHGUSB_3 on IN3 (solid shape): outline of 171 points within 12.91,74.34 20.56,81.16
+5V_CHGUSB_3 on IN4 (solid shape): outline of 99 points within 12.97,77.99 16.71,81.28
+5V_CHGUSB_3 on VCC: 12.89,74.18 12.89,81.79 16.09,81.79 20.89,76.99 20.89,74.41 20.65,74.18
+5VALW on TOP (solid shape): 28.59,51.7 28.59,50.86 28.33,50.6 27.04,50.6 26.66,50.99 26.66,51.7 26.78,51.82 28.46,51.82
+5VALW on TOP (solid shape): 23.89,76.57 23.89,76.46 24,76.35 24,75.37 23.95,75.32 23.11,75.32 22.73,75.7 22.73,76.46 22.59,76.6 22.59,76.72 22.66,76.78 23.68,76.78
+5VALW on TOP (solid shape): 57.47,28.44 57.47,27.76 58.35,26.87 58.35,24.84 58.11,24.6 56.64,24.6 56.64,25.1 55.94,25.1 55.94,24.6 55.44,24.6 55.44,25.1 54.74,25.1 54.74,24.6 53.63,24.6 53.42,24.81 53.42,25.09 52.52,25.99 52.52,28.51 52.97,28.97 56.93,28.97
+5VALW on BOTTOM (solid shape): 23.71,77.17 23.71,76.67 24.01,76.36 24.01,75.47 23.94,75.4 23.07,75.4 23.02,75.45 23.02,76.41 23.07,76.46 23.07,77.2 23.13,77.25 23.63,77.25
+5VALW on BOTTOM (solid shape): 256.63,10.89 256.63,9.07 256.55,8.99 252.97,8.99 252.8,9.16 252.8,10.98 252.86,11.04 256.47,11.04
+5VALW on BOTTOM (solid shape): 26.2,51.67 26.58,51.67 26.71,51.8 27.67,51.8 27.82,51.65 27.82,51.04 27.6,50.81 25.84,50.81 25.77,50.88 25.77,51.77 25.86,51.86 26.01,51.86
+5VALW on BOTTOM (solid shape): 38.93,43.31 39.28,43.31 39.7,42.89 39.7,41.46 39.46,41.22 37.34,41.22 36.96,41.6 36.96,43.25 37.02,43.31 37.63,43.31 38.92,43.31
+5VALW on BOTTOM (solid shape): 57.49,28.41 57.49,27.86 57.78,27.57 58.23,27.57 58.48,27.31 58.48,25.28 58.28,25.08 56.49,25.08 56.49,25.59 55.79,25.59 55.79,25.08 55.29,25.08 55.29,25.59 54.59,25.59 54.59,25.08 52.74,25.08 52.54,25.28 52.54,28.66 52.85,28.97 56.93,28.97
+5VALW on IN2 (solid shape): outline of 488 points within 2.24,12.03 6.5,28
+5VALW on IN4 (solid shape): 48.03,37.66 48.03,36.31 47.79,36.06 45.65,36.06 45.05,36.66 45.05,38.09 45.48,38.52 47.17,38.52
+5VALW on IN4 (solid shape): 41.1,41.91 41.1,41.09 40.44,40.43 37.65,40.43 36,42.08 36,42.6 36.49,43.09 39.92,43.09
+5VALW on IN4 (solid shape): 54.52,30.14 54.52,27.72 54.04,27.23 54.04,26.66 53.95,26.58 52.64,26.58 52.34,26.88 52.34,29.88 52.87,30.41 54.25,30.41
+5VALW on IN4 (solid shape): outline of 737 points within 17.67,50.69 28.44,76.64
+5VALW on VCC: outline of 160 points within 1.27,1.27 256.34,119.23 ; 1 cut-out
+5VALWP on TOP (solid shape): 58.08,24.14 58.08,22.99 57.57,22.49 53.89,22.49 53.51,22.87 53.51,24.24 53.68,24.42 57.8,24.42
+5VALWP on BOTTOM (solid shape): 59.93,23.68 59.93,22.44 60.38,21.99 60.38,20.09 60.24,19.95 57.21,19.95 56.83,19.57 56.83,17.79 56.45,17.41 53.78,17.41 53.51,17.68 53.51,24.78 53.63,24.9 58.71,24.9
+5VS on TOP (solid shape): 28.41,35.16 28.41,34.25 28.31,34.15 26.91,34.15 26.73,34.32 26.73,35.29 26.76,35.31 28.26,35.31
+5VS on TOP (solid shape): 34.66,40.85 34.66,35.11 34.17,34.63 33.16,34.63 32.98,34.81 32.98,38.92 32.75,39.15 32.75,40.83 32.92,40.99 34.52,40.99
+5VS on TOP (solid shape): 182.92,122.12 183.74,122.12 183.81,122.06 183.81,121.62 183.74,121.55 183.11,121.55 182.86,121.3 182.86,120.98 182.66,120.79 182.47,120.79 182.35,120.92 182.35,121.17 182.41,121.23 182.41,122.31 182.47,122.38 182.66,122.38
+5VS on BOTTOM (solid shape): 258.61,10.41 258.61,9.06 258.55,8.99 258.04,8.99 257.97,9.06 257.97,10.41 258.11,10.55 258.48,10.55
+5VS on BOTTOM (solid shape): 52.66,35.99 52.66,35.61 52.68,35.59 52.68,35.38 52.41,35.1 52.41,34.02 51.82,34.02 51.78,34.05 51.78,35.43 51.78,35.43 51.78,35.9 51.97,36.09 52.57,36.09
