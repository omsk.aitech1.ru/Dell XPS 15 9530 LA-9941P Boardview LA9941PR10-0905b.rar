# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NFC_VDD_SIM: length 4.4
  BOTTOM w0.102: JNFC1.10 118.3,20.44 RN8.2 RN9.1 120.86,22.13 v2(120.89,22.13)
NTC: length 2.8
  BOTTOM w0.203: PU700.6 125.2,119.43 125.73,119.96 PR724.2
ODD_DA#: length 9.6
  IN4 w0.089: 277.14,27.57 277.03,27.69 276.36,27.69 275.06,28.98 274.28,28.98 274.07,29.19 v1(273.5,29.19)
  IN4 w0.102: v6(278.09,26.04) 278.19,26.14 278.19,27.03 277.91,27.31 277.4,27.31 277.14,27.57
  GND3 w0.102: v7(278.09,25.61) v6(278.09,26.04)
  BOTTOM w0.089: v1(273.5,29.19) 273.19,28.88 U7.F17
  BOTTOM w0.102: RPH2.2 277.61,26.55 277.43,26.37 277.43,25.92 277.73,25.61 v7(278.09,25.61)
ODD_DETECT#: length 6.8
  IN4 w0.089: 254.47,21.06 255.33,21.92 256.22,21.92 v6(256.6,22.3)
  IN4 w0.102: v6(253.81,20.39) 254.47,21.06
  GND3 w0.089: v6(256.6,22.3) 256.92,22.61 v7(257.49,22.61)
  GND3 w0.102: v7(253.19,20.39) v6(253.81,20.39)
  BOTTOM w0.089: v7(257.49,22.61) 257.82,22.94 U7.BB4
  BOTTOM w0.102: v7(253.19,20.39) v2(253.19,19.41)
ODD_EN#: length 25
  TOP w0.102: v1(268.26,14.33) 267.8,13.88 267.8,13.32 267.66,13.17 RPH9.6
  IN2 w0.089: 273.92,19.66 273.92,20.46 274.29,20.82 274.29,24.97 276.63,27.31 v4(276.85,27.31)
  IN2 w0.102: 273.92,19.66 273.92,16.77 272.67,15.52 272.67,14.31 272.06,13.7 271.61,13.7 270.59,14.71 268.64,14.71 v1(268.26,14.33)
  GND3 w0.089: v4(276.85,27.31) 276.85,27.33 276.36,27.81 v7(276.22,27.81)
  BOTTOM w0.089: v7(276.22,27.81) 274.98,27.81 274.67,28.12 U7.C16
P1:
  vias: v8(67.83,23.81) v9(66.08,16.9) v9(66.33,22.24) v9(66.33,21.09) v9(66.71,16.9) v9(67.12,25.15) v9(67.09,24.4) v9(67.09,23.38) v9(67.09,22.24) v9(67.09,21.09) v9(67.35,16.9) v9(67.86,22.24) v9(67.86,21.09) v9(67.98,16.9) v9(68.62,16.9)
P1_SW: length 29.8
  IN1 w0.254: v1(119.44,85.22) 119.66,85.44 120.22,85.44 120.64,85.86 120.64,95.76 125.25,100.36 125.25,102.26 124.78,102.73 124.39,102.73 v1(124.24,102.88)
  BOTTOM w0.254: v1(119.44,85.22) 119.18,85.48 PL702.2 ; PR742.1 PR741.2 v2(124.75,103.56) 124.75,103.09 124.54,102.88 v1(124.24,102.88)
P2_SW: length 21.3
  IN1 w0.254: v1(124.01,103.51) 123.74,103.24 123.74,99.86 120.05,96.17 119.15,96.17 v1(118.93,95.96)
  BOTTOM w0.254: PR715.1 PR714.2 123.83,107.33 123.38,106.88 v2(123.38,106.38) 123.38,104.08 123.95,103.51 v1(124.01,103.51) ; v1(118.93,95.96) 118.61,96.28 PL701.2
PBTN_OUT#: length 240.8
  TOP w0.089: v1(165.28,15.62) 165.28,15.63 UE1.H4
  TOP w0.102: v1(141.37,108.24) 141.18,108.05 JXDP.41
  IN1 w0.076: v1(141.37,108.24) 140.3,108.24 137.44,105.39 137.44,103.66 137.86,103.25 138.94,103.25 140.65,101.53 140.65,95.96 136.08,91.39 136.08,85.7 136.56,85.22 136.56,65.35 136.09,64.88 136.09,54.78 147.45,43.43 147.45,26.66 148.26,25.84 148.26,23.34 151.13,20.47 154.24,20.47 154.5,20.2 155.18,20.2 155.73,20.76 160.47,20.76 161.53,19.7 161.53,18.91 161.76,18.68 161.76,18 161.61,17.84 161.61,17.03 161.73,16.9 161.73,16.66 162.3,16.09 164.81,16.09 v1(165.28,15.62) 165.45,15.62 165.97,15.1 167.24,15.1 167.41,15.27 168.69,15.27 168.73,15.23 169.68,15.23 169.86,15.05 171.49,15.05 171.6,14.94 173.91,14.94 174.18,14.68 174.18,14.55 174.63,14.1 183.62,14.1 184.62,15.1 192.96,15.1 193.51,14.55 195.51,14.55 195.96,14.1 204.22,14.1 204.78,14.65 204.78,18.84 205.59,19.66 210.88,19.66 v4(211.28,20.06)
  IN4 w0.076: v4(211.28,20.06) 211.28,19.61 211.93,18.96 220.91,18.96 223,16.86 228.32,16.86 228.7,16.48 237.35,16.48 237.95,15.89 242.59,15.89 242.99,15.49 251.89,15.49 252.72,16.32 255.73,16.32 256.57,17.16 261.72,17.16 262.21,17.64 263.58,17.64 264.98,19.04 266.69,19.04 266.69,19.05 267.25,19.05 267.26,19.04 267.59,19.04 267.59,19.05 268.36,19.05 268.58,18.83 270.31,18.83 270.53,19.05 v6(271.08,19.05)
  GND3 w0.089: 271.08,19.06 271.08,19.4 271.4,19.72 v7(271.4,19.95)
  GND3 w0.102: v6(271.08,19.05) 271.08,19.06
  BOTTOM w0.089: U7.K1 271.09,20.57 271.4,20.26 v7(271.4,19.95) 271.4,19.86 T81.1
PBTN_SW#: length 266.9
  TOP w0.102: SW1.1 20.61,110.48 19.23,110.48 19.11,110.36 19.11,108.77 17.99,107.65 17.99,104.83 19.65,103.18 v1(20.43,103.18) ; v3(184.28,21.83) 183.84,22.27 v8(182.99,22.27) 180.1,22.27 179.13,21.3 179.13,15.37 178.43,14.67 DE9.1 177.57,14.42 RE48.2
  GND1 w0.102: v3(184.28,21.83) 184.28,21.88 v4(184.56,22.17)
  IN2 w0.102: v1(20.43,103.18) 22.41,101.2 22.41,94.83 20.38,92.8 20.38,87.99 23.73,84.64 29.21,84.64 32.09,81.76 32.09,72.68 31.41,71.99 31.41,69.81 30.95,69.35 30.36,69.35 30.04,69.02 30.04,68.2 31.25,66.99 31.25,62.13 31.95,61.44 31.95,55.72 39.55,48.12 42,48.12 48.66,41.46 53.79,41.46 55.79,39.45 61.5,39.45 61.91,39.05 66.02,39.05 66.98,38.09 69.45,38.09 70.31,37.23 72.25,37.23 73.2,38.18 74.06,38.18 74.38,37.86 93.1,37.86 95.56,40.32 98.76,40.32 104.14,34.94 167.18,34.94 171.32,30.79 171.32,25.9 172.76,24.46 175.56,24.46 176.98,25.88 177.72,25.88 178.83,24.77 182.6,24.77 184.56,22.81 v4(184.56,22.17)
  BOTTOM w0.102: DE2.2 17.84,102.27 18.76,103.18 v1(20.43,103.18)
PCH_CLK_BIASREF: length 4.3
  BOTTOM w0.089: U7.AN44 261.72,40.62 260.13,42.2
  BOTTOM w0.102: 260.13,42.2 v2(259.97,42.37) 259.9,42.43 RH28.1
PCH_GPIO0: length 10.1
  TOP w0.089: 254.47,23.89 255.81,23.89 256.44,24.52 258.05,24.52 258.35,24.82 259.7,24.82 v1(260.03,25.15)
  TOP w0.102: 254.47,23.89 252.56,23.89 252.41,24.04 252.41,24.7 252.32,24.79 RPH8.5
  BOTTOM w0.089: U7.AT8 260.24,25.15 v1(260.03,25.15)
PCH_GPIO1: length 8.8
  IN4 w0.102: v6(277.94,24.58) 277.55,24.58 276.92,25.22 274.96,25.22 274.2,25.98 v6(273.49,25.98)
  GND3 w0.089: v6(273.49,25.98) 273.4,26.07 273.4,26.09 v7(273.23,26.26)
  GND3 w0.102: v6(277.94,24.58) 278.19,24.84 v7(278.37,24.84)
  BOTTOM w0.089: v7(273.23,26.26) 273.4,26.44 273.4,26.51 273.19,26.73 U7.F13
  BOTTOM w0.102: v7(278.37,24.84) 278.37,24.8 277.91,24.34 277.91,23.52 RH172.1
PCH_GPIO5: length 11.8
  TOP w0.089: v1(276.9,30.97) 276.9,30.88 v2(276.45,30.44)
  IN2 w0.089: v1(276.9,30.97) 276.9,30.19 276.32,29.62 275.02,29.62 273.74,28.33 272.67,28.33 271.94,27.61 270.86,27.61 v1(270.47,27.22)
  BOTTOM w0.089: U7.M15 270.2,27.49 v1(270.47,27.22) ; 277.14,31.22 v1(276.9,30.97)
  BOTTOM w0.102: RH167.2 277.81,32.02 277.81,31.88 277.14,31.22
PCH_GPIO6: length 36.5
  TOP w0.102: RPH8.7 251.52,25.79 251.37,25.64 v3(251.37,25.05) v2(251.37,23.64)
  GND1 w0.102: v3(251.37,25.05) v4(251.83,25.05)
  IN4 w0.089: 254.47,23.32 254.59,23.44 256.35,23.44 257.13,22.66 257.13,21.77 257.94,20.96 259.73,20.96 260.73,21.96 262.36,21.96 263.24,22.84 263.24,26.4 264.15,27.31 264.15,27.75 264.37,27.97 265.42,27.97 266.24,28.79 269.82,28.79 270.8,27.8 271.83,27.8 272.01,27.98 274.67,27.98 275.29,27.36 v6(275.29,27.09)
  IN4 w0.102: 254.47,23.32 254.46,23.31 254.25,23.31 253.06,24.5 253.06,24.68 252.69,25.05 v4(251.83,25.05)
  GND3 w0.089: v6(275.29,27.09) 275.5,27.3 v7(275.66,27.3)
  BOTTOM w0.089: U7.A14 275.13,27.3 v7(275.66,27.3)
PCH_GPIO12: length 17.3
  TOP w0.102: v3(271.28,12.28) 271.06,12.06 RPH7.6
  GND1 w0.102: v3(271.28,12.28) 271.28,13.1 271.37,13.19 v5(271.37,13.2)
  IN1 w0.076: v1(271.54,26.29) 272.24,25.6 272.24,21.92 271.65,21.34 271.65,19.91 272.16,19.4 272.16,19.06
  IN1 w0.102: v5(271.37,13.2) 271.45,13.28 271.45,14.33 273.04,15.91 273.04,16.26 272.16,17.14 272.16,19.06
  BOTTOM w0.102: v1(271.54,26.29) 271.54,26.48 271.39,26.62 U7.K13
PCH_GPIO15: length 10.5
  TOP w0.089: v2(266.77,25.51) 266.6,25.68 v1(266.6,26.11)
  IN1 w0.076: v1(266.6,26.11) 266.23,25.74 266.23,23.58 266.52,23.29 266.52,20.98 265.64,20.09 265.64,19.66
  IN1 w0.102: 265.64,19.66 265.64,19.46 265.39,19.21 v4(265.39,18.53)
  GND3 w0.102: v4(265.39,18.53) 265.28,18.53 v7(265.06,18.31)
  BOTTOM w0.102: v1(266.6,26.11) 266.47,25.98 U7.AB11 ; v7(265.06,18.31) RH158.2
PCH_GPIO16: length 7.6
  BOTTOM w0.089: U7.AN2 261.83,22.05 261.83,21.45 261.55,21.18 261.55,20.42 260.79,19.66
  BOTTOM w0.102: 260.79,19.66 259.88,18.74 259.21,18.74 RH191.2 259.24,17.85 259.24,16.99 RH176.2
PCH_GPIO20: length 10
  TOP w0.102: v2(261.99,17.94) 261.76,17.71 v3(261.16,17.71) 260.58,17.14 RPH25.7
  GND1 w0.102: v4(261.33,18.54) 261.33,17.89 v3(261.16,17.71)
  GND3 w0.102: v7(261.17,19.28) 261.33,19.11 v4(261.33,18.54)
  BOTTOM w0.089: U7.AF3 264.58,22.56 264.51,22.48 264.51,22 264.28,21.77 264.28,21.53 264.51,21.3 264.51,20.73 263.75,19.97 262.92,19.97 262.79,19.84 262.79,19.84 262.61,19.66
  BOTTOM w0.102: 262.61,19.66 262.31,19.35 261.25,19.35 v7(261.17,19.28)
PCH_GPIO21: length 5.8
  BOTTOM w0.089: U7.AT1 260.34,21.47 260.34,20.84
  BOTTOM w0.102: 260.34,20.84 260.34,20.07 259.62,19.35 257.95,19.35 RH12.1
PCH_GPIO24: length 16.4
  TOP w0.089: 267.2,19.66 267.15,19.71 267.15,20.4 266.66,20.89 v2(266.66,21.24) 266.66,22.97 266.42,23.21 266.42,23.57 267,24.15 267,24.59 v1(267.58,25.17)
  TOP w0.102: 267.2,19.66 268.01,18.85 268.2,18.85 268.73,18.32 268.73,14.39 270.06,13.06 RPH7.8
  BOTTOM w0.102: U7.Y10 267.3,25.17 v1(267.58,25.17)
PCH_GPIO28: length 7.5
  TOP w0.089: RH165.2 262.55,20.71 262.55,23.29 263.84,24.58 264.24,24.58 264.48,24.81 v2(264.48,25.29) 264.48,25.46 264.7,25.68 v1(265.01,25.68)
  BOTTOM w0.102: v1(265.01,25.68) 265.31,25.98 U7.AD11
PCH_GPIO36: length 6.5
  BOTTOM w0.089: U7.AT3 260.52,22.1 260.82,21.8 260.82,21.53 260.66,21.37 260.66,20.1 260.22,19.66
  BOTTOM w0.102: RH194.2 257.83,18.76 258.22,19.15 259.71,19.15 260.22,19.66
PCH_GPIO37: length 1.4
  TOP w0.089: v1(262.92,21.08) 263.2,21.36 RH169.2
  BOTTOM w0.089: v1(262.92,21.08) 262.92,21.61 U7.AK1
PCH_GPIO44: length 4.9
  TOP w0.102: v3(266.27,18.96) 266.3,18.93 RPH24.7
  GND1 w0.102: v3(266.27,18.96) 266.1,19.12 v4(266.1,19.44)
  GND3 w0.102: v7(266.51,19.49) 266.15,19.49 v4(266.1,19.44)
  BOTTOM w0.089: 266.68,19.66 266.68,19.66 266.68,22.07 U7.AA2
  BOTTOM w0.102: 266.68,19.66 v7(266.51,19.49)
PCH_GPIO49: length 8.8
  BOTTOM w0.089: 261.08,19.66 261.16,19.74 v2(261.73,19.74) 262.42,19.74 263.3,20.62 263.3,21.74 262.96,22.08 U7.AK3
  BOTTOM w0.102: 261.08,19.66 RH188.2 260.19,17.85 260.19,16.99 RH180.2
PCH_GPIO52: length 6.9
  BOTTOM w0.089: U7.B13 274.74,27 276.51,27 v2(276.67,27.16) 276.88,27.38 276.88,27.57 277.14,27.83
  BOTTOM w0.102: 277.14,27.83 277.33,28.01 278.45,28.01 278.64,27.82 278.64,26.17 278.52,26.05 RPH2.1
PCH_GPIO70: length 7.2
  IN4 w0.102: v6(272.92,25.98) 273.24,25.66 273.94,25.66 275.21,24.39 277.3,24.39 277.62,24.07 v6(278,24.07)
  GND3 w0.089: v7(272.81,26.32) 272.81,26.1 v6(272.92,25.98)
  GND3 w0.102: v6(278,24.07) 278.13,23.95 v7(278.37,23.95)
  BOTTOM w0.089: v7(272.81,26.32) 272.81,26.47 272.59,26.69 U7.G13
PCH_GPIO72: length 14.7
  TOP w0.102: RPH4.5 274.18,16.79 v3(273.79,16.39) 273.79,17.57 v2(273.52,17.84)
  GND1 w0.102: v5(272.68,16.14) 272.93,16.39 273.78,16.39 v3(273.79,16.39)
  IN1 w0.076: 271.96,19.06 271.96,19.32 271.47,19.81 271.47,21.41 272.03,21.97 272.03,23.08 v4(271.62,23.49)
  IN1 w0.102: 271.96,19.06 271.96,16.86 v5(272.68,16.14)
  GND3 w0.089: v4(271.62,23.49) 271.27,23.84 v7(271.27,23.95)
  BOTTOM w0.089: v7(271.27,23.95) 271.03,24.19 U7.K7
PCH_INTVRMEN: length 11.3
  TOP w0.089: 277.14,26.59 v2(276.82,26.59) 276.64,26.59 275.77,25.73 v1(271.46,25.73)
  TOP w0.102: RH16.2 RH13.2 279.36,26.86 277.42,26.86 277.14,26.59
  BOTTOM w0.089: v1(271.46,25.73) 271.71,25.47 272.29,25.47 U7.G10
PCH_JTAG_TCK: length 3.8
  TOP w0.089: v8(265.49,20.1) RH35.1 265.75,21.47 v1(266.1,21.12)
  BOTTOM w0.089: v1(266.1,21.12) 265.91,21.31 265.91,21.79 266.1,21.99 266.1,22 266.11,22 266.11,22.45 U7.AB3
PCH_JTAG_TDI: length 11.8
  BOTTOM w0.089: 264.02,19.66 264.25,19.89 264.81,19.89 265.2,20.28 265.2,21.09 265.08,21.21 265.08,22.05 U7.AE2
  BOTTOM w0.102: v8(260.21,14.44) 260.21,16.19 260.55,16.53 RH20.2 261.14,16.99 261.14,17.85 RH26.1 261.12,18.74 261.78,18.74 261.98,18.95 262.65,18.95 262.86,19.15 263.51,19.15 264.02,19.66
PCH_JTAG_TDO: length 9.2
  BOTTOM w0.089: U7.AD3 265.51,22.45 265.51,22 265.51,22 265.51,21.99 265.7,21.79 265.7,20.86 265.97,20.59 v8(265.97,20.15) 265.97,19.66
  BOTTOM w0.102: RH18.2 263.05,16.99 263.05,17.85 RH24.1 263.03,18.75 263.73,18.75 263.92,18.94 264.44,18.94 264.88,19.39 265.72,19.39 265.97,19.64 265.97,19.66
PCH_JTAG_TMS: length 8.2
  BOTTOM w0.089: U7.AD1 265.4,20.19 264.87,19.66
  BOTTOM w0.102: RH19.2 262.09,16.99 262.09,17.85 RH25.1 262.07,18.74 262.73,18.74 262.94,18.95 263.64,18.95 264.13,19.44 v2(264.44,19.44) 264.65,19.44 264.87,19.66
PCH_PLTRST#: length 65.5
  TOP w0.102: v1(249.57,49.5) 247.13,47.06 247.13,43 v2(246.92,42.79) 246.62,42.49 245.52,42.49 245.34,42.67 UH4.1 ; v3(264.35,10.85) 264.12,10.63 UH5.2 262.61,10.63 262.52,10.54 262.52,10.12 262.66,9.98 UH5.1
  GND1 w0.102: v5(264.35,12.05) v3(264.35,10.85)
  IN1 w0.076: 260.84,42.2 263.34,39.71 264.24,39.71 264.59,39.36 264.59,35.7 264.3,35.42 264.3,34.76 265.74,33.32 265.74,29.73 266.23,29.24 266.23,27.41 266.47,27.17 266.94,27.17 267.13,26.97 267.13,26.11 267.52,25.73 v1(267.58,25.73) 267.03,25.18 267.03,23.65 266.72,23.34 266.72,20.65 266.51,20.43 266.51,19.66
  IN1 w0.102: 260.84,42.2 259.78,43.27 255.33,43.27 249.57,49.03 v1(249.57,49.5) ; 266.51,19.66 266.51,18.94 264.69,17.12 264.69,15.87 264.17,15.34 264.17,12.23 v5(264.35,12.05)
  BOTTOM w0.102: v1(267.58,25.73) 267.34,25.73 U7.Y11
PCH_PWROK_EC: length 146.7
  TOP w0.089: v3(164.19,17.67) 164.19,17.65 163.78,17.25 UE1.E6 ; v1(271.54,24.96) 271.13,24.56 271.13,24.09 T175.1
  TOP w0.102: v1(242.52,17.41) 242.52,17.11 241.23,15.82 240.2,15.82 239.74,15.37 RH193.2 239.74,14.49 239.6,14.35 UH3.1
  GND1 w0.076: v3(164.19,17.67) 163.85,17.67 v4(163.7,17.53)
  IN2 w0.076: 168.78,15.76 168.4,15.76 168.24,15.59 167.65,15.59 167.51,15.73 167.51,16.58 167.2,16.89 165.34,16.89 165.17,16.72 164.06,16.72 163.83,16.95 163.83,17.22 163.7,17.34 v4(163.7,17.53)
  IN2 w0.102: v1(225.54,20.27) 225.23,20.58 200.48,20.58 198.41,18.51 193.33,18.51 192.91,18.1 183,18.1 181.96,17.06 171.58,17.06 170.28,15.76 168.78,15.76
  IN4 w0.089: 265.66,21.75 264.69,20.79 264.51,20.79 263.6,19.87 262.84,19.87 262.63,19.66 ; 265.66,21.75 265.66,23.2 266.6,24.14 v1(266.6,24.29) ; 265.66,21.75 265.91,21.5 267.53,21.5 268.05,20.98 269.18,20.98 269.62,21.42 269.62,23.06 269.16,23.51 269.16,24.28 269.48,24.6 269.79,24.6 269.87,24.52 270.89,24.52 271.33,24.96 v1(271.54,24.96)
  IN4 w0.102: v1(242.52,17.41) 243.51,16.42 250.83,16.42 252.52,18.11 252.99,18.11 253.17,18.29 259.77,18.29 260.71,19.23 262.2,19.23 262.63,19.66
  BOTTOM w0.089: U7.AB7 266.49,24.19 v1(266.6,24.29) ; U7.F10 272.99,25.77 272.18,24.96 v1(271.54,24.96)
  BOTTOM w0.102: v1(225.54,20.27) 228.31,20.27 229.04,19.54 229.04,13.55 229.95,12.64 233.44,12.64 234.17,13.37 234.17,16.95 235.06,17.84 235.06,19.16 235.37,19.46 242.02,19.46 242.81,18.68 242.81,17.7 v1(242.52,17.41)
PCH_RSMRST#: length 131
  TOP w0.089: UE1.D4 163.23,16.16 162.69,15.61 162.69,15.51 162.68,15.5 v3(162.68,15.52) ; 274.19,19.66 273.72,20.12 v1(272.46,20.12)
  TOP w0.102: 274.19,19.66 T177.1 v3(274.51,18.18)
  GND1 w0.089: v3(162.68,15.52) 162.68,15 v4(162.66,14.98)
  GND1 w0.102: v3(274.51,18.18) 274.75,18.18 v4(274.93,18.37)
  IN1 w0.076: v4(209.61,18.32) 209.19,18.74 206.02,18.74 205.69,18.41 205.69,14.28 204.59,13.18 200.66,13.18 200.19,12.71 196.06,12.71 195.19,13.57 184.39,13.57 183.99,13.18 173.69,13.18 173.22,13.65 171.68,13.65 171.53,13.81 170.41,13.81 170.32,13.9 169.66,13.9 169.29,14.27 168.91,14.27 168.75,14.1 168.75,14.09 168.64,13.99 168.16,13.99 167.93,14.22 165.97,14.22 165.73,14.46 165.73,14.74 165.4,15.07 165.07,15.07 164.95,15.2 162.88,15.2 v4(162.66,14.98)
  IN4 w0.076: v4(274.93,18.37) 274.71,18.59 270.72,18.59 270.5,18.38 266.05,18.38 265.81,18.14 264.72,18.14 263.77,17.18 262.4,17.18 262.04,16.83 256.89,16.83 256.05,15.99 252.86,15.99 252.03,15.16 243.23,15.16 242.87,14.8 241.39,14.8 240.77,15.43 236.89,15.43 236.27,14.81 224.3,14.81 220.51,18.6 209.89,18.6 v4(209.61,18.32)
  BOTTOM w0.089: v1(272.46,20.12) 271.59,20.99 271.59,22.03 U7.J2
PCH_RTCRST#: length 46.8
  TOP w0.102: v1(261.5,52.01) 261.59,52.01 262.19,52.61 v8(262.19,53.3)
  IN1 w0.076: v1(261.5,52.01) 261.5,51.86 262.07,51.29 264.27,51.29 270.05,45.51 270.05,44.27 272.66,41.66 275.32,41.66 278.64,38.35 278.64,29.49 278.14,28.99 278.14,28.56 277.69,28.11 276.72,28.11 276.23,27.61 276.23,24.85 v4(276.16,24.79)
  GND3 w0.089: v4(276.16,24.79) 276.16,25.1 v7(276.26,25.2)
  BOTTOM w0.089: v7(276.26,25.2) 276.15,25.09 275.33,25.09 275.24,25.17 274.96,25.17 274.79,25 274.54,25 274.27,25.28 U7.D9
  BOTTOM w0.102: v1(261.5,52.01) CH5.1 261.49,51.11 RH3.2 261.31,49.82 CLRP1.1
PCH_RTCX1: length 7.3
  TOP w0.102: v1(276.73,22.91) 277.65,21.98 RH1.1 277.63,21.7 CH3.1 277.53,20.74 277.53,19.54 277.63,19.44 YH1.1
  BOTTOM w0.089: U7.B5 274.74,23.82 275.41,23.82 275.92,23.31 276.32,23.31 v1(276.73,22.91)
PCH_RTCX2: length 7.6
  TOP w0.089: RH1.2 276.74,22.34 v1(276.74,22.35)
  TOP w0.102: RH1.2 276.76,21.7 CH4.1 276.95,20.65 276.95,19.57 276.82,19.44 YH1.2
  IN4 w0.102: v1(276.74,22.35) 276.71,22.39 276.64,22.39 275.75,23.27 275.09,23.27 v6(274.55,22.73)
  GND3 w0.089: v7(274.12,22.73) v6(274.55,22.73)
  BOTTOM w0.089: U7.B4 274.36,22.97 v7(274.12,22.73)
PCH_SATALED#: length 8.4
  BOTTOM w0.089: 260.51,19.66 261.35,20.51 261.35,21.25 261.64,21.53 261.64,21.78 261.34,22.08 U7.AP3
  BOTTOM w0.102: 260.51,19.66 259.79,18.95 258.63,18.95 258.32,18.63 258.32,17.02 RH14.1
PCH_SMBCLK: length 284.1
  TOP w0.102: UN2.4 225.59,62.5 224.7,61.62 224.7,61.11 223.89,60.29 223.89,50.91 224.83,49.97 230.36,49.97 234.3,46.02 234.3,28.14 234.63,27.81 234.63,24.68 229.64,19.69 229.64,14.07 229.45,13.88 v1(229.45,13.87) 229.67,13.65 229.67,13.14 228.92,12.39 223.47,12.39 219.19,16.67 213.21,16.67 211.73,18.14 211.15,18.14 211.05,18.24 DE6.2 210.18,18.14 210.04,18.14 209.8,18.38 209.8,19.31 209.99,19.5 209.99,21.04 209.42,21.61 209.42,22.14 209.12,22.44 208.64,22.44 208.39,22.19 208.39,21.94 v1(208.21,21.76) ; v3(247.95,17.46) QH2.1 ; JXDP.53 138.7,111.05 138.56,110.9 138.16,110.9 137.05,109.79 137.05,105.73 136.56,105.24 136.56,103.69 136.09,103.23 136.09,96.83 136.56,96.36 136.56,89.06 137.48,88.15 137.79,88.15 v1(137.98,87.96) ; v3(251.27,18.55) RPH14.3
  GND1 w0.102: v3(247.95,17.46) 247.95,17.46 v5(247.95,17.77) ; v5(251.2,18.85) 251.27,18.79 v3(251.27,18.55)
  IN1 w0.102: v1(137.98,87.96) 138.56,87.38 138.56,65.68 138.92,65.31 138.92,62.38 161.1,40.2 168.91,40.2 170.05,39.06 170.05,28.27 170.24,28.07 170.34,28.07 v1(170.66,28.39) ; v1(247.33,17.48) 247.14,17.67 247.14,17.94 247.34,18.14 247.58,18.14 v5(247.95,17.77) 248.46,18.28 250.74,18.28 251.08,18.62 251.08,18.73 v5(251.2,18.85)
  BOTTOM w0.102: JDIMM2.202 246.1,24.95 245.9,24.75 245.9,20.84 247.41,19.34 247.41,18.17 247.14,17.91 247.14,17.67 v1(247.33,17.48) 247.14,17.29 247.14,16.99 246.86,16.71 244.05,16.71 243.24,17.53 243.24,19.14 242.72,19.67 235.28,19.67 234.86,19.24 234.86,17.92 233.97,17.03 233.97,13.46 233.35,12.84 230.12,12.84 229.61,13.35 229.61,13.7 v1(229.45,13.87) ; v1(170.66,28.39) 170.98,28.07 171.33,28.07 171.53,27.87 171.53,27.38 171.6,27.31 JDIMM1.202 171.6,25.16 171.48,25.03 171.48,24.68 171.67,24.49 175.31,24.49 176.66,25.85 182.12,25.85 184.11,23.86 187.39,23.86 187.62,24.09 203.37,24.09 206.11,21.34 208.28,21.34 208.39,21.46 208.39,21.57 v1(208.21,21.76) 208.39,21.94 208.39,22.05 208.25,22.2 JTP.4
PCH_SMBDATA: length 284
  TOP w0.102: v1(208.79,21.76) 208.6,21.95 208.6,22.11 208.72,22.23 209.04,22.23 209.22,22.05 209.22,21.53 209.79,20.95 209.79,19.59 209.6,19.4 209.6,18.3 209.96,17.94 210.18,17.94 DE6.3 211.05,17.84 211.15,17.94 211.65,17.94 213.12,16.47 219.1,16.47 223.38,12.19 229,12.19 229.87,13.05 229.87,13.7 v1(230.03,13.87) 229.84,14.06 229.84,19.6 234.84,24.6 234.84,27.9 234.5,28.23 234.5,46.11 230.44,50.17 224.92,50.17 224.09,51 224.09,60.21 224.79,60.9 226.69,60.9 226.96,61.17 UN2.6 ; JXDP.51 138.7,110.55 138.55,110.69 138.24,110.69 137.25,109.7 137.25,105.65 136.76,105.16 136.76,103.61 136.29,103.14 136.29,96.92 136.76,96.45 136.76,89.14 137.56,88.35 137.79,88.35 v1(137.98,88.54) ; v3(250.77,18.55) RPH14.4
  GND1 w0.102: v3(249.25,18.65) v5(248.84,18.65) ; v3(250.77,18.55) v5(250.77,18.87)
  IN1 w0.102: v1(170.62,27.63) 170.38,27.87 170.16,27.87 169.85,28.18 169.85,38.98 168.82,40 161.01,40 138.72,62.29 138.72,65.22 138.35,65.59 138.35,86.95 137.58,87.73 137.58,88.13 v1(137.98,88.54) ; v5(250.77,18.87) 250.81,18.83 250.81,18.64 250.66,18.48 249.01,18.48 v5(248.84,18.65) 248.81,18.62 248.52,18.62 248.24,18.34 247.25,18.34 246.94,18.02 246.94,17.67 v1(246.75,17.48)
  BOTTOM w0.102: v1(230.03,13.87) 229.82,13.65 229.82,13.43 230.21,13.04 233.26,13.04 233.77,13.55 233.77,17.12 234.66,18.01 234.66,19.33 235.2,19.87 242.8,19.87 243.44,19.23 243.44,17.61 244.14,16.92 246.78,16.92 246.94,17.07 246.94,17.29 v1(246.75,17.48) 246.94,17.67 246.94,17.99 247.2,18.26 247.2,19.25 245.7,20.76 245.7,24.75 245.5,24.95 JDIMM2.200 ; JTP.3 208.75,22.2 208.6,22.04 208.6,21.95 v1(208.79,21.76) 208.6,21.56 208.6,21.37 208.36,21.14 206.03,21.14 203.28,23.89 187.7,23.89 187.47,23.66 184.02,23.66 182.03,25.65 176.75,25.65 175.39,24.29 171.58,24.29 171.27,24.6 171.27,25.01 171,25.28 JDIMM1.200 171,27.18 171.33,27.5 171.33,27.78 171.24,27.87 170.86,27.87 v1(170.62,27.63)
PCH_SMLCLK: length 224.9
  TOP w0.089: UE1.B8 162.03,17.91 v3(161.34,17.91)
  TOP w0.102: v1(221.58,58.61) 222.66,57.52 222.66,50.11 223.51,49.26 230.06,49.26 233.78,45.54 233.78,28.81 233.51,28.54 233.51,25.08 227.49,19.06 v1(227.49,18.81) 227.49,16.14 226.06,14.7 222.68,14.7 220.32,17.06 215.54,17.06 215.15,17.46 215.15,18.46 215.7,19.01 v2(215.92,19.01) QV7.1 ; v1(158.67,18.78) 158.43,18.54 157.93,18.54 RPH19.8
  GND1 w0.076: v3(161.34,17.91) v4(161.34,18.35)
  IN1 w0.102: v4(263.43,11.16) 262.88,10.6 261.19,10.6 260.82,10.97 257.28,10.97 254.62,13.62 254.62,15.49 255.27,16.14 255.27,18.03 252.86,20.43 252.72,20.43 v4(252.1,21.06)
  IN2 w0.102: v4(187.05,16.71) 187.25,16.92 193,16.92 193.19,16.72 198.47,16.72 199.45,17.7 202.26,17.7 203.4,18.83 212.64,18.83 213.37,19.57 223.46,19.57 224.22,18.81 v1(227.49,18.81)
  IN3 w0.102: v4(187.05,16.71) 185.94,15.6 175.5,15.6 174.05,17.05 171.55,17.05 170.55,18.05 170.55,18.78 169.26,20.07 162.67,20.07 161.34,18.74 v4(161.34,18.35) ; v1(213.04,76.59) 212.62,76.59 212.05,76.02 212.05,73.45 214.31,71.19 214.31,67.83 216.72,65.41 216.72,63.76 217.49,63 219.52,63 219.86,62.66 219.86,61.69 219.79,61.62 219.79,60.4 v1(221.58,58.61)
  IN4 w0.076: 160.65,18.61 160.92,18.35 v4(161.34,18.35)
  IN4 w0.102: v1(227.49,18.81) 228.02,19.34 240.79,19.34 241.46,20 245.24,20 246.76,21.51 v6(248.52,21.51) 248.52,21.13 249.15,20.51 249.92,20.51 250.09,20.68 251.6,20.68 251.92,20.99 252.03,20.99 v4(252.1,21.06) ; 160.65,18.61 160.03,19.24 159.13,19.24 v1(158.67,18.78)
  GND3 w0.102: v7(248.52,22.21) v6(248.52,21.51) ; v4(263.43,11.16) 263.7,10.89 v7(263.7,10.65)
  BOTTOM w0.102: JTB1.38 v7(263.7,10.65) ; v1(213.04,76.59) 212.36,75.91 QV21.6
PCH_SMLDATA: length 217.1
  TOP w0.089: UE1.A6 161.62,17.16 161.44,16.99 161.22,16.99 161.1,17.11
  TOP w0.102: 161.1,17.11 160.19,17.11 v2(159.79,16.71) v1(159.25,16.71) ; RPH19.7 158.51,18.04 v1(158.6,18.13) ; v1(222.25,61.35) 222.25,59.95 221.11,58.81 221.11,58.24 222.06,57.28 222.06,50.24 223.24,49.06 229.97,49.06 233.58,45.45 233.58,28.89 233.31,28.62 233.31,25.16 231.89,23.74 230.55,23.74 226.83,20.02 226.83,15.77 225.97,14.9 224.08,14.9 223.43,15.55 223.43,18.35 v1(223.26,18.51) 222.46,17.71 QV7.4
  IN1 w0.102: v4(252.77,21.03) 252.68,20.94 252.68,20.76 252.8,20.64 252.95,20.64 255.47,18.11 255.47,16.05 254.83,15.41 254.83,13.71 257.36,11.17 260.91,11.17 261.28,10.8 262.44,10.8 v4(262.85,11.21) ; v1(159.25,16.71) 159.05,16.91 159.05,17.69 v1(158.6,18.13)
  IN2 w0.102: v1(223.26,18.51) 222.41,19.36 213.49,19.36 211.24,17.11 208.05,17.11 207.66,17.5 199.53,17.5 198.55,16.52 187.43,16.52 187.16,16.25 180.89,16.25 180.49,16.65 171.75,16.65 170.29,15.18 167.61,15.18 167.12,15.67 167.12,16.21 166.76,16.57 165.6,16.57 165.43,16.4 163.31,16.4 162.18,17.52 159.28,17.52 158.67,18.13 v1(158.6,18.13)
  IN4 w0.102: v1(223.26,18.51) 224.29,19.54 240.71,19.54 241.37,20.2 245.16,20.2 246.81,21.86 248.84,21.86 v6(249.82,20.88) 250.58,21.64 252.16,21.64 v4(252.77,21.03)
  GND3 w0.102: v6(249.82,20.88) v7(249.82,20.48) ; v7(263.03,10.63) 263.03,11.03 v4(262.85,11.21)
  BOTTOM w0.102: v1(222.25,61.35) 221.42,60.52 216.82,60.52 214.84,62.5 214.84,67.2 213.97,68.07 213.97,70.25 213.41,70.81 211.33,70.81 211.06,71.08 QV21.3 ; JTB1.40 263.3,10.35 v7(263.03,10.63)
PCH_SPI_CLK: length 13
  TOP w0.102: RPH5.1 244.17,14.31 244.04,14.18 243.7,14.18 243.57,14.31 243.57,16.35 243.44,16.47 243.24,16.47 243.11,16.35 243.11,14.92 242.99,14.79 v2(242.12,14.79) 241.97,14.79 241.85,14.66 241.85,14.32 241.45,13.92 241.45,13.92 241.31,13.79 241.31,12.68 241.55,12.45 v1(242.44,12.45)
  BOTTOM w0.102: v1(242.44,12.45) 242.44,12.57 243.05,13.18 243.05,13.36 242.87,13.53 242.69,13.53 242.32,13.16 UH2.6
PCH_SPI_CLK_R: length 34.5
  TOP w0.102: v3(244.17,18.02) 244.05,17.9 v2(244.05,17.43) 244.05,16.14 244.17,16.02 RPH5.8
  GND1 w0.102: v4(244.17,18.4) v3(244.17,18.02)
  IN4 w0.089: 260.37,21.05 260.9,21.58 262.52,21.58 263.62,22.68 263.62,25.2 v1(264.04,25.61)
  IN4 w0.102: 260.37,21.05 259.89,20.57 254.46,20.57 253.92,20.04 253.62,20.04 253.19,20.47 250.17,20.47 250,20.3 248.77,20.3 248.35,20.72 246.49,20.72 245.57,19.8 241.54,19.8 241.44,19.69 241.44,19.46 241.54,19.36 243.86,19.36 244.17,19.06 v4(244.17,18.4)
  BOTTOM w0.089: U7.AJ11 263.67,25.98 v1(264.04,25.61)
PCH_SPI_CS1#: length 1.2
  TOP w0.089: T7.1 262.64,23.86 v1(262.09,23.86)
  BOTTOM w0.102: v1(262.09,23.86) 262.25,23.86 262.57,24.18 U7.AL7
PCH_SPI_CS#: length 40.9
  IN4 w0.076: v6(250.85,17.45) 250.85,17.45 251.32,17.91 251.32,18.07 251.06,18.34 251.06,18.46 251.14,18.55 251.27,18.55 251.59,18.24 251.7,18.24 251.8,18.34 251.8,18.45 251.31,18.95 251.31,19.07 251.4,19.16 251.52,19.16 252.02,18.67 252.13,18.67 252.25,18.78 252.71,18.78 252.89,18.96 259.49,18.96 261.35,20.82 262.11,20.82 262.62,20.32 263.52,20.32 265.18,21.99 265.18,23.25 265.38,23.45 265.38,23.92 265.46,23.99 265.77,23.99 265.85,24.07 265.85,24.22 265.77,24.3 265.46,24.3 265.38,24.38 265.38,24.53 265.46,24.6 265.92,24.6 266,24.68 266,24.83 265.92,24.91 265.46,24.91 265.38,24.99 265.38,25.14 265.46,25.21 265.91,25.21 265.99,25.29 265.99,25.44 265.91,25.52 265.46,25.52 265.38,25.59 265.38,25.75 265.46,25.82 265.91,25.82 265.99,25.9 265.99,26.05 265.91,26.13 265.46,26.13 265.38,26.2 265.38,26.36 265.48,26.46 265.9,26.46 265.97,26.54 265.97,26.74 265.9,26.82 264.56,26.82 264.46,26.72 264.46,24.5 v1(264.01,24.05)
  GND3 w0.102: v7(250.85,16.99) v6(250.85,17.45)
  BOTTOM w0.089: U7.AJ7 263.87,24.19 v1(264.01,24.05)
  BOTTOM w0.102: UH2.1 RH33.2 250.17,16.26 250.04,16.39 248.42,16.39 248.3,16.52 248.3,16.85 248.44,16.99 v2(250.2,16.99) v7(250.85,16.99)
PCH_SPI_HOLD#: length 10.2
  BOTTOM w0.102: RH40.2 RH41.1 249.92,14.99 243.27,14.99 242.7,14.43 UH2.7
PCH_SPI_HOLD#_R: length 18.4
  IN4 w0.089: 264.27,19.66 v6(264.3,19.7)
  IN4 w0.102: v6(255.48,16.75) 255.48,16.74 256.25,17.5 261.4,17.5 262.35,18.45 262.53,18.45 263.11,19.02 263.63,19.02 264.27,19.66
  GND3 w0.089: v7(263.64,20.28) 263.71,20.28 v6(264.3,19.7)
  GND3 w0.102: v7(255.41,16.21) 255.48,16.29 v6(255.48,16.75)
  BOTTOM w0.089: v7(263.64,20.28) 263.49,20.44 263.49,22.01 U7.AJ2
  BOTTOM w0.102: v7(255.41,16.21) 253.02,16.21 v2(252.3,15.49) 251.56,14.75 RH41.2
PCH_SPI_SI: length 12.8
  TOP w0.102: RPH5.2 244.67,13.8 244.71,13.75 244.95,13.75 245.07,13.62 245.07,13.42 244.95,13.29 244.51,13.29 244.38,13.42 244.38,13.57 244.26,13.7 244.08,13.7 243.95,13.57 243.95,13.2 243.83,13.08 243.66,13.08 243.55,13.2 243.55,13.47 243.42,13.6 243.13,13.6 243.03,13.7 243.03,14.11 242.91,14.23 242.74,14.23 242.62,14.11 242.62,13.42 242.52,13.32 242.3,13.32 242.17,13.44 242.17,13.58 242.06,13.69 241.91,13.69 241.8,13.58 241.8,13.05 241.91,12.94 v2(242.68,12.94) 242.92,12.94 243.04,12.81 v1(243.04,12.45)
  BOTTOM w0.102: v1(243.04,12.45) 243.09,12.45 243.22,12.32 243.22,11.67 243.09,11.54 242.81,11.54 242.68,11.67 242.68,11.76 242.56,11.89 UH2.5
PCH_SPI_SI_R: length 35.2
  TOP w0.102: v2(244.17,19.77) 244.3,19.64 244.3,18.51 244.6,18.21 v3(244.6,17.99) 244.6,16.54 244.67,16.47 RPH5.7
  GND1 w0.102: v4(244.75,18.4) 244.75,18.14 v3(244.6,17.99)
  IN4 w0.089: 254.47,20.3 254.55,20.37 259.98,20.37 260.99,21.39 262.6,21.39 262.7,21.48 263.1,21.48 v6(263.41,21.17)
  IN4 w0.102: 254.47,20.3 254.01,19.84 253.54,19.84 253.1,20.27 251.03,20.27 250.86,20.1 250.18,20.1 250.11,20.02 250.11,19.35 250.01,19.25 249.8,19.25 249.7,19.35 249.7,20 249.6,20.1 249.4,20.1 249.29,20 249.29,19.32 249.19,19.22 248.99,19.22 248.89,19.32 248.89,20 248.79,20.1 248.58,20.1 248.48,20 248.48,19.32 248.38,19.22 248.18,19.22 248.08,19.32 248.08,20.42 247.97,20.52 247.36,20.52 247.26,20.42 247.26,19.32 247.16,19.22 246.96,19.22 246.86,19.32 246.86,20.42 246.76,20.52 246.58,20.52 246.48,20.42 246.48,19.32 246.37,19.22 246.19,19.22 246.09,19.32 246.09,19.49 245.98,19.59 244.91,19.59 244.75,19.44 v4(244.75,18.4)
  GND3 w0.089: v6(263.41,21.17) v7(263.8,21.17)
  BOTTOM w0.089: U7.AH1 263.8,21.63 263.8,21.17 v7(263.8,21.17)
PCH_SPI_SO: length 13.2
  TOP w0.102: RPH5.3 245.17,14.21 246.37,13.01 v1(246.37,12.62)
  BOTTOM w0.102: UH2.2 245.65,14.43 245.53,14.3 245.53,14.08 245.65,13.95 247.15,13.95 247.25,13.85 247.25,13.65 247.15,13.54 245.71,13.54 245.58,13.42 245.58,11.56 245.71,11.44 246.24,11.44 246.37,11.56 v1(246.37,12.62)
PCH_SPI_SO_R: length 33.2
  TOP w0.102: v2(245.12,18.83) v3(245.12,18.05) 244.98,17.91 244.98,16.95 245.17,16.76 RPH5.6
  GND1 w0.102: v3(245.12,18.05) 245.12,18.18 v4(245.34,18.4)
  IN4 w0.089: v6(263.87,21.57) 263.87,21.2 263.37,20.7 262.77,20.7 262.27,21.2 261.07,21.2 260.05,20.18 258.86,20.18 258.76,20.08 258.76,19.75 258.67,19.66
  IN4 w0.102: v4(245.34,18.4) 244.96,18.78 244.96,19.29 245.06,19.39 245.36,19.39 245.46,19.29 245.46,18.88 245.57,18.78 245.78,18.78 245.88,18.88 245.88,18.91 245.98,19.01 247.34,19.01 247.47,19.14 247.47,19.6 247.57,19.71 247.76,19.71 247.86,19.6 247.86,19.12 247.97,19.01 250.06,19.01 251.07,20.03 253.06,20.03 253.45,19.63 254.56,19.63 254.66,19.74 254.66,20 254.76,20.1 254.96,20.1 255.07,20 255.07,19.74 255.17,19.63 255.37,19.63 255.47,19.74 255.47,20 255.57,20.1 255.78,20.1 255.88,20 255.88,19.74 255.98,19.63 256.18,19.63 256.29,19.74 256.29,20 256.39,20.1 256.59,20.1 256.69,20 256.69,19.74 256.79,19.63 257,19.63 257.1,19.74 257.1,20 257.2,20.1 257.4,20.1 257.5,20 257.5,19.74 257.61,19.63 257.81,19.63 257.91,19.74 257.91,20 258.01,20.1 258.22,20.1 258.32,20 258.32,19.74 258.42,19.63 258.65,19.63 258.67,19.66
  GND3 w0.089: v7(264.21,21.18) 264.21,21.23 v6(263.87,21.57)
  BOTTOM w0.089: U7.AH3 263.77,22.09 264.07,21.79 264.07,21.31 v7(264.21,21.18)
PCH_SPI_WP#: length 6
  TOP w0.102: RPH5.4 245.67,14.45 246.93,13.19 246.93,12.64 v1(246.95,12.62)
  BOTTOM w0.102: RH38.2 249.64,12.97 249.45,13.16 UH2.3 247.49,13.16 v1(246.95,12.62)
PCH_SPI_WP#_R: length 25.4
  TOP w0.102: v3(245.39,17.7) 245.36,17.68 v2(245.36,17.25) 245.36,16.95 245.45,16.86 245.45,16.42 245.67,16.2 RPH5.5
  GND1 w0.102: v3(245.39,17.7) 245.92,18.23 v4(245.92,18.4)
  IN4 w0.089: v6(263.78,22.28) 264.16,21.89 264.16,21.23 263.45,20.51 262.69,20.51 262.19,21.01 261.15,21.01 260.11,19.97 259.83,19.97 259.52,19.66
  IN4 w0.102: 259.52,19.66 259.29,19.43 253.37,19.43 252.97,19.82 251.16,19.82 250.14,18.81 246.33,18.81 v4(245.92,18.4)
  GND3 w0.089: v7(263.37,22.58) 263.67,22.28 v6(263.78,22.28)
  BOTTOM w0.089: v7(263.37,22.58) U7.AJ4
PCH_SRTCRST#: length 45
  TOP w0.102: v1(262.13,51.95) 262.46,51.62 v2(263.1,51.62)
  IN1 w0.076: v1(262.13,51.95) 262.33,51.75 264.5,51.75 270.51,45.74 270.51,44.77 272.79,42.49 275.18,42.49 279.25,38.42 279.25,33.87 279.59,33.54 279.59,32.46 279.72,32.33 279.72,31.95 279.1,31.33 279.1,29.3 278.67,28.87 278.67,28.43 277.89,27.65 277.12,27.65 277.09,27.68 276.69,27.68 276.4,27.39 276.4,26.75 276.6,26.55 v4(276.6,25.66)
  GND3 w0.089: v4(276.6,25.66) 276.17,25.66 v7(275.9,25.39)
  BOTTOM w0.089: v7(275.9,25.39) 274.75,25.39 U7.B9
  BOTTOM w0.102: CLRP2.2 262.74,49.78 RH4.2 262.51,51.11 CH6.2 262.52,51.56 v1(262.13,51.95)
PCH_SUSWARN#: length 148.8
  TOP w0.089: UE1.D8 162.9,18.16 v1(162.8,18.06)
  TOP w0.102: v1(277.14,13.74) 276.86,13.74 275.83,14.77 275.83,15.22 275.89,15.29 RPH4.8
  IN1 w0.102: v1(234.16,18.35) 234.16,17.75 235.45,16.46 v4(235.45,15.97)
  IN2 w0.076: v1(162.8,18.06) 162.8,17.14 163.38,16.57 165.24,16.57 165.41,16.74 167.04,16.74 167.32,16.45 167.32,15.7 167.59,15.44 168.78,15.44
  IN2 w0.102: v4(235.45,15.97) 235.98,15.44 241.47,15.44 241.66,15.63 242.93,15.63 243.69,14.87 243.85,14.7 258.32,14.7 258.87,14.15 259.89,14.15 260.62,14.88 263.55,14.88 264.56,13.87 267.64,13.87 267.89,13.61 271.01,13.61 271.46,13.17 276.01,13.17 276.58,13.74 v1(277.14,13.74) ; v1(234.16,18.35) 231.73,18.35 230.42,19.66 224.23,19.66 223.71,20.18 213.12,20.18 212.39,19.44 203.14,19.44 202.01,18.31 193.41,18.31 192.99,17.89 183.09,17.89 182.04,16.85 171.67,16.85 170.25,15.44 168.78,15.44
  BOTTOM w0.076: v1(162.8,18.06) 162.03,17.28 T178.1
  BOTTOM w0.089: U7.J4 271.5,22.51 271.22,22.23 271.22,21.95 271.4,21.77 271.4,20.7 271.99,20.12
  BOTTOM w0.102: 271.99,20.12 271.99,19.83 272.18,19.64 276.54,19.64 278.12,18.07 278.12,15.68 275.93,13.5 274.84,13.5 274.61,13.26 274.61,12.84 274.99,12.46 275.97,12.46 277.14,13.62 v1(277.14,13.74)
PCH_TD_IREF: length 2.6
  TOP w0.089: RH322.1 259.7,39.2 v1(259.38,38.88) 259.52,38.88 v2(260.07,38.34)
  BOTTOM w0.089: U7.AY43 258.9,39.36 v1(259.38,38.88)
PCI_PIRQA#: length 14.2
  TOP w0.102: v3(280.05,29.71) 279.84,29.92 RPH1.1 278.19,29.92 v2(278.09,30.02)
  GND1 w0.102: v3(280.05,29.71) 280.22,29.71 v5(280.44,29.5)
  IN1 w0.102: v5(280.44,29.5) 280.25,29.5 279.34,28.59 279.34,28.03 v4(277.72,26.41)
  IN4 w0.089: 277.14,26.91 276.7,26.91 276.16,27.45 276.16,27.61 274.98,28.79 272.69,28.79 v1(272.29,29.19)
  IN4 w0.102: v4(277.72,26.41) 277.72,26.46 277.28,26.91 277.14,26.91
  BOTTOM w0.089: v1(272.29,29.19) 271.99,29.49 U7.H20
PCI_PIRQB#: length 13.3
  TOP w0.102: v3(280.05,29.22) 279.85,29.42 RPH1.2
  GND1 w0.102: v3(280.05,29.22) 280.05,29.24 279.79,29.5 v5(279.67,29.5)
  IN1 w0.102: v5(279.67,29.5) 279.67,29.21 279.14,28.68 279.14,28.19 277.93,26.99 277.64,26.99 277.15,26.5 v4(277.1,26.5)
  IN4 w0.089: v4(277.1,26.5) 276.84,26.5 275.96,27.38 275.96,27.5 274.88,28.58 272.28,28.58 271.69,29.16 v1(271.03,29.16)
  BOTTOM w0.089: U7.L20 270.8,29.4 v1(271.03,29.16)
PCI_PIRQC#: length 13.6
  TOP w0.102: RPH1.4 279.83,28.42 v3(280.03,28.21) 280.03,28.13 279.75,27.85 v2(279.75,27.29)
  GND1 w0.102: v3(280.03,28.21) 279.91,28.21 v5(279.67,28.46)
  IN1 w0.102: v5(279.67,28.46) 279.67,27.95 278.47,26.75 278.47,26.39 277.62,25.53 v4(277.24,25.53)
  IN4 w0.089: v1(271.67,28.27) 272.01,28.27 272.12,28.17 274.75,28.17 275.55,27.37 275.55,27.25 276.96,25.83 276.96,25.81 277.14,25.63
  IN4 w0.102: 277.14,25.63 v4(277.24,25.53)
  BOTTOM w0.089: v1(271.67,28.27) 271.39,28.55 U7.K17
PCI_PIRQD#: length 15.7
  TOP w0.102: v3(280.04,28.71) 279.83,28.92 RPH1.3
  GND1 w0.102: v3(280.04,28.71) 280.17,28.71 280.43,28.46 v5(280.44,28.46)
  IN1 w0.102: v5(280.44,28.46) 280.44,28.43 278.7,26.69 278.7,26.17 v4(277.62,25.09)
  IN4 w0.089: 277.14,26.08 276.99,26.08 275.75,27.31 275.75,27.43 274.83,28.36 272.23,28.36 271.85,28.74 270.9,28.74 v1(270.47,29.16)
  IN4 w0.102: v4(277.62,25.09) 277.68,25.15 277.68,25.69 277.29,26.08 277.14,26.08
  BOTTOM w0.089: v1(270.47,29.16) 270.2,29.44 U7.M20
PCIE_MCARD1_DET#: length 11
  TOP w0.089: v1(261.1,24.48) 260.72,24.87 260.72,25.17 260.22,25.66 259.46,25.66 258.82,26.3 258.19,26.3 257.92,26.56 255.98,26.56 255.71,26.29 v2(255.2,26.29) 254.47,26.29
  TOP w0.102: RPH8.8 254.47,26.29
  BOTTOM w0.089: U7.AT7 260.8,24.19 v1(261.1,24.48)
PCIE_PRX_CARDTX_N4: length 31.5
  IN1 w0.089: v1(259.98,34.72) 259.98,34.98 260.14,35.13 262.81,35.13 263.97,33.98 263.97,33.09 264.48,32.58 264.48,32.33 264.08,31.94 264.08,29.61 264.6,29.09 265.44,29.09 265.87,28.66 265.87,23.62 265.49,23.25 265.49,21.12 265.1,20.72 265.1,19.86 264.73,19.49 264.73,18.09 264.03,17.39 264.03,16.18 263.4,15.55 263.4,12.02 v1(263.21,11.83)
  BOTTOM w0.089: v1(259.98,34.72) 260.35,34.72 260.44,34.81 260.44,34.96 U7.AT33
  BOTTOM w0.102: v1(263.21,11.83) 263.4,12.01 263.4,12.16 263.3,12.26 JTB1.39
PCIE_PRX_CARDTX_P4: length 31.5
  IN1 w0.089: v1(263.79,11.83) 263.59,12.03 263.59,15.47 264.22,16.1 264.22,17.32 264.91,18.01 264.91,19.41 265.28,19.78 265.28,20.65 265.68,21.04 265.68,23.17 266.05,23.54 266.05,28.74 265.51,29.27 264.68,29.27 264.27,29.69 264.27,31.86 264.66,32.25 264.66,32.66 264.15,33.17 264.15,34.05 262.89,35.31 260.46,35.31 v1(260.07,35.7)
  BOTTOM w0.089: v1(260.07,35.7) 260.3,35.7 U7.AR33
  BOTTOM w0.102: JTB1.37 263.7,12.24 263.6,12.14 263.6,12.01 v1(263.79,11.83)
PCIE_PRX_WLANTX_N3: length 29.8
  IN1 w0.089: v1(258.85,35.68) 258.76,35.68 258.63,35.55 258.63,35.43 259.76,34.3 261.88,34.3 263.33,32.85 263.33,31.76 263.89,31.2 263.89,26.79 263.62,26.52 263.62,20.94 262.56,19.87 262.56,18.74 262.08,18.26 262.08,16.66 262.37,16.36 262.37,12.04 v1(262.59,11.82)
  BOTTOM w0.102: U7.AW33 259.03,35.31 258.85,35.48 v1(258.85,35.68) ; v1(262.59,11.82) 262.4,12.01 262.4,12.15 262.5,12.25 JTB1.43
PCIE_PRX_WLANTX_P3: length 29.7
  IN1 w0.089: v1(262.01,11.82) 262.19,12 262.19,16.28 261.89,16.58 261.89,18.33 262.37,18.82 262.37,19.95 263.44,21.01 263.44,26.6 263.71,26.87 263.71,31.12 263.15,31.68 263.15,32.77 261.81,34.11 259.69,34.11 258.45,35.36 258.45,35.49 v1(258.26,35.68)
  BOTTOM w0.102: U7.AY33 258.43,35.31 258.26,35.48 v1(258.26,35.68) ; JTB1.45 262.1,12.24 262.2,12.15 262.2,12.01 v1(262.01,11.82)
PCIE_PTX_CARDRX_N4: length 35.5
  IN1 w0.089: v1(249.35,23.47) 249.35,22.31 251.88,19.78 252.54,19.78 253.67,18.65 253.67,15.22 252.74,14.28 252.74,13.06 253.15,12.65 254.6,12.65 255,12.25 255,12.04 254.81,11.85 v1(254.81,11.83)
  BOTTOM w0.102: v1(254.81,11.83) 255,12.02 255,12.16 254.9,12.25 JTB1.81 ; v1(249.35,23.47) 249.48,23.47 249.64,23.63 249.64,23.81 249.3,24.16 249.3,37.62 251.06,39.38 252.16,39.38 CH21.1
PCIE_PTX_CARDRX_N4_C: length 6.8
  BOTTOM w0.089: 254.59,39.28 254.6,39.28 254.61,39.28 255.05,39.28 255.6,38.73 255.6,36.54 255.99,36.15 256.14,36.15 256.19,36.19 256.19,36.55 256.3,36.66 256.55,36.66 256.63,36.58 256.63,36.38 256.5,36.25 U7.BE36
  BOTTOM w0.102: 254.59,39.28 253.81,39.28 CH21.2
PCIE_PTX_CARDRX_P4: length 35.5
  IN1 w0.089: v1(255.39,11.83) 255.39,11.85 255.18,12.06 255.18,12.33 254.67,12.83 253.22,12.83 252.92,13.14 252.92,14.21 253.86,15.15 253.86,18.72 252.62,19.96 251.96,19.96 249.54,22.39 249.54,23.05 249.9,23.41 v1(250.15,23.41)
  BOTTOM w0.102: JTB1.79 255.3,12.27 255.2,12.17 255.2,12.02 v1(255.39,11.83) ; v1(250.15,23.41) 249.85,23.72 249.85,23.9 249.51,24.24 249.51,37.53 251.14,39.17 252.12,39.17 CH22.1
PCIE_PTX_CARDRX_P4_C: length 6.8
  BOTTOM w0.089: U7.BC36 256.92,36.25 256.62,35.95 255.91,35.95 255.4,36.46 255.4,38.65 254.97,39.08 254.61,39.08 254.6,39.07 254.59,39.07
  BOTTOM w0.102: 254.59,39.07 253.66,39.07 CH22.2
PCIE_PTX_WLANRX_N3: length 32
  IN1 w0.089: v1(251.06,22.92) 250.8,22.65 250.8,22.39 251.45,21.73 251.75,21.73 251.83,21.65 253.06,21.65 254.47,20.24 256.13,18.58 256.13,15.4 255.69,14.96 255.69,14.18 v1(255.89,13.98)
  BOTTOM w0.102: CH19.1 252.12,37.39 251.94,37.39 251.43,37.9 250.86,37.9 250.2,37.25 250.2,25.04 250.81,24.43 250.81,23.17 v1(251.06,22.92) ; JTB1.73 256.5,12.86 256.4,12.96 256.4,13.13 256.12,13.42 255.79,13.42 255.69,13.52 255.69,13.78 v1(255.89,13.98)
PCIE_PTX_WLANRX_N3_C: length 5.3
  BOTTOM w0.089: U7.BE34 256.65,35.44 256.73,35.35 256.73,35.23 256.65,35.14 256.21,35.14 256.16,35.19 256.16,35.51 256.12,35.55 255.47,35.55 254.74,36.29 254.74,36.74 254.61,36.87 254.6,36.87 254.59,36.88
  BOTTOM w0.102: CH19.2 253.73,37.37 254.1,37.37 v9(254.49,36.98) 254.59,36.88
PCIE_PTX_WLANRX_P3: length 32.3
  IN1 w0.089: v1(255.3,13.98) 255.5,14.18 255.5,15.03 255.95,15.48 255.95,18.51 254.03,20.42 254.03,20.42 252.99,21.47 251.75,21.47 251.68,21.55 251.38,21.55 250.62,22.31 250.62,22.78 v1(250.48,22.92)
  BOTTOM w0.102: v1(255.3,13.98) 255.48,13.8 255.48,13.43 255.7,13.21 256.03,13.21 256.2,13.05 256.2,12.96 256.1,12.87 JTB1.75 ; CH20.1 252.16,37.6 252.02,37.6 251.51,38.11 250.77,38.11 249.99,37.33 249.99,24.96 250.6,24.34 250.6,23.04 v1(250.48,22.92)
PCIE_PTX_WLANRX_P3_C: length 5.3
  BOTTOM w0.089: U7.BC34 256.94,35.44 256.63,35.75 255.55,35.75 254.93,36.37 254.93,36.82 254.79,36.97 254.75,37.01 254.75,37.02 254.74,37.03
  BOTTOM w0.102: CH20.2 253.73,37.58 254.19,37.58 254.74,37.03
PCIE_RCOMP: length 4.1
  BOTTOM w0.089: 254.47,34.62 255.28,34.62 256.37,33.53 256.8,33.53 U7.BD29
  BOTTOM w0.102: RH113.2 v2(254.32,34.62) 254.47,34.62
PCIECLKREQ0#: length 4.8
  TOP w0.102: RPH24.6 266.8,18.77 266.95,18.93 v2(266.95,19.25) 266.95,19.44 v3(266.56,19.83)
  GND1 w0.089: v3(266.56,19.83) 266.29,19.83 v4(266.1,20.02)
  GND3 w0.089: v4(266.1,20.02) 266.34,20.26 v7(266.34,20.43)
  BOTTOM w0.089: v7(266.34,20.43) 266.48,20.56 266.48,21.39 U7.AB1
PEG_A_CLKRQ#: length 131.4
  TOP w0.089: 201.71,78.23 v1(201.71,78.24)
  TOP w0.102: 201.71,78.23 v2(200.97,77.5) 200.83,77.35 200.83,71.26 201.77,70.32 201.77,67.61 QV39.1
  IN1 w0.076: 263.03,19.66 263.03,20.08 264.49,21.55 v1(264.49,23.06)
  IN1 w0.102: v4(263.12,16.76) 262.62,17.26 262.62,18.13 263.03,18.54 263.03,19.66 ; v1(201.71,78.24) 203.62,76.34 203.62,76.23 205.36,74.49 205.36,72.52 208.15,69.73 210.34,69.73 214.98,65.1 222.12,65.1 223.84,66.81 223.84,67.72 223.94,67.83 223.96,67.83 224.28,68.14 228.1,68.14 232.62,63.62 238.13,63.62 240.06,61.69 240.06,61.4 243.43,58.03 244.94,58.03 252.03,50.93 252.03,50.28 254.22,48.09 258.41,48.09 259.48,49.17 263.95,49.17 266.03,47.1 266.03,45.93 266.38,45.58 266.38,43.51 v4(265.74,42.87)
  IN2 w0.089: v1(264.49,23.06) 264.49,27.03 264.17,27.35 264.17,31.89 264.47,32.18 264.47,32.78 263.81,33.44 262.73,33.44 262.26,33.91 262.26,35.34 262.54,35.62 262.54,39.28 263.39,40.13 264.99,40.13 265.6,40.74 265.6,41.29 265.9,41.59 265.9,42.2
  IN2 w0.102: 265.9,42.2 265.9,42.71 v4(265.74,42.87)
  GND3 w0.102: v4(263.12,16.76) 263.35,16.53 v7(263.56,16.53)
  BOTTOM w0.102: U7.AF6 264.49,23.56 v1(264.49,23.06)
PEG_B_CLKREQ#: length 7.9
  BOTTOM w0.089: U7.U4 268.25,22.53 267.97,22.25 267.97,21.95 268.15,21.77 268.15,21.67 268.73,21.09 v2(268.73,20.23) 268.73,19.61
  BOTTOM w0.102: 268.73,19.61 268.06,18.94 266.39,18.94 265.8,18.35 RPH30.1
PEG_COMP: length 2.8
  TOP w0.089: RU1.1 175.8,85.93 176.02,85.71 v1(176.33,85.71) 176.83,85.71 177.19,86.06 v2(177.19,86.32)
  BOTTOM w0.305: U6.AH6 176.73,86.1 v1(176.33,85.71)
PEG_GTX_C_HRX_N0: length 29.4
  TOP w0.114: v1(179.88,91.44) 180.08,91.44 180.45,91.07 180.78,91.07 180.87,91.16 181.01,91.16 181.56,90.6 181.56,89.2 182.4,88.36 182.4,88.2 182.23,88.04 182.23,87.7 182.6,87.33 182.94,87.33 183.11,87.49 183.27,87.49 183.59,87.17 183.59,86.27 186.34,83.52 189.25,83.52 189.27,83.5 189.82,83.5 189.84,83.52 190.16,83.52 191.65,85.01 193.09,85.01 193.33,85.25 193.33,85.67 193.44,85.78 193.79,85.78 193.9,85.67 193.9,85.25 194.14,85.01 194.66,85.01 194.9,85.25 194.9,85.67 195.02,85.78 195.36,85.78 195.48,85.67 195.48,85.25 195.72,85.01 196.24,85.01 196.48,85.25 196.48,85.67 196.59,85.78 196.94,85.78 197.05,85.67 197.05,85.25 197.29,85.01 197.8,85.01 198.18,85.39 198.75,85.39 CV532.2
  BOTTOM w0.089: U6.Y2 179.53,91.79 v1(179.88,91.44)
PEG_GTX_C_HRX_N1: length 29.4
  TOP w0.114: v1(178.48,91.49) 178.29,91.49 178.16,91.36 178.16,91.18 178.29,91.05 178.71,91.05 178.94,91.28 179.11,91.28 179.23,91.17 179.23,89.27 180.82,87.68 181.18,87.68 186.07,82.79 190.44,82.79 191.95,84.3 193.95,84.3 193.97,84.28 194.52,84.28 194.54,84.3 200.6,84.3 CV534.2
  BOTTOM w0.089: U6.Y3 178.83,91.84 178.48,91.49 178.48,91.49 v1(178.48,91.49)
PEG_GTX_C_HRX_N2: length 32.7
  TOP w0.114: CV536.2 200.58,87.14 200.48,87.04 200.48,86.82 200.37,86.71 192.53,86.71 192.29,86.47 192.29,86.04 192.19,85.94 191.82,85.94 191.72,86.04 191.72,86.47 191.48,86.71 190.95,86.71 190.71,86.47 190.71,85.38 190.61,85.28 190.24,85.28 190.14,85.38 190.14,86.47 189.9,86.71 189.38,86.71 189.14,86.47 189.14,84.66 189.04,84.56 v9(187.51,84.56) 186.62,84.56 184.52,86.66 184.52,87.56 182.43,89.64 182.43,91.55 181.51,92.48 180.41,92.48 180.25,92.64 180.25,92.91 180.37,93.03 v1(180.61,93.03)
  BOTTOM w0.089: v1(180.61,93.03) U6.V1
PEG_GTX_C_HRX_N3: length 32.2
  TOP w0.114: CV538.2 198.89,88.14 198.17,88.14 197.94,87.91 197.94,87.54 197.82,87.42 188.55,87.42 188.31,87.18 188.31,85.39 188.19,85.27 187.87,85.27 187.74,85.39 187.74,87.18 187.5,87.42 186.98,87.42 186.74,87.18 186.74,86.02 186.61,85.89 186.29,85.89 185.23,86.95 185.23,87.85 183.15,89.94 183.15,92.02 182.65,92.51 182.48,92.68 182.48,92.72 182.03,93.18 181.99,93.18 181.47,93.7 178.93,93.7 178.7,93.47 178.7,93.22 v1(178.54,93.06)
  BOTTOM w0.089: v1(178.54,93.06) 178.14,92.65 U6.V4
PEG_GTX_C_HRX_N4: length 31.4
  TOP w0.114: CV540.2 200.7,89.18 197.34,89.18 197.1,88.94 197.1,88.24 196.98,88.13 196.64,88.13 196.52,88.24 196.52,88.94 196.28,89.18 195.76,89.18 195.54,88.96 195.54,88.26 195.41,88.13 193.46,88.13 193.43,88.15 192.87,88.15 192.85,88.13 185.96,88.13 183.9,90.19 v9(183.9,90.97) 183.9,92.27 181.9,94.27 178.75,94.27 177.56,93.08 177.06,93.08 v1(177.05,93.07)
  BOTTOM w0.089: v1(177.05,93.07) 177.43,92.7 U6.V5
PEG_GTX_C_HRX_N5: length 29.7
  TOP w0.114: v1(181.38,96.31) 181.13,96.31 180.96,96.13 180.96,95.77 181.13,95.59 181.59,95.59 184.61,92.57 184.61,90.49 186.25,88.84 187.89,88.84 188.01,88.95 188.01,89.5 188.25,89.74 188.77,89.74 189.01,89.5 189.01,88.95 189.12,88.84 189.47,88.84 189.58,88.95 189.58,89.5 189.82,89.74 193.87,89.74 194.12,89.48 v9(194.12,89.21) 194.12,88.97 194.25,88.84 194.57,88.84 194.7,88.97 194.7,89.91 194.94,90.15 198.61,90.15 CV542.2
  BOTTOM w0.089: U6.M2 179.67,96.72 180.16,97.21 180.82,97.21 181.18,96.84 181.18,96.51 v1(181.38,96.31)
PEG_GTX_C_HRX_N6: length 33.2
  TOP w0.114: v1(178.48,97.12) 178.63,97.28 178.63,97.52 178.87,97.76 179.47,97.76 180.21,97.02 181.52,97.02 182.33,96.21 182.33,96.15 v9(184.2,94.28) 185.32,93.16 185.32,90.78 185.65,90.45 186.38,90.45 186.62,90.21 186.62,89.68 186.75,89.55 187.07,89.55 187.19,89.68 187.19,90.21 187.43,90.45 193.15,90.45 193.28,90.58 193.28,91.13 193.52,91.37 194.04,91.37 194.28,91.13 194.28,90.97 194.4,90.86 194.74,90.86 194.85,90.97 194.85,91.46 195.11,91.71 195.6,91.71 195.86,91.46 195.86,90.97 195.97,90.86 196.31,90.86 196.43,90.97 196.43,91.46 196.68,91.71 197.18,91.71 197.43,91.46 197.43,90.97 197.55,90.86 197.89,90.86 198,90.97 198,91.13 198.24,91.37 199.33,91.37 199.41,91.46 200.68,91.46 CV544.2
  BOTTOM w0.089: v1(178.48,97.12) 178.13,97.48 U6.L4
PEG_GTX_C_HRX_N7: length 33
  TOP w0.114: CV546.2 198.67,91.96 198.54,92.09 198.54,92.51 198.41,92.64 198.14,92.64 198.03,92.52 198.03,92.47 197.9,92.34 197.7,92.34 197.57,92.47 197.57,92.52 197.46,92.64 197.11,92.64 196.68,92.21 194.52,92.21 194.5,92.19 193.94,92.19 193.92,92.21 193.65,92.21 192.39,90.94 190.92,90.94 190.65,91.21 190.65,91.29 190.53,91.42 189.32,91.42 189.08,91.66 189.08,92.09 188.97,92.21 188.62,92.21 188.51,92.09 188.51,91.66 188.27,91.42 187.75,91.42 187.51,91.66 187.51,92.09 187.39,92.21 187.05,92.21 186.92,92.08 186.92,91.2 186.67,90.94 186.09,90.94 185.84,91.2 v9(185.84,92.26) 185.84,93.41 181.74,97.5 180.26,97.5 179.67,98.09 178.77,98.09 178.36,97.68 177.83,97.15 177.83,96.65 177.96,96.52 178.08,96.52 178.28,96.72 178.62,96.72 178.73,96.61 178.73,96.44 178.6,96.31 v1(178.48,96.31)
  BOTTOM w0.089: v1(178.48,96.31) 178.13,96.66 U6.M4
PEG_GTX_C_HRX_N8: length 32.4
  TOP w0.114: CV548.2 200.69,93.75 196.59,93.75 196.03,93.19 192.5,93.19 192.26,92.95 192.26,92.12 192.13,92 191.81,92 191.69,92.12 v9(191.69,92.36) 191.69,92.95 191.45,93.19 190.92,93.19 190.68,92.95 190.68,92.47 190.56,92.34 190.24,92.34 190.11,92.47 190.11,92.95 189.87,93.19 187.37,93.19 186.16,94.4 186.16,94.54 186.38,94.77 186.38,95.11 186.01,95.48 185.67,95.48 185.45,95.25 185.31,95.25 185.04,95.51 185.04,95.66 185.27,95.88 185.27,96.22 184.9,96.59 184.56,96.59 184.34,96.37 184.19,96.37 183.93,96.63 183.93,96.77 184.15,97 184.15,97.34 183.79,97.71 183.44,97.71 183.22,97.48 183.08,97.48 182.82,97.74 182.82,97.89 183.04,98.11 183.04,98.45 182.46,99.03 181.76,99.03 181.49,98.76 v1(181.49,98.19)
  BOTTOM w0.089: U6.L2 179.61,97.53 180.09,98.01 180.56,98.01 180.92,97.66 181.4,97.66 181.49,97.75 v1(181.49,98.19)
PEG_GTX_C_HRX_N9: length 28.4
  TOP w0.114: v1(177.08,97.94) 177.08,97.76 177.2,97.64 177.39,97.64 177.56,97.8 177.56,98.6 177.86,98.9 179.49,98.9 179.59,99 179.59,99.56 179.88,99.84 182.9,99.84 184.66,98.09 184.66,97.84 187.49,95.01 187.49,94.67 187.26,94.45 187.26,94.3 187.52,94.04 187.67,94.04 187.89,94.26 188.23,94.26 188.55,93.95 190.35,93.95 190.37,93.97 190.92,93.97 190.94,93.95 195.78,93.95 196.64,94.8 198.7,94.8 CV551.2
  BOTTOM w0.089: v1(177.08,97.94) 177.43,97.59 U6.L5
PEG_GTX_C_HRX_N10: length 34
  TOP w0.114: CV557.2 200.51,98.14 196.95,98.14 195.58,96.76 189.12,96.76 182.38,103.5 180.44,103.5 180.42,103.52 179.74,103.52 179.72,103.5 179.57,103.5 179.33,103.74 178.81,103.74 177.81,104.74 175.63,104.74 175.49,104.88 175.49,105.08 175.61,105.2 v1(175.89,105.2)
  BOTTOM w0.089: v1(175.89,105.2) 175.7,105.4 175.7,105.53 175.42,105.81 174.76,105.81 174.19,105.25 174.19,104.59 174.67,104.1 U6.B9
PEG_GTX_C_HRX_N11: length 31.5
  TOP w0.114: v1(175.11,102.22) 175.5,102.61 175.5,103.83 175.69,104.02 177.18,104.02 178.39,102.81 178.94,102.81 179.68,102.07 181.01,102.07 181.03,102.05 181.96,102.05 181.98,102.07 182.5,102.07 188.73,95.83 190.5,95.83 190.61,95.72 190.61,95.49 190.85,95.24 191.26,95.24 191.5,95.49 191.5,95.72 191.61,95.83 191.84,95.83 191.96,95.72 191.96,95.49 192.2,95.24 192.61,95.24 192.85,95.49 192.85,95.72 192.96,95.83 195.96,95.83 197.08,96.96 198.61,96.96 CV559.2
  BOTTOM w0.089: U6.D9 174.78,102.54 v1(175.11,102.22)
PEG_GTX_C_HRX_N12: length 31.8
  TOP w0.114: v1(174.27,101.48) 174.47,101.28 174.47,101.04 174.7,100.81 v9(175.8,100.81) 178.83,100.81 179.28,100.36 180.71,100.36 180.73,100.34 181.48,100.34 181.49,100.36 183.1,100.36 188.55,94.91 189.34,94.91 189.72,94.53 195.67,94.53 196.43,95.3 197.27,95.3 197.51,95.54 197.51,96.13 197.62,96.24 197.96,96.24 198.08,96.13 198.08,95.93 198.32,95.69 200.64,95.69 CV561.2
  BOTTOM w0.089: v1(174.27,101.48) 174.63,101.84 U6.E9
