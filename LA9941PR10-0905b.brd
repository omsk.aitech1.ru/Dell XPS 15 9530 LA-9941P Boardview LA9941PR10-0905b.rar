# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D1: length 80.5
  IN4 w0.076: v1(109.15,27.82) 108.75,28.22 108.75,28.92 108.68,29 108.53,29 108.44,29.09 108.44,29.21 108.53,29.3 108.68,29.3 108.75,29.38 108.75,29.53 108.68,29.61 108.52,29.61 108.43,29.7 108.43,29.82 108.52,29.91 108.68,29.91 108.75,29.99 108.75,30.27 110.3,31.82 110.3,38.78 119.71,48.19 119.71,49.2 133.79,63.28 133.79,68.13 134.3,68.64 134.3,72.97 136.08,74.75 136.08,81.81 140.79,86.52 142.71,86.52 142.86,86.37 144.74,86.37 145.29,86.91 v1(145.42,86.91)
  BOTTOM w0.089: U6.AH52 145.77,86.56 v1(145.42,86.91)
  BOTTOM w0.102: JDIMM1.4 109.8,27.17 v1(109.15,27.82)
DDR_A_D2: length 80.3
  IN4 w0.076: v1(146.12,85.29) 145.69,84.86 144.88,84.86 144.63,84.6 141.42,84.6 137.89,81.07 137.89,73.54 137.75,73.4 137.75,72.8 136.16,71.21 136.16,67.89 135.6,67.33 135.6,62.53 130.37,57.31 130.37,56.3 113.6,39.53 113.6,35.6 113.53,35.52 113.05,35.52 112.98,35.45 112.98,35.29 113.05,35.22 113.53,35.22 113.6,35.14 113.6,34.99 113.53,34.91 113.05,34.91 112.98,34.84 112.98,34.68 113.05,34.61 113.53,34.61 113.6,34.53 113.6,34.38 113.53,34.3 113.05,34.3 112.98,34.23 112.98,34.07 113.05,34 113.53,34 113.6,33.92 113.6,33.77 113.53,33.69 113.05,33.69 112.98,33.62 112.98,33.47 113.05,33.39 113.53,33.39 113.6,33.31 113.6,29.62 v1(114,29.22)
  BOTTOM w0.089: U6.AK51 146.47,84.94 v1(146.12,85.29)
  BOTTOM w0.102: v1(114,29.22) 113.4,28.63 JDIMM1.16
DDR_A_D3: length 78.9
  IN4 w0.076: v1(112.61,35.88) 112.22,36.27 112.22,38.8 121.28,47.85 121.28,47.96 121.05,48.19 121.05,48.32 121.14,48.4 121.27,48.4 121.49,48.18 121.6,48.18 121.71,48.29 121.71,48.39 121.31,48.79 121.31,48.9 121.42,49.01 121.53,49.01 121.93,48.61 122.03,48.61 122.14,48.72 122.14,48.83 121.74,49.22 121.74,49.33 121.85,49.44 121.96,49.44 122.36,49.04 122.46,49.04 122.57,49.15 122.57,49.26 122.18,49.65 122.18,49.76 122.28,49.87 122.39,49.87 122.79,49.47 122.9,49.47 123,49.58 123,49.69 122.61,50.08 122.61,50.19 122.71,50.3 122.82,50.3 123.22,49.9 123.33,49.9 123.43,50.01 123.43,50.12 123.04,50.52 123.04,50.62 123.15,50.73 123.25,50.73 123.65,50.33 123.76,50.33 123.87,50.44 123.87,50.55 123.47,50.95 123.47,51.05 123.58,51.16 123.69,51.16 124.08,50.77 124.19,50.77 124.3,50.87 124.3,50.98 123.9,51.38 123.9,51.49 124.01,51.59 124.12,51.59 124.51,51.2 124.62,51.2 124.73,51.31 124.73,51.41 124.33,51.81 124.33,51.92 124.44,52.03 124.55,52.03 124.94,51.63 125.05,51.63 125.16,51.74 125.16,51.84 124.76,52.24 124.76,52.35 124.87,52.46 124.98,52.46 125.38,52.06 125.48,52.06 125.59,52.17 125.59,52.28 125.19,52.67 125.19,52.78 135.14,62.72 135.14,67.52 135.65,68.03 135.65,72.37 137.43,74.16 137.43,81.26 141.26,85.08 143.12,85.08 v1(143.32,85.29)
  BOTTOM w0.089: v1(143.32,85.29) 143.73,84.88 U6.AK54
  BOTTOM w0.102: v1(112.61,35.88) 113.1,35.39 JDIMM1.15
DDR_A_D4: length 79
  IN4 w0.076: v1(109.02,35.75) 109.02,33.13 109.15,33 109.94,33 110.07,33.13 110.07,33.31 109.99,33.39 109.6,33.39 109.52,33.46 109.52,33.62 109.6,33.69 109.99,33.69 110.07,33.77 110.07,33.92 109.99,34 109.6,34 109.52,34.07 109.52,34.23 109.6,34.3 109.99,34.3 110.07,34.38 110.07,38.87 119.48,48.28 119.48,49.29 133.56,63.38 133.56,68.09 133.51,68.14 133.51,72.51 135.85,74.85 135.85,81.91 140.69,86.75 142.96,86.75 143.17,86.55 144.35,86.55 v1(144.72,86.91)
  BOTTOM w0.089: v1(144.72,86.91) 145.07,86.56 U6.AH53
  BOTTOM w0.102: JDIMM1.5 110.1,35.31 109.66,35.75 v1(109.02,35.75)
DDR_A_D5: length 81.4
  IN4 w0.076: v1(109.15,29.35) 109.92,30.12 109.92,30.23 109.6,30.56 109.6,30.66 109.71,30.77 109.81,30.77 110.13,30.45 110.29,30.45 110.39,30.56 110.39,30.71 110.04,31.06 110.04,31.24 110.53,31.73 110.53,38.68 119.93,48.09 119.93,49.1 134.02,63.19 134.02,68.03 134.53,68.54 134.53,72.88 136.31,74.66 136.31,81.72 140.87,86.28 142.58,86.28 142.71,86.15 144.93,86.15 145.27,86.49 145.7,86.49 v1(146.12,86.91)
  BOTTOM w0.089: U6.AH51 146.47,86.56 v1(146.12,86.91)
  BOTTOM w0.102: v1(109.15,29.35) 110.4,28.09 JDIMM1.6
DDR_A_D6: length 79.8
  IN4 w0.076: v1(114,27.7) 114.39,28.09 114.39,30.15 114.05,30.49 114.05,33.9 114.12,33.98 114.97,33.98 115.06,34.07 115.06,34.2 114.97,34.29 114.12,34.29 114.05,34.36 114.05,34.51 114.12,34.59 115.01,34.59 115.1,34.68 115.1,34.81 115.01,34.9 114.12,34.9 114.05,34.97 114.05,35.12 114.12,35.2 114.85,35.2 114.94,35.29 114.94,35.42 114.85,35.5 114.12,35.5 114.05,35.58 114.05,39.65 130.6,56.2 130.6,57.21 135.82,62.44 135.82,67.23 136.38,67.79 136.38,71.11 137.98,72.71 137.98,73.31 138.12,73.44 138.12,80.97 141.52,84.37 145.32,84.37 v1(145.42,84.48)
  BOTTOM w0.089: U6.AK52 145.77,84.83 v1(145.42,84.48)
  BOTTOM w0.102: v1(114,27.7) 114,27.69 JDIMM1.18
DDR_A_D7: length 79.3
  IN4 w0.076: v1(112.61,37.4) 113.31,37.4 113.37,37.47 113.37,37.65 113.3,37.73 113.03,37.73 112.94,37.82 112.94,37.94 113.03,38.03 113.3,38.03 113.37,38.11 113.37,38.26 113.3,38.34 113,38.34 112.91,38.43 112.91,38.55 113,38.64 113.3,38.64 113.37,38.72 113.37,38.9 113.3,38.97 113.02,38.97 112.93,39.06 112.93,39.19 113.02,39.28 113.3,39.28 113.37,39.35 113.37,39.63 125.96,52.21 125.96,52.34 125.57,52.73 125.57,52.83 125.68,52.94 125.79,52.94 126.18,52.55 126.3,52.55 126.39,52.64 126.39,52.77 126,53.16 126,53.27 126.11,53.37 126.22,53.37 126.61,52.99 126.73,52.99 126.82,53.08 126.82,53.2 126.44,53.59 126.44,53.7 126.54,53.81 126.65,53.81 127.04,53.42 127.16,53.42 127.25,53.51 127.25,53.63 126.87,54.02 126.87,54.13 126.97,54.24 127.08,54.24 127.47,53.85 127.6,53.85 127.69,53.94 127.69,54.06 127.3,54.45 127.3,54.56 127.41,54.67 127.51,54.67 127.9,54.28 128.03,54.28 128.12,54.37 128.12,54.5 127.73,54.88 127.73,54.99 127.84,55.1 127.94,55.1 128.33,54.71 128.46,54.71 128.55,54.8 128.55,54.93 128.16,55.31 128.16,55.42 129.13,56.39 129.24,56.39 129.63,56 129.75,56 129.84,56.09 129.84,56.22 129.45,56.61 129.45,56.72 129.56,56.82 129.67,56.82 129.92,56.57 130.05,56.57 130.14,56.66 130.14,56.79 129.89,57.04 129.89,57.15 135.37,62.63 135.37,67.42 135.93,67.98 135.93,71.3 137.52,72.9 137.52,73.5 137.66,73.63 137.66,81.16 141.35,84.86 144.29,84.86 v1(144.72,85.29)
  BOTTOM w0.089: v1(144.72,85.29) 145.07,84.94 U6.AK53
  BOTTOM w0.102: JDIMM1.17 113.7,36.32 v1(112.61,37.4)
DDR_A_D8: length 71.8
  IN4 w0.076: v1(115.15,37.4) 114.89,37.4 114.76,37.53 114.76,38.31 114.89,38.43 115.45,38.43 115.58,38.56 115.58,40.18 133.98,58.58 133.98,58.75 133.61,59.12 133.61,59.22 133.72,59.33 133.83,59.33 134.22,58.94 134.34,58.94 134.43,59.03 134.43,59.16 134.05,59.55 134.05,59.65 134.15,59.76 134.26,59.76 134.65,59.37 134.77,59.37 134.86,59.46 134.86,59.59 134.48,59.98 134.48,60.09 134.58,60.19 134.69,60.19 135.08,59.81 135.21,59.81 135.3,59.89 135.3,60.02 134.91,60.41 134.91,60.52 135.02,60.62 135.12,60.62 135.51,60.24 135.64,60.24 135.73,60.33 135.73,60.45 135.34,60.84 135.34,60.95 135.45,61.06 135.55,61.06 135.94,60.67 136.07,60.67 136.16,60.76 136.16,60.88 135.77,61.27 135.77,61.38 135.88,61.49 135.99,61.49 136.3,61.17 136.43,61.17 136.52,61.26 136.52,61.39 136.2,61.7 136.2,61.81 136.54,62.15 136.54,66.94 137.09,67.5 137.09,70.82 138.69,72.42 138.69,72.97 138.83,73.11 138.83,80.68 141.76,83.61 143.27,83.61 v1(143.32,83.66)
  BOTTOM w0.089: v1(143.32,83.66) 143.73,83.26 U6.AN54
  BOTTOM w0.102: v1(115.15,37.4) 115.73,36.83 115.73,35.65 115.5,35.42 JDIMM1.23
DDR_A_D9: length 73.8
  IN4 w0.076: v1(145.42,83.66) 144.94,84.15 143.15,84.15 142.85,83.84 141.67,83.84 138.6,80.77 138.6,73.2 138.46,73.07 138.46,72.51 136.87,70.91 136.87,67.59 136.31,67.03 136.31,62.24 133.24,59.17 133.24,59.06 133.63,58.66 133.63,58.56 133.52,58.45 133.42,58.45 133.02,58.84 132.91,58.84 132.8,58.74 132.8,58.63 133.2,58.23 133.2,58.13 133.09,58.02 132.99,58.02 132.59,58.41 132.48,58.41 132.37,58.31 132.37,58.2 132.77,57.8 132.77,57.69 132.66,57.59 132.55,57.59 132.16,57.98 132.05,57.98 131.94,57.87 131.94,57.77 132.34,57.37 132.34,57.26 132.23,57.15 132.12,57.15 131.73,57.55 131.62,57.55 131.51,57.44 131.51,57.34 131.91,56.94 131.91,56.83 131.8,56.72 131.69,56.72 131.3,57.12 131.19,57.12 131.08,57.01 131.08,56.9 131.48,56.51 131.48,56.4 115.35,40.28 115.35,39.48 115.25,39.38 114.82,39.38 114.72,39.28 114.72,39.14 114.82,39.04 115.26,39.04 115.35,38.95 115.35,38.83 115.26,38.74 114.61,38.74 114.53,38.66 114.53,36.5 v1(115.15,35.88)
  BOTTOM w0.089: v1(145.42,83.66) 145.77,83.31 U6.AN52
  BOTTOM w0.102: v1(115.15,35.88) 114.9,35.63 JDIMM1.21
DDR_A_D10: length 73.8
  IN4 w0.076: v1(146.12,82.04) 145.72,81.63 145.11,81.63 144.94,81.46 142.48,81.46 141.16,80.14 141.16,72.49 140.78,72.1 140.78,71.59 139.13,69.94 139.13,66.63 138.57,66.07 138.57,65.59 139,65.16 139,60.72 123.88,45.6 123.88,44.38 121.99,42.49 121.99,40.46 119.66,38.14 119.66,37.66 119.58,37.59 119.07,37.59 119,37.51 119,37.36 119.07,37.28 119.58,37.28 119.66,37.2 119.66,37.05 119.58,36.98 119.07,36.98 119,36.9 119,36.75 119.07,36.67 119.58,36.67 119.66,36.59 119.66,36.44 119.58,36.37 119.26,36.37 119.18,36.28 119.18,36.15 119.26,36.06 119.58,36.06 119.66,35.99 119.66,30.68 v1(118.2,29.22)
  BOTTOM w0.089: U6.AR51 146.47,81.69 v1(146.12,82.04)
  BOTTOM w0.102: v1(118.2,29.22) 119.4,28.02 JDIMM1.36
DDR_A_D11: length 72.2
  IN4 w0.076: v1(118.42,37.4) 120.42,39.4 120.42,39.51 120.09,39.84 120.09,39.96 120.18,40.05 120.31,40.05 120.63,39.73 120.74,39.73 120.85,39.83 120.85,39.94 120.42,40.37 120.42,40.49 120.51,40.58 120.64,40.58 121.06,40.16 121.17,40.16 121.28,40.27 121.28,40.37 120.87,40.78 120.87,40.91 120.96,41 121.09,41 121.49,40.59 121.6,40.59 121.76,40.75 121.76,41.13 121.68,41.21 121.36,41.21 121.28,41.28 121.28,41.43 121.36,41.51 121.68,41.51 121.76,41.59 121.76,41.74 121.68,41.82 121.36,41.82 121.28,41.89 121.28,42.04 121.36,42.12 121.68,42.12 121.76,42.2 121.76,42.58 122.09,42.91 122.09,43.02 121.59,43.53 121.59,43.63 121.69,43.74 121.8,43.74 122.28,43.26 122.44,43.26 122.55,43.37 122.55,43.52 122.08,43.99 122.08,44.12 122.17,44.22 122.3,44.22 122.78,43.73 122.91,43.73 123,43.82 123,43.95 122.5,44.44 122.5,44.55 122.61,44.66 122.72,44.66 123.22,44.16 123.34,44.16 123.43,44.25 123.43,44.38 122.94,44.88 122.94,44.98 123.04,45.09 123.15,45.09 123.43,44.81 123.56,44.81 123.65,44.9 123.65,45.02 123.37,45.31 123.37,45.41 138.77,60.82 138.77,65.06 138.34,65.5 138.34,66.17 138.9,66.73 138.9,70.03 140.55,71.68 140.55,72.2 140.93,72.58 140.93,80.23 142.47,81.77 142.78,81.77 142.89,81.67 144.35,81.67 v1(144.72,82.04)
  BOTTOM w0.089: v1(144.72,82.04) 145.07,81.69 U6.AR53
  BOTTOM w0.102: v1(118.42,37.4) 119.1,36.72 JDIMM1.35
DDR_A_D12: length 72.6
  IN4 w0.076: v1(116.54,29.22) 115.81,29.95 115.81,40.09 136.76,61.04 136.76,66.84 137.32,67.4 137.32,70.72 138.92,72.32 138.92,72.88 139.06,73.01 139.06,80.58 141.86,83.38 142.87,83.38 143.06,83.19 144.25,83.19 v1(144.72,83.66)
  BOTTOM w0.089: v1(144.72,83.66) 145.07,83.31 U6.AN53
  BOTTOM w0.102: v1(116.54,29.22) 115.2,27.89 JDIMM1.22
DDR_A_D13: length 74.8
  IN4 w0.076: v1(116.54,27.7) 116.93,28.09 116.93,30.15 116.04,31.04 116.04,36.37 116.11,36.44 116.5,36.44 116.58,36.53 116.58,36.66 116.5,36.75 116.11,36.75 116.04,36.83 116.04,39.99 136.99,60.95 136.99,66.75 137.55,67.31 137.55,70.63 139.15,72.23 139.15,72.78 139.28,72.92 139.28,80.49 141.95,83.15 142.76,83.15 143.03,82.89 144.8,82.89 145.16,83.24 145.7,83.24 v1(146.12,83.66)
  BOTTOM w0.089: U6.AN51 146.47,83.31 v1(146.12,83.66)
  BOTTOM w0.102: v1(116.54,27.7) 116.4,27.7 115.8,27.1 JDIMM1.24
DDR_A_D14: length 72.4
  IN4 w0.076: v1(145.42,81.22) 145.42,81.23 142.58,81.23 141.39,80.04 141.39,72.39 141.01,72.01 141.01,71.49 139.36,69.84 139.36,60.76 124.11,45.51 124.11,44.28 122.22,42.39 122.22,40.37 120.42,38.57 120.42,38.04 120.35,37.97 119.97,37.97 119.89,37.89 119.89,37.74 119.97,37.66 120.35,37.66 120.42,37.59 120.42,37.43 120.35,37.36 119.97,37.36 119.89,37.28 119.89,37.13 119.97,37.05 120.35,37.05 120.42,36.98 120.42,36.82 120.35,36.75 119.97,36.75 119.89,36.67 119.89,36.52 119.97,36.44 120.35,36.44 120.42,36.37 120.42,36.21 120.35,36.14 119.97,36.14 119.89,36.06 119.89,35.91 119.97,35.83 120.35,35.83 120.42,35.76 120.42,29.92 v1(118.2,27.7)
  BOTTOM w0.089: v1(145.42,81.22) 145.42,81.28 U6.AR52
  BOTTOM w0.102: v1(118.2,27.7) 118.8,27.1 JDIMM1.34
DDR_A_D15: length 71.7
  IN4 w0.076: v1(143.32,82.04) 142.42,82.04 140.71,80.33 140.71,72.68 140.32,72.29 140.32,71.78 138.67,70.13 138.67,66.82 138.11,66.26 138.11,65.4 138.54,64.97 138.54,60.91 121.21,43.58 121.21,43.47 121.7,42.98 121.7,42.85 121.61,42.76 121.49,42.76 120.99,43.26 120.88,43.26 120.78,43.15 120.78,43.04 121.3,42.51 121.3,42.39 121.21,42.3 121.09,42.3 120.56,42.82 120.45,42.82 120.34,42.72 120.34,42.61 121.05,41.9 121.05,41.77 120.97,41.68 120.84,41.68 120.13,42.39 120.02,42.39 119.86,42.23 119.86,41.93 119.94,41.86 120.15,41.86 120.24,41.77 120.24,41.64 120.15,41.55 119.94,41.55 119.86,41.48 119.86,41.32 119.94,41.25 120.59,41.25 120.68,41.16 120.68,41.03 120.59,40.94 119.94,40.94 119.86,40.87 119.86,40.71 119.94,40.64 120.1,40.64 120.19,40.55 120.19,40.42 120.1,40.33 119.94,40.33 119.86,40.26 119.86,39.17 119.25,38.56 118.25,38.56 118.02,38.33 118.02,34.92 118.14,34.81 118.3,34.81 118.41,34.92 118.41,35.01 118.49,35.09 118.68,35.09 118.77,35.17 118.77,35.3 118.68,35.39 118.49,35.39 118.41,35.47 118.41,35.88 v1(118.42,35.88)
  BOTTOM w0.089: v1(143.32,82.04) 143.73,81.63 U6.AR54
  BOTTOM w0.102: JDIMM1.33 118.5,35.8 v1(118.42,35.88)
DDR_A_D16: length 66.6
  IN4 w0.076: v1(145.42,80.41) 144.85,80.98 143.01,80.98 141.87,79.84 141.87,72.04 141.49,71.65 141.49,71.29 139.84,69.64 139.84,60.56 126.67,47.39 126.67,47.29 126.97,46.99 126.97,46.86 126.88,46.77 126.76,46.77 126.46,47.07 126.35,47.07 126.24,46.96 126.24,46.85 126.74,46.36 126.74,46.23 126.65,46.14 126.52,46.14 126.03,46.64 125.92,46.64 125.81,46.53 125.81,46.42 126.31,45.93 126.31,45.8 126.22,45.71 126.09,45.71 125.6,46.21 125.49,46.21 125.38,46.1 125.38,45.99 125.88,45.5 125.88,45.37 125.79,45.28 125.66,45.28 125.17,45.78 125.06,45.78 124.95,45.67 124.95,45.56 125.45,45.06 125.45,44.94 125.36,44.85 125.23,44.85 124.8,45.27 124.68,45.27 124.59,45.18 124.59,45.06 125.01,44.63 125.01,44.51 122.7,42.19 122.7,40.17 121.53,39.01 121.53,37.98 v1(120.96,37.4)
  BOTTOM w0.089: U6.AV52 145.77,80.06 v1(145.42,80.41)
  BOTTOM w0.102: JDIMM1.39 120.3,36.75 v1(120.96,37.4)
DDR_A_D17: length 66
  IN4 w0.076: v1(144.79,80.41) 144.41,80.79 143.15,80.79 142.1,79.75 142.1,71.94 141.72,71.56 141.72,71.2 140.07,69.55 140.07,60.46 127.2,47.6 127.2,46.37 122.93,42.1 122.93,40.07 121.84,38.99 121.84,32.24 121.71,32.11 121.03,32.11 120.9,32.24 120.9,35.83 v1(120.96,35.88)
  BOTTOM w0.089: v1(144.79,80.41) 145.07,80.13 U6.AV53
  BOTTOM w0.102: v1(120.96,35.88) 120.9,35.82 JDIMM1.41
DDR_A_D18: length 65
  IN4 w0.076: v1(124.6,35.88) 124.6,33.34 124.73,33.22 125.6,33.22 125.73,33.34 125.73,33.49 125.62,33.6 125.21,33.6 125.13,33.68 125.13,33.83 125.21,33.9 125.67,33.9 125.74,33.98 125.74,34.13 125.67,34.21 125.21,34.21 125.13,34.29 125.13,34.44 125.21,34.51 125.67,34.51 125.74,34.59 125.74,34.74 125.67,34.82 125.21,34.82 125.13,34.89 125.13,35.05 125.21,35.12 125.67,35.12 125.74,35.2 125.74,35.35 125.67,35.43 125.21,35.43 125.13,35.5 125.13,35.66 125.21,35.73 125.65,35.73 125.74,35.83 125.74,35.96 125.65,36.06 125.04,36.06 124.95,36.14 124.95,36.27 125.04,36.36 125.62,36.36 125.74,36.49 125.74,39.62 129.46,43.33 129.46,46.66 142.33,59.52 142.33,68.51 144.23,70.42 144.23,75.7 144.37,75.84 144.37,77.5 144.84,77.97 v1(145.36,77.97)
  BOTTOM w0.089: v1(145.36,77.97) 145.76,78.38 U6.AY52
  BOTTOM w0.102: v1(124.6,35.88) 124.17,35.88 123.9,35.61 JDIMM1.51
DDR_A_D19: length 65.7
  IN4 w0.076: v1(146.12,78.82) 146.12,78.54 145.97,78.39 144.93,78.39 144.52,77.99 144.46,77.99 144.32,78.12 144.2,78.12 144.11,78.03 144.11,77.9 144.25,77.76 144.25,77.65 144.08,77.48 144.08,76.03 144,75.95 144,70.51 142.1,68.61 142.1,59.62 129.23,46.75 129.23,44.55 129.01,44.32 129.01,44.21 129.23,43.99 129.23,43.87 129.14,43.78 129.02,43.78 128.79,44 128.69,44 128.58,43.89 128.58,43.78 129.02,43.34 129.02,43.22 128.93,43.13 128.8,43.13 128.36,43.57 128.25,43.57 128.15,43.46 128.15,43.35 128.59,42.91 128.59,42.78 128.5,42.7 128.37,42.7 127.93,43.14 127.82,43.14 127.72,43.03 127.72,42.92 128.16,42.48 128.16,42.35 128.07,42.26 127.94,42.26 127.5,42.71 127.39,42.71 127.28,42.6 127.28,42.49 127.73,42.05 127.73,41.92 127.72,41.92 125.52,39.71 125.52,39.48 125.44,39.4 125.13,39.4 125.04,39.31 125.04,39.19 125.13,39.1 125.44,39.1 125.52,39.02 125.52,38.87 125.44,38.79 124.83,38.79 124.74,38.7 124.74,38.58 124.83,38.49 125.44,38.49 125.52,38.41 125.52,38.26 125.44,38.18 125.08,38.18 124.99,38.09 124.99,37.97 125.08,37.88 125.44,37.88 125.52,37.8 125.52,36.78 125.4,36.66 125.24,36.66 125.12,36.78 125.12,37.28 124.99,37.4 v1(124.6,37.4)
  BOTTOM w0.089: v1(146.12,78.82) 146.47,78.47 U6.AY51
  BOTTOM w0.102: v1(124.6,37.4) 125.13,36.87 125.13,35.72 124.5,35.09 JDIMM1.53
DDR_A_D20: length 66.7
  IN4 w0.076: v1(146.12,80.41) 145.69,79.98 145.18,79.98 144.82,79.61 142.73,79.61 142.51,79.39 142.51,71.7 142.17,71.37 142.17,71.01 140.52,69.36 140.52,60.27 127.66,47.41 127.66,46.18 123.38,41.91 123.38,39.88 122.3,38.8 122.3,28.54 v1(121.45,27.7)
  BOTTOM w0.089: v1(146.12,80.41) 146.47,80.06 U6.AV51
  BOTTOM w0.102: JDIMM1.42 121.2,27.45 v1(121.45,27.7)
DDR_A_D21: length 65.1
  IN4 w0.076: v1(121.45,29.22) 122.07,29.84 122.07,38.89 123.15,39.98 123.15,42 127.43,46.27 127.43,47.5 140.3,60.37 140.3,69.45 141.95,71.11 141.95,71.46 142.33,71.85 142.33,79.65 143.09,80.41 v1(143.32,80.41)
  BOTTOM w0.089: U6.AV54 143.73,80.01 v1(143.32,80.41)
  BOTTOM w0.102: v1(121.45,29.22) 120.6,28.37 JDIMM1.40
DDR_A_D22: length 63.8
  IN4 w0.076: v1(143.26,78.79) 143.7,78.35 143.7,76.94 143.32,76.57 143.32,70.48 141.64,68.8 141.64,59.81 129.23,47.4 128.78,46.94 128.78,44.73 126.83,42.79 126.83,41.75 123.89,38.81 123.89,31.57 123.97,31.49 124.39,31.49 124.48,31.4 124.48,31.28 124.39,31.19 123.97,31.19 123.89,31.11 123.89,29.62 v1(124.28,29.22)
  BOTTOM w0.089: U6.AY54 143.72,78.33 v1(143.26,78.79)
  BOTTOM w0.102: v1(124.28,29.22) 123.6,28.54 JDIMM1.50
DDR_A_D23: length 64.2
  IN4 w0.076: v1(124.28,27.7) 124.58,27.7 124.71,27.82 124.71,31.73 124.65,31.8 124.29,31.8 124.19,31.89 124.19,32.02 124.29,32.11 124.88,32.11 124.97,32.2 124.97,32.33 124.88,32.42 124.28,32.42 124.21,32.5 124.21,38.8 127.06,41.65 127.06,42.69 129,44.64 129,46.85 129.86,47.7 141.87,59.71 141.87,68.7 143.78,70.61 143.78,76.77 143.88,76.87 143.88,78.3 143.94,78.37 144.52,78.37 144.73,78.58 v1(144.73,78.79)
  BOTTOM w0.089: v1(144.73,78.79) 145.07,78.45 U6.AY53
  BOTTOM w0.102: JDIMM1.52 124.2,27.61 v1(124.28,27.7)
DDR_A_D24: length 65.3
  IN4 w0.076: v1(148.67,78.71) 148.22,78.26 148.22,77.93 147.88,77.59 147.65,77.59 147.09,77.03 146.61,77.03 145.21,75.63 145.21,70.07 143.27,68.12 143.27,59.13 130.4,46.27 130.4,42.95 128.8,41.35 128.8,41.24 129.36,40.68 129.36,40.55 129.27,40.46 129.15,40.46 128.59,41.02 128.48,41.02 128.37,40.91 128.37,40.81 128.93,40.25 128.93,40.12 128.84,40.03 128.71,40.03 128.15,40.59 128.05,40.59 127.94,40.48 127.94,40.38 128.45,39.87 128.45,39.74 128.36,39.65 128.23,39.65 127.72,40.16 127.62,40.16 126.75,39.29 126.75,34.6 126.86,34.5 127.63,34.5 127.72,34.58 127.72,34.71 127.63,34.8 127.22,34.8 127.14,34.88 127.14,35.03 127.22,35.11 127.66,35.11 127.75,35.19 127.75,35.32 127.66,35.41 127.22,35.41 127.14,35.49 v1(127.14,35.88)
  BOTTOM w0.089: U6.AY47 149.12,78.26 v1(148.67,78.71)
  BOTTOM w0.102: v1(127.14,35.88) 126.77,35.88 126.3,35.41 JDIMM1.59
DDR_A_D25: length 64.7
  IN4 w0.076: v1(147.73,78.82) 147.7,78.82 147.27,78.38 147.27,77.9 146.87,77.5 145.96,77.5 144.71,76.26 144.71,70.22 142.81,68.31 142.81,59.32 130.38,46.89 129.94,46.46 129.94,43.13 126.23,39.42 126.23,32.25 126.3,32.17 126.53,32.17 126.62,32.08 126.62,31.95 126.53,31.87 126.3,31.87 126.23,31.79 126.23,31.64 126.3,31.56 126.52,31.56 126.6,31.47 126.6,31.34 126.52,31.26 126.3,31.26 126.23,31.18 126.23,29.62 v1(126.62,29.22)
  BOTTOM w0.089: U6.AY49 148.21,78.34 v1(147.73,78.82)
  BOTTOM w0.102: v1(126.62,29.22) 125.4,28 JDIMM1.56
DDR_A_D26: length 63.8
  IN4 w0.076: v1(148.67,78.01) 147.96,77.31 147.66,77.31 146.99,76.64 146.99,75.76 146.23,75 146.23,70.76 143.5,68.03 143.5,59.04 130.63,46.17 130.63,42.42 130.55,42.34 130.28,42.34 130.2,42.27 130.2,42.11 130.28,42.04 130.55,42.04 130.63,41.96 130.63,41.5 130.5,41.37 130.39,41.37 129.83,41.94 129.72,41.94 129.61,41.83 129.61,41.72 130.18,41.16 130.18,41.05 130.07,40.94 129.96,40.94 129.4,41.51 129.29,41.51 129.18,41.4 129.18,41.29 129.75,40.72 129.75,40.62 128.55,39.42 127.2,39.42 127.11,39.33 127.11,39.21 127.2,39.12 128.24,39.12 128.33,39.03 128.33,38.85 128.26,38.78 127.39,38.78 127.3,38.69 127.3,38.56 127.39,38.47 128.26,38.47 128.33,38.39 128.33,38.24 128.26,38.17 127.61,38.17 127.53,38.08 127.53,37.95 127.61,37.86 127.91,37.86 128,37.77 128,37.63 127.91,37.54 127.27,37.54 127.14,37.41 v1(127.14,37.4)
  BOTTOM w0.089: U6.BA47 149.12,77.56 v1(148.67,78.01)
  BOTTOM w0.102: v1(127.14,37.4) 125.7,35.96 JDIMM1.57
DDR_A_D27: length 65.9
  IN4 w0.076: v1(129.66,35.88) 129.58,35.88 129.45,35.75 129.45,35.49 129.53,35.41 129.81,35.41 129.88,35.33 129.88,35.18 129.81,35.11 129.53,35.11 129.45,35.03 129.45,34.88 129.53,34.8 129.81,34.8 129.88,34.72 129.88,34.57 129.81,34.5 129.53,34.5 129.45,34.42 129.45,34.27 129.53,34.19 129.81,34.19 129.88,34.11 129.88,33.96 129.81,33.89 129.53,33.89 129.45,33.81 129.45,33.2 129.58,33.07 130.19,33.07 130.32,33.2 130.32,39.28 131.98,40.94 131.98,45.61 145.77,59.41 145.77,66.19 145.7,66.27 144.93,66.27 144.84,66.36 144.84,66.49 144.93,66.58 145.7,66.58 145.77,66.65 145.77,66.8 145.7,66.88 144.93,66.88 144.84,66.97 144.84,67.1 144.93,67.19 145.7,67.19 145.77,67.26 145.77,67.41 145.7,67.49 145.17,67.49 145.08,67.58 145.08,67.71 145.17,67.79 145.7,67.79 145.77,67.87 145.77,68.4 149.15,71.77 149.15,75.86 149.55,76.27 149.55,76.59 150.55,77.58 v1(150.55,78.01)
  BOTTOM w0.089: v1(150.55,78.01) 151,77.56 U6.BA45
  BOTTOM w0.102: v1(129.66,35.88) 129.3,35.52 JDIMM1.69
DDR_A_D28: length 67
  IN4 w0.076: v1(129.66,37.4) 130.06,37.81 130.06,39.35 131.75,41.03 131.75,45.71 144.61,58.58 144.61,61.32 144.69,61.39 145.04,61.39 145.13,61.48 145.13,61.61 145.04,61.7 144.69,61.7 144.61,61.78 144.61,61.93 144.69,62 145.46,62 145.55,62.09 145.55,62.22 145.46,62.31 144.69,62.31 144.61,62.38 144.61,62.54 144.69,62.61 145.46,62.61 145.55,62.7 145.55,62.83 145.46,62.92 144.69,62.92 144.61,62.99 144.61,63.15 144.69,63.22 145.46,63.22 145.55,63.31 145.55,63.44 145.46,63.53 144.69,63.53 144.61,63.6 144.61,63.76 144.69,63.83 145.46,63.83 145.55,63.92 145.55,64.05 145.46,64.14 144.69,64.14 144.61,64.21 144.61,64.37 144.69,64.44 145.46,64.44 145.55,64.53 145.55,64.66 145.46,64.75 144.69,64.75 144.61,64.82 144.61,64.98 144.69,65.05 145.46,65.05 145.55,65.14 145.55,65.27 145.46,65.36 144.69,65.36 144.61,65.43 144.61,65.59 144.69,65.66 145.46,65.66 145.55,65.75 145.55,65.88 145.46,65.97 144.69,65.97 144.61,66.04 144.61,67.56 147.75,70.69 147.75,72.43 148.77,73.45 148.77,76.69 149.18,77.11 149.68,77.11 150.05,77.48 150.05,78.21 v1(150.55,78.71)
  BOTTOM w0.089: U6.AY45 151,78.26 v1(150.55,78.71)
  BOTTOM w0.102: v1(129.66,37.4) 128.7,36.45 JDIMM1.67
DDR_A_D29: length 67.8
  IN4 w0.076: v1(151.49,78.71) 151.05,78.28 151.05,77.46 149.37,75.79 149.37,71.67 146,68.3 146,59.32 132.2,45.52 132.2,40.84 130.57,39.21 130.57,32.92 130.49,32.84 129.68,32.84 129.59,32.76 129.59,32.63 129.68,32.54 130.49,32.54 130.57,32.46 130.57,32.31 130.49,32.24 129.67,32.24 129.58,32.15 129.58,32.02 129.67,31.93 130.49,31.93 130.57,31.85 130.57,31.7 130.49,31.63 129.88,31.63 129.79,31.54 129.79,31.41 129.88,31.32 130.49,31.32 130.57,31.24 130.57,31.09 130.49,31.02 130.07,31.02 129.99,30.94 129.99,29.62 v1(129.6,29.22)
  BOTTOM w0.089: U6.AY43 151.94,78.26 v1(151.49,78.71)
  BOTTOM w0.102: v1(129.6,29.22) 129,28.62 JDIMM1.68
DDR_A_D30: length 62.4
  IN4 w0.076: v1(126.62,27.7) 127.01,28.09 127.01,32.12 126.52,32.62 126.52,39.39 130.17,43.04 130.17,46.36 131.16,47.35 143.04,59.23 143.04,68.22 144.98,70.16 144.98,75.76 146.48,77.26 146.96,77.26 147.71,78.01 147.72,78.01 v1(147.73,78.01)
  BOTTOM w0.089: U6.BA49 148.18,77.56 147.73,78.01 v1(147.73,78.01)
  BOTTOM w0.102: JDIMM1.58 126,27.27 126.43,27.7 v1(126.62,27.7)
DDR_A_D31: length 66.7
  IN4 w0.076: v1(129.6,27.7) 129.6,27.76 129.73,27.88 131.09,27.88 131.19,27.98 131.19,28.12 131.09,28.22 130.08,28.22 129.99,28.31 129.99,28.44 130.08,28.53 130.75,28.53 130.82,28.6 130.82,28.76 130.75,28.83 130.04,28.83 129.95,28.92 129.95,29.05 130.04,29.14 130.75,29.14 130.82,29.21 130.82,29.37 130.75,29.44 130.45,29.44 130.36,29.53 130.36,29.66 130.45,29.75 130.75,29.75 130.82,29.82 130.82,39.14 132.43,40.75 132.43,45.42 146.23,59.22 146.23,68.2 150.4,72.38 150.4,75.57 151.49,76.65 v1(151.49,78.01)
  BOTTOM w0.089: v1(151.49,78.01) 151.94,77.56 U6.BA43
  BOTTOM w0.102: JDIMM1.70 v1(129.6,27.7)
DDR_A_D32: length 58.1
  IN4 w0.076: v1(150.2,35.88) 150.4,35.68 150.4,34.95 149.62,34.16 149.62,33.97 149.55,33.9 149.36,33.9 149.26,33.8 149.26,33.66 149.36,33.56 149.87,33.56 149.95,33.48 149.95,32.94 150.04,32.85 150.16,32.85 150.25,32.94 150.25,33.48 150.33,33.56 150.8,33.56 150.89,33.65 150.89,33.78 150.8,33.88 150.25,33.88 150.16,33.97 150.16,34.09 150.25,34.18 150.79,34.18 150.86,34.26 150.86,39.74 151.6,40.47 151.6,41.37 153.95,43.72 153.95,44.63 171.87,62.55 171.87,71.84 171.92,71.89 v1(171.92,73.01)
  BOTTOM w0.089: v1(171.92,73.01) 171.51,73.41 U6.BF14
  BOTTOM w0.102: JDIMM1.129 149.7,35.38 v1(150.2,35.88)
DDR_A_D33: length 60.8
  IN4 w0.076: v1(150.2,37.4) 150.61,37.81 150.61,38.68 150.53,38.76 150.47,38.76 150.39,38.84 150.39,38.99 150.47,39.06 150.53,39.06 150.61,39.14 150.61,39.29 150.53,39.37 150.47,39.37 150.39,39.44 150.39,39.6 150.47,39.67 150.53,39.67 150.61,39.75 150.61,39.9 150.53,39.98 150.47,39.98 150.39,40.05 150.39,40.21 150.47,40.28 150.95,40.28 151.04,40.37 151.04,40.5 150.95,40.59 150.47,40.59 150.39,40.66 150.39,41.25 150.48,41.33 150.62,41.33 150.88,41.08 150.98,41.08 151.09,41.19 151.09,41.29 150.74,41.64 150.74,41.75 150.85,41.86 150.96,41.86 151.31,41.51 151.42,41.51 151.52,41.62 151.52,41.73 151.17,42.08 151.17,42.18 151.28,42.29 151.39,42.29 151.74,41.94 151.85,41.94 151.96,42.05 151.96,42.16 151.6,42.51 151.6,42.61 151.71,42.72 151.82,42.72 152.17,42.37 152.28,42.37 152.39,42.48 152.39,42.59 152.04,42.94 152.04,43.05 152.14,43.15 152.25,43.15 152.6,42.8 152.71,42.8 152.82,42.91 152.82,43.02 152.47,43.37 152.47,43.48 152.61,43.62 152.72,43.62 153.07,43.27 153.18,43.27 153.29,43.38 153.29,43.49 152.94,43.84 152.94,43.95 153.04,44.05 153.15,44.05 153.5,43.7 153.61,43.7 153.72,43.81 153.72,43.92 153.37,44.27 153.37,44.38 171.51,62.52 171.51,75.34 v1(171.92,75.74)
  BOTTOM w0.089: U6.BC14 171.51,76.15 v1(171.92,75.74)
  BOTTOM w0.102: JDIMM1.131 150.3,35.37 150.63,35.7 150.63,36.97 v1(150.2,37.4)
DDR_A_D34: length 60.2
  IN4 w0.076: v1(173.54,75.81) 174.04,75.31 174.04,72.33 174.51,71.87 174.51,68.61 174.35,68.45 174.35,61.84 163.23,50.72 163.23,49.67 154.67,41.11 154.67,35.3 154.6,35.22 154.14,35.22 154.06,35.15 154.06,35 154.14,34.92 154.6,34.92 154.67,34.84 154.67,34.69 154.6,34.62 154.14,34.62 154.06,34.54 154.06,34.39 154.14,34.31 154.6,34.31 154.67,34.23 154.67,34.08 154.6,34.01 154.14,34.01 154.06,33.93 154.06,33.78 154.14,33.7 154.6,33.7 154.67,33.62 154.67,33.45 154.6,33.37 153.81,33.37 153.73,33.45 153.73,35.8 153.81,35.88 v1(154.01,35.88)
  BOTTOM w0.089: v1(173.54,75.81) 173.19,76.16 U6.BC11
  BOTTOM w0.102: JDIMM1.141 153.3,35.17 v1(154.01,35.88)
DDR_A_D35: length 58.4
  IN4 w0.076: v1(173.54,73.01) 173.54,72.58 174.28,71.84 174.28,68.71 174.12,68.56 174.12,61.93 162.6,50.41 162.6,50.31 163,49.9 163,49.8 162.9,49.69 162.79,49.69 162.39,50.09 162.28,50.09 162.17,49.98 162.17,49.87 162.57,49.47 162.57,49.37 162.46,49.26 162.36,49.26 161.96,49.66 161.85,49.66 161.74,49.55 161.74,49.44 162.14,49.04 162.14,48.93 162.03,48.83 161.93,48.83 161.52,49.23 161.42,49.23 161.31,49.12 161.31,49.01 161.71,48.61 161.71,48.5 161.6,48.4 161.49,48.4 161.27,48.62 161.17,48.62 161.06,48.51 161.06,48.4 161.28,48.18 161.28,48.07 154.42,41.21 154.42,40.85 154.34,40.78 153.95,40.78 153.87,40.7 153.87,40.55 153.95,40.47 154.34,40.47 154.42,40.39 154.42,40.24 154.34,40.17 153.81,40.17 153.73,40.09 153.73,39.94 153.81,39.86 154.34,39.86 154.42,39.78 154.42,39.63 154.34,39.56 153.81,39.56 153.73,39.48 153.73,39.33 153.81,39.25 154.34,39.25 154.42,39.17 154.42,39.02 154.34,38.95 153.81,38.95 153.73,38.87 153.73,38.72 153.81,38.64 154.34,38.64 154.42,38.57 154.42,37.81 v1(154.01,37.4)
  BOTTOM w0.089: v1(173.54,73.01) 173.14,73.41 U6.BF11
  BOTTOM w0.102: JDIMM1.143 153.9,35.18 154.47,35.75 154.47,36.95 v1(154.01,37.4)
DDR_A_D36: length 59.4
  IN4 w0.076: v1(171.92,74.41) 172.32,74 172.32,72.88 172.1,72.65 172.1,62.46 154.18,44.54 154.18,43.62 151.83,41.27 151.83,40.38 151.12,39.67 151.12,33.48 149.59,31.96 149.59,29.33 149.92,29.01 v1(150.54,29.01)
  BOTTOM w0.089: U6.BE14 171.57,74.76 v1(171.92,74.41)
  BOTTOM w0.102: JDIMM1.130 150,28.47 v1(150.54,29.01)
DDR_A_D37: length 60
  IN4 w0.076: v1(171.92,75.11) 172.57,74.46 172.57,72.75 172.32,72.51 172.32,69.24 172.53,69.03 172.53,62.57 154.4,44.44 154.4,43.53 152.06,41.18 152.06,40.28 151.37,39.6 151.37,33.41 151.01,33.05 151.01,32.55 150.93,32.47 150.57,32.47 150.49,32.39 150.49,32.24 150.57,32.17 150.93,32.17 151.01,32.09 151.01,27.95 v1(150.54,27.48)
  BOTTOM w0.089: U6.BD14 171.57,75.46 v1(171.92,75.11)
  BOTTOM w0.102: JDIMM1.132 150.6,27.42 v1(150.54,27.48)
DDR_A_D38: length 59.8
  IN4 w0.076: v1(173.54,75.11) 172.97,74.54 172.97,72.65 173.82,71.8 173.82,68.99 173.66,68.83 173.66,62.12 160.6,49.06 160.6,48.11 153.25,40.76 153.25,31.45 151.95,30.16 151.95,27.96 v1(152.43,27.48)
  BOTTOM w0.089: v1(173.54,75.11) 173.19,75.46 U6.BD11
  BOTTOM w0.102: JDIMM1.140 153,27.21 152.72,27.48 v1(152.43,27.48)
DDR_A_D39: length 58.8
  IN4 w0.076: v1(173.54,74.41) 173.17,74.04 173.17,72.7 174.05,71.82 174.05,68.82 173.89,68.66 173.89,62.03 160.83,48.96 160.83,47.98 153.51,40.66 153.51,30.09 v1(152.43,29.01)
  BOTTOM w0.089: U6.BE11 173.19,74.76 v1(173.54,74.41)
  BOTTOM w0.102: v1(152.43,29.01) 153.6,27.84 JDIMM1.142
DDR_A_D40: length 61.4
  IN4 w0.076: v1(156.32,37.4) 156.06,37.4 155.93,37.28 155.93,35.6 155.84,35.51 155.71,35.51 155.61,35.6 155.61,38.56 155.69,38.64 156.44,38.64 156.51,38.71 156.51,38.86 156.44,38.94 155.69,38.94 155.61,39.02 155.61,39.17 155.69,39.25 156.44,39.25 156.51,39.32 156.51,39.47 156.44,39.55 155.69,39.55 155.61,39.63 155.61,39.78 155.69,39.85 156.44,39.85 156.51,39.93 156.51,40.08 156.44,40.16 155.69,40.16 155.61,40.24 155.61,40.61 155.79,40.79 155.9,40.79 156.17,40.52 156.3,40.52 156.38,40.61 156.38,40.73 156.12,41 156.12,41.11 164.17,49.17 164.17,50.33 175.45,61.61 175.45,72 v1(175.17,72.28)
  BOTTOM w0.089: U6.BC9 174.3,75.69 174.3,74.62 174.26,74.59 174.26,73.16 175.14,72.28 v1(175.17,72.28)
  BOTTOM w0.102: v1(156.32,37.4) 155.1,36.18 JDIMM1.147
DDR_A_D41: length 60.2
  IN4 w0.076: v1(175.17,72.98) 174.8,72.61 174.8,72.13 175.22,71.71 175.22,61.7 163.94,50.43 163.94,49.3 155.38,40.74 155.38,35.35 155.46,35.28 156.14,35.28 156.23,35.19 156.23,35.06 156.14,34.97 155.46,34.97 155.38,34.9 155.38,34.75 155.46,34.67 156.13,34.67 156.22,34.58 156.22,34.45 156.13,34.36 155.46,34.36 155.38,34.29 155.38,34.14 155.46,34.06 156.09,34.06 156.18,33.97 156.18,33.84 156.09,33.75 155.51,33.75 155.38,33.63 155.38,33.45 155.51,33.32 156.2,33.32 156.6,33.72 156.6,35.6 v1(156.32,35.88)
  BOTTOM w0.089: v1(175.17,72.98) 174.45,73.7 174.45,74.45 U6.BE9
  BOTTOM w0.102: v1(156.32,35.88) 156.22,35.88 155.7,35.36 JDIMM1.149
DDR_A_D42: length 59.1
  IN4 w0.076: v1(158.34,37.4) 158.69,37.4 158.81,37.53 158.81,38.56 158.74,38.64 158.26,38.64 158.17,38.73 158.17,38.85 158.26,38.94 158.74,38.94 158.81,39.02 158.81,39.17 158.74,39.25 158.26,39.25 158.17,39.34 158.17,39.46 158.26,39.55 158.74,39.55 158.81,39.63 158.81,39.78 158.74,39.86 158.26,39.86 158.17,39.95 158.17,40.07 158.26,40.16 158.74,40.16 158.81,40.24 158.81,40.39 158.74,40.47 158.26,40.47 158.17,40.56 158.17,40.68 158.26,40.77 158.74,40.77 158.81,40.85 158.81,41.37 166.25,48.81 166.25,49 165.75,49.51 165.75,49.68 165.87,49.8 165.98,49.8 166.59,49.2 166.7,49.2 166.8,49.3 166.8,49.41 166.2,50.02 166.2,50.13 166.3,50.24 166.41,50.24 167.02,49.63 167.13,49.63 167.24,49.74 167.24,49.84 166.63,50.45 166.63,50.56 166.75,50.68 166.86,50.68 167.14,50.4 167.27,50.4 167.36,50.49 167.36,50.62 167.08,50.9 167.08,51.01 177.8,61.73 177.8,71.89 v1(177.44,72.25)
  BOTTOM w0.089: U6.BE6 176.6,74.76 177.02,74.34 177.02,73.78 176.94,73.7 176.94,72.74 v1(177.44,72.25)
  BOTTOM w0.102: JDIMM1.157 158.1,35.47 157.91,35.66 157.91,36.97 v1(158.34,37.4)
DDR_A_D43: length 61.1
  IN4 w0.076: v1(177.43,71.65) 177.43,61.69 165.52,49.77 165.52,48.51 157.95,40.94 157.95,35.24 158.02,35.16 158.35,35.16 158.43,35.09 158.43,34.93 158.35,34.86 158.02,34.86 157.95,34.78 157.95,34.63 158.02,34.55 158.18,34.55 158.27,34.46 158.27,34.34 158.18,34.25 158.02,34.25 157.95,34.17 157.95,34.02 158.02,33.94 158.19,33.94 158.28,33.85 158.28,33.73 158.19,33.64 158.02,33.64 157.95,33.56 157.95,32.48 158.07,32.35 158.72,32.35 158.85,32.48 158.85,35.81 158.78,35.88 v1(158.34,35.88)
  BOTTOM w0.089: U6.BC6 176.43,76.16 176.1,75.83 176.1,74.6 176.25,74.44 176.65,74.44 176.82,74.26 176.82,73.85 176.75,73.78 176.75,72.34 177.07,72.03 177.07,72.01
  BOTTOM w0.102: JDIMM1.159 158.7,35.52 v1(158.34,35.88) ; 177.07,72.01 v1(177.43,71.65)
DDR_A_D44: length 60.7
  IN4 w0.076: v1(154.97,27.48) 154.52,27.93 154.52,29.88 155.16,30.51 155.16,32.02 155.23,32.1 155.5,32.1 155.59,32.19 155.59,32.32 155.5,32.41 155.23,32.41 155.16,32.48 155.16,32.63 155.23,32.71 155.8,32.71 155.89,32.8 155.89,32.93 155.8,33.02 155.23,33.02 155.16,33.09 155.16,40.87 163.71,49.43 163.71,50.52 174.99,61.8 174.99,71.64 174.57,72.05 174.57,74.51 v1(175.17,75.11)
  BOTTOM w0.089: U6.BD9 174.82,75.46 v1(175.17,75.11)
  BOTTOM w0.102: JDIMM1.146 154.8,27.32 v1(154.97,27.48)
DDR_A_D45: length 59.1
  IN4 w0.076: v1(154.97,29.01) 156.12,30.16 156.12,30.81 156.04,30.88 155.78,30.88 155.69,30.97 155.69,31.1 155.78,31.19 156.04,31.19 156.12,31.26 156.12,31.42 156.04,31.49 155.47,31.49 155.38,31.58 155.38,31.71 155.47,31.8 156.04,31.8 156.12,31.87 156.12,32.92 156.83,33.63 156.83,41.47 164.4,49.04 164.4,50.24 175.69,61.52 175.69,73.16 v1(175.17,73.68)
  BOTTOM w0.089: U6.BF9 174.79,74.06 v1(175.17,73.68)
  BOTTOM w0.102: v1(154.97,29.01) 155.4,28.58 JDIMM1.148
DDR_A_D46: length 59.1
  IN4 w0.076: v1(177.43,72.83) 178.03,72.23 178.03,61.64 167.59,51.2 167.59,49.76 159.08,41.26 159.08,32.27 158.94,32.13 158.43,32.13 158.33,32.03 158.33,31.89 158.43,31.8 158.9,31.8 158.98,31.72 158.98,31.57 158.9,31.49 158.55,31.49 158.48,31.41 158.48,29.4 v1(158.87,29.01)
  BOTTOM w0.089: v1(177.43,72.83) 177.81,73.21 177.81,73.72 177.69,73.83 177.69,74.31 U6.BE5
  BOTTOM w0.102: JDIMM1.158 158.4,28.54 v1(158.87,29.01)
DDR_A_D47: length 60.1
  IN4 w0.076: v1(158.87,27.48) 159.33,27.95 159.33,30.2 159.26,30.27 158.88,30.27 158.79,30.36 158.79,30.49 158.88,30.58 159.26,30.58 159.33,30.65 159.33,30.81 159.26,30.88 158.84,30.88 158.75,30.97 158.75,31.1 158.84,31.19 159.26,31.19 159.33,31.26 159.33,41.15 167.82,49.63 167.82,51.1 178.26,61.54 178.26,73.71 v1(176.86,75.11)
  BOTTOM w0.089: v1(176.86,75.11) 176.51,75.46 U6.BD6
  BOTTOM w0.102: v1(158.87,27.48) 159,27.36 JDIMM1.160
DDR_A_D48: length 68.5
  IN4 w0.076: v1(178.54,77.62) 179.5,76.66 182.36,76.66 182.68,76.35 182.68,71.39 182.6,71.31 181.56,71.31 181.48,71.23 181.48,71.08 181.56,71.01 182.6,71.01 182.68,70.93 182.68,70.78 182.6,70.7 181.56,70.7 181.48,70.62 181.48,70.47 181.56,70.4 182.6,70.4 182.68,70.32 182.68,70.17 182.6,70.09 181.56,70.09 181.48,70.02 181.48,69.86 181.56,69.79 182.6,69.79 182.68,69.71 182.68,69.56 182.6,69.48 182.07,69.48 181.98,69.39 181.98,69.27 182.07,69.18 182.6,69.18 182.68,69.1 182.68,64.31 168.99,50.62 168.99,49.01 161.29,41.31 161.29,40.85 161.21,40.77 160.79,40.77 160.7,40.68 160.7,40.55 160.79,40.46 161.21,40.46 161.29,40.39 161.29,40.24 161.21,40.16 160.79,40.16 160.7,40.07 160.7,39.94 160.79,39.85 161.21,39.85 161.29,39.78 161.29,39.63 161.21,39.55 160.79,39.55 160.7,39.46 160.7,39.33 160.79,39.25 161.21,39.25 161.29,39.17 161.29,39.02 161.21,38.94 160.79,38.94 160.7,38.85 160.7,38.72 160.79,38.64 161.21,38.64 161.29,38.56 161.29,37.81 v1(160.88,37.4)
  BOTTOM w0.089: v1(178.54,77.62) 178.14,77.21 U6.BB4
  BOTTOM w0.102: JDIMM1.163 159.9,36.42 v1(160.88,37.4)
DDR_A_D49: length 67.4
  IN4 w0.076: v1(180.77,76.04) 181.16,76.44 182.27,76.44 182.45,76.26 182.45,75.17 180.41,73.13 180.41,68.15 180.34,68.08 179.61,68.08 179.53,67.99 179.53,67.86 179.61,67.77 180.34,67.77 180.41,67.7 180.41,67.55 180.34,67.47 179.59,67.47 179.5,67.38 179.5,67.25 179.59,67.16 180.34,67.16 180.41,67.09 180.41,65.74 180.2,65.53 180.2,65.4 180.12,65.33 179.27,65.33 179.2,65.25 179.2,65.1 179.27,65.02 180.12,65.02 180.2,64.95 180.2,64.79 180.12,64.72 179.27,64.72 179.2,64.64 179.2,64.49 179.27,64.41 180.12,64.41 180.2,64.34 180.2,64.18 180.12,64.11 179.27,64.11 179.2,64.03 179.2,63.88 179.27,63.8 180.12,63.8 180.2,63.73 180.2,63.57 180.12,63.5 179.27,63.5 179.2,63.42 179.2,63.27 179.27,63.19 180.12,63.19 180.2,63.12 180.2,62.96 180.12,62.89 179.27,62.89 179.2,62.81 179.2,62.66 179.27,62.58 180.03,62.58 180.14,62.48 180.14,62.34 180.03,62.24 179.34,62.24 179.2,62.1 179.2,61.15 168.76,50.71 168.76,49.14 160.47,40.85 160.47,36.29 v1(160.88,35.88)
  BOTTOM w0.089: v1(180.77,76.04) 180.58,75.85 179.96,75.85 U6.BC2
  BOTTOM w0.102: v1(160.88,35.88) 160.5,35.5 JDIMM1.165
DDR_A_D50: length 68.8
  IN4 w0.076: v1(164.58,37.4) 164.2,37.4 164.11,37.49 164.11,38.56 164.19,38.64 164.76,38.64 164.84,38.71 164.84,38.87 164.76,38.94 163.84,38.94 163.75,39.03 163.75,39.16 163.84,39.25 164.76,39.25 164.84,39.32 164.84,39.48 164.76,39.55 163.84,39.55 163.75,39.64 163.75,39.77 163.84,39.86 164.76,39.86 164.84,39.93 164.84,40.09 164.76,40.16 163.84,40.16 163.75,40.25 163.75,40.38 163.84,40.47 164.76,40.47 164.84,40.54 164.84,40.72 164.76,40.8 163.85,40.8 163.76,40.89 163.76,41.01 163.85,41.1 164.76,41.1 164.84,41.18 164.84,41.33 164.76,41.41 164.55,41.41 164.48,41.48 164.48,41.63 164.55,41.71 164.76,41.71 164.84,41.79 164.84,42.06 174.32,51.54 174.32,53.4 184.82,63.9 184.82,78.02 183.88,78.95 181.75,78.95 181.71,78.99 179.71,78.99 v1(179.14,78.42)
  BOTTOM w0.089: v1(179.14,78.42) 178.83,78.73 U6.AW3
  BOTTOM w0.102: v1(164.58,37.4) 163.5,36.32 JDIMM1.175
DDR_A_D51: length 68.5
  IN4 w0.076: v1(164.58,35.88) 164.08,35.88 163.96,35.75 163.96,35.52 164.03,35.45 164.3,35.45 164.37,35.37 164.37,35.22 164.3,35.14 164.03,35.14 163.96,35.07 163.96,34.91 164.03,34.84 164.3,34.84 164.37,34.76 164.37,34.61 164.3,34.53 164.03,34.53 163.96,34.46 163.96,34.3 164.03,34.23 164.3,34.23 164.37,34.15 164.37,34 164.3,33.92 164.03,33.92 163.96,33.85 163.96,32.37 163.83,32.24 163.65,32.24 163.52,32.37 163.52,41.1 174.09,51.67 174.09,53.49 184.59,63.99 184.59,77.92 183.79,78.72 181.6,78.72 181.51,78.81 180.37,78.81 v1(179.91,78.35)
  BOTTOM w0.089: v1(179.91,78.35) 179.53,78.74 U6.AW2
  BOTTOM w0.102: v1(164.58,35.88) 164.1,35.4 JDIMM1.177
DDR_A_D52: length 68.3
  IN4 w0.076: v1(160.9,29.01) 160.31,29.01 160.18,28.88 160.18,28.7 160.26,28.63 160.41,28.63 160.49,28.55 160.49,28.4 160.41,28.32 160.26,28.32 160.18,28.25 160.18,28.09 160.26,28.02 160.41,28.02 160.49,27.94 160.49,27.79 160.41,27.71 160.26,27.71 160.18,27.64 160.18,27.43 160.08,27.33 159.92,27.33 159.82,27.43 159.82,29.27 159.92,29.37 160.43,29.37 160.54,29.48 160.54,29.63 160.43,29.74 160.04,29.74 159.97,29.81 159.97,41.06 168.3,49.4 168.3,50.9 178.74,61.34 178.74,73.43 v1(181.35,76.04)
  BOTTOM w0.089: U6.BB3 179.13,76.91 179.44,76.91 179.81,76.53 180.87,76.53 v1(181.35,76.04)
  BOTTOM w0.102: v1(160.9,29.01) 160.2,28.3 JDIMM1.164
DDR_A_D53: length 67.7
  IN4 w0.076: v1(160.9,27.48) 161.3,27.88 161.3,30.09 161.22,30.16 160.3,30.16 160.22,30.24 160.22,30.44 160.3,30.51 161.39,30.51 161.48,30.6 161.48,30.73 161.39,30.82 160.29,30.82 160.19,30.91 160.19,31.04 160.29,31.13 161.4,31.13 161.49,31.22 161.49,31.35 161.4,31.44 160.31,31.44 160.22,31.52 160.22,40.96 168.53,49.27 168.53,50.81 178.97,61.25 178.97,73.07 v1(181.91,76.02)
  BOTTOM w0.089: v1(181.91,76.02) 181.21,76.72 180.02,76.72 U6.BB2
  BOTTOM w0.102: JDIMM1.166 160.8,27.38 v1(160.9,27.48)
DDR_A_D54: length 69.4
  IN4 w0.076: v1(163.35,27.48) 162.51,28.32 162.51,35.5 163.03,36.03 163.03,39.18 162.96,39.26 162.55,39.26 162.47,39.33 162.47,39.49 162.55,39.56 162.96,39.56 163.03,39.64 163.03,41.33 173.63,51.93 173.63,53.68 184.13,64.18 184.13,77.73 183.7,78.16 181.75,78.16 181.52,77.93 179.03,77.93 178.54,78.42 v1(178.54,79.24)
  BOTTOM w0.089: U6.AW4 178.13,78.84 v1(178.54,79.24)
  BOTTOM w0.102: v1(163.35,27.48) 163.2,27.34 JDIMM1.174
DDR_A_D55: length 67.9
  IN4 w0.076: v1(181.3,78.44) 181.35,78.49 183.7,78.49 184.36,77.83 184.36,64.09 173.86,53.59 173.86,51.8 163.29,41.23 163.29,35.52 163.22,35.45 162.82,35.45 162.74,35.36 162.74,35.23 162.82,35.14 163.22,35.14 163.29,35.07 163.29,34.91 163.22,34.84 162.82,34.84 162.74,34.75 162.74,34.62 162.82,34.53 163.22,34.53 163.29,34.46 163.29,34.3 163.22,34.23 163.04,34.23 162.95,34.14 162.95,34.01 163.04,33.92 163.22,33.92 163.29,33.85 163.29,32.78 162.94,32.42 162.94,29.41 v1(163.35,29.01)
  BOTTOM w0.089: U6.AW1 180.48,78.79 180.52,78.82 180.92,78.82 v1(181.3,78.44)
  BOTTOM w0.102: JDIMM1.176 163.8,28.56 v1(163.35,29.01)
DDR_A_D56: length 71.9
  IN4 w0.076: v1(179.11,80.06) 179.4,80.06 179.77,80.42 181.65,80.42 181.95,80.12 184.62,80.12 185.99,78.75 185.99,63.42 175.49,52.91 175.49,50.91 166.03,41.45 166.03,40.93 166.11,40.85 167.12,40.85 167.19,40.77 167.19,40.62 167.12,40.54 166.11,40.54 166.03,40.47 166.03,40.32 166.11,40.24 167.12,40.24 167.19,40.16 167.19,40.01 167.12,39.93 166.11,39.93 166.03,39.86 166.03,39.71 166.11,39.63 167.12,39.63 167.19,39.55 167.19,39.4 167.12,39.33 166.11,39.33 166.03,39.25 166.03,39.1 166.11,39.02 167.12,39.02 167.19,38.94 167.19,38.79 167.12,38.72 166.11,38.72 166.03,38.64 166.03,38.41 166.11,38.34 166.32,38.34 166.41,38.25 166.41,38.12 166.32,38.03 166.11,38.03 166.03,37.96 166.03,37.5 166.13,37.4 v1(167.12,37.4)
  BOTTOM w0.089: v1(179.11,80.06) 178.83,80.34 U6.AU3
  BOTTOM w0.102: v1(167.12,37.4) 165.3,35.58 JDIMM1.181
DDR_A_D57: length 70.8
  IN4 w0.076: v1(167.12,35.88) 167.12,35.35 167.05,35.28 166.74,35.28 166.65,35.19 166.65,35.06 166.74,34.97 167.05,34.97 167.12,34.89 167.12,33.33 167.05,33.25 165.88,33.25 165.81,33.33 165.81,33.59 165.88,33.67 166.72,33.67 166.8,33.74 166.8,33.9 166.72,33.97 165.88,33.97 165.81,34.05 165.81,34.2 165.88,34.28 166.72,34.28 166.8,34.35 166.8,34.51 166.72,34.58 165.88,34.58 165.81,34.66 165.81,41.58 175.26,51.04 175.26,53.01 185.76,63.51 185.76,78.66 184.53,79.89 181.86,79.89 181.66,79.68 181.26,79.68 v1(180.89,80.05)
  BOTTOM w0.089: v1(180.89,80.05) 180.49,80.46 U6.AU1
  BOTTOM w0.102: v1(167.12,35.88) 166.47,35.88 165.9,35.31 165.9,34.38 JDIMM1.183
DDR_A_D58: length 71.1
  IN4 w0.076: v1(169.04,37.4) 169.44,37.81 169.44,38.48 169.37,38.56 168.9,38.56 168.82,38.64 168.82,38.79 168.9,38.86 169.67,38.86 169.75,38.94 169.75,39.09 169.67,39.17 168.9,39.17 168.82,39.25 168.82,39.4 168.9,39.47 169.67,39.47 169.75,39.55 169.75,39.7 169.67,39.78 168.9,39.78 168.82,39.85 168.82,40.01 168.9,40.08 169.67,40.08 169.75,40.16 169.75,40.31 169.67,40.39 168.9,40.39 168.82,40.46 168.82,40.62 168.9,40.69 169.67,40.69 169.75,40.77 169.75,40.92 169.67,41 168.9,41 168.82,41.07 168.82,41.23 168.9,41.3 169.67,41.3 169.75,41.38 169.75,41.53 169.67,41.61 168.9,41.61 168.82,41.68 168.82,41.84 168.9,41.91 169.67,41.91 169.75,41.99 169.75,42.9 177.06,50.22 177.06,52.26 187.56,62.76 187.56,79.41 185.28,81.69 181.54,81.69 v1(181.53,81.68)
  BOTTOM w0.089: v1(181.53,81.68) 181.12,82.09 U6.AR1
  BOTTOM w0.102: JDIMM1.191 168.3,36.67 v1(169.04,37.4)
DDR_A_D59: length 73.4
  IN4 w0.076: v1(178.51,81.68) 178.99,82.16 181.75,82.16 181.99,81.92 185.37,81.92 187.79,79.5 187.79,62.67 177.29,52.17 177.29,50.12 169.97,42.8 169.97,42.34 170.05,42.26 170.36,42.26 170.43,42.18 170.43,42.03 170.36,41.96 170.05,41.96 169.97,41.88 169.97,41.73 170.05,41.65 170.34,41.65 170.42,41.57 170.42,41.42 170.34,41.35 170.05,41.35 169.97,41.27 169.97,41.12 170.05,41.04 170.22,41.04 170.29,40.96 170.29,40.81 170.22,40.74 170.05,40.74 169.97,40.66 169.97,40.51 170.05,40.43 170.22,40.43 170.29,40.36 170.29,40.2 170.22,40.13 170.05,40.13 169.97,40.05 169.97,39.9 170.05,39.82 170.22,39.82 170.29,39.75 170.29,39.59 170.22,39.52 170.05,39.52 169.97,39.44 169.97,39.29 170.05,39.21 170.22,39.21 170.29,39.14 170.29,38.98 170.22,38.91 170.05,38.91 169.97,38.83 169.97,38.68 170.05,38.6 170.22,38.6 170.29,38.53 170.29,38.37 170.22,38.3 169.75,38.3 169.67,38.22 169.67,38.07 169.75,37.99 170.22,37.99 170.29,37.92 170.29,37.76 170.22,37.69 169.64,37.69 169.57,37.61 169.57,37.46 169.64,37.38 170.22,37.38 170.29,37.31 170.29,37.15 170.22,37.08 169.63,37.08 169.56,37 169.56,36.85 169.63,36.77 170.22,36.77 170.29,36.7 170.29,36.55 170.22,36.47 169.63,36.47 169.56,36.39 169.56,36.24 169.63,36.16 170.19,36.16 170.27,36.09 170.27,35.96 170.19,35.88 v1(169.04,35.88)
  BOTTOM w0.089: U6.AR4 178.13,82.06 v1(178.51,81.68)
  BOTTOM w0.102: v1(169.04,35.88) 168.9,35.74 JDIMM1.193
DDR_A_D60: length 71.5
  IN4 w0.076: v1(179.92,80.06) 180.5,79.47 181.7,79.47 181.89,79.66 184.43,79.66 185.53,78.56 185.53,63.61 175.03,53.1 175.03,51.17 165.58,41.72 165.58,32.55 165.65,32.48 165.97,32.48 166.05,32.4 166.05,32.25 165.97,32.17 165.65,32.17 165.58,32.09 165.58,31.94 165.65,31.87 165.97,31.87 166.05,31.79 166.05,31.64 165.97,31.56 165.65,31.56 165.58,31.48 165.58,31.33 165.65,31.26 165.97,31.26 166.05,31.18 166.05,31.03 165.97,30.95 165.65,30.95 165.58,30.87 165.58,30.72 165.65,30.65 165.97,30.65 166.05,30.57 166.05,30.42 165.97,30.34 165.65,30.34 165.58,30.27 165.58,29.1 165.67,29.01 v1(165.98,29.01)
  BOTTOM w0.089: v1(179.92,80.06) 179.53,80.45 U6.AU2
  BOTTOM w0.102: JDIMM1.180 165,28.02 v1(165.98,29.01)
DDR_A_D61: length 72.7
  IN4 w0.076: v1(178.48,80.06) 179.26,79.27 181.8,79.27 181.96,79.43 184.34,79.43 185.3,78.47 185.3,63.7 174.8,53.2 174.8,51.3 165.32,41.82 165.32,35.44 165.25,35.36 164.93,35.36 164.86,35.29 164.86,35.14 164.93,35.06 165.25,35.06 165.32,34.98 165.32,34.83 165.25,34.75 164.93,34.75 164.86,34.68 164.86,34.53 164.93,34.45 165.25,34.45 165.32,34.37 165.32,34.22 165.25,34.14 164.93,34.14 164.86,34.07 164.86,33.92 164.93,33.84 165.25,33.84 165.32,33.76 165.32,33.61 165.25,33.53 164.72,33.53 164.63,33.45 164.63,33.32 164.72,33.23 165.25,33.23 165.32,33.15 165.32,28.14 v1(165.98,27.48)
  BOTTOM w0.089: v1(178.48,80.06) 178.13,80.41 U6.AU4
  BOTTOM w0.102: JDIMM1.182 165.6,27.1 v1(165.98,27.48)
DDR_A_D62: length 72.1
  IN4 w0.076: v1(168.95,29.01) 168.52,29.44 168.52,32.47 168.59,32.55 168.59,34.97 168.67,35.05 169.39,35.05 169.48,35.14 169.48,35.27 169.39,35.36 168.67,35.36 168.59,35.43 168.59,42.07 176.83,50.31 176.83,52.36 187.33,62.86 187.33,79.31 185.18,81.47 182.15,81.47 181.93,81.24 180.37,81.24 v1(179.92,81.68)
  BOTTOM w0.089: U6.AR2 179.53,82.08 v1(179.92,81.68)
  BOTTOM w0.102: v1(168.95,29.01) 168.51,28.58 168.51,27.31 168.6,27.23 JDIMM1.192
DDR_A_D63: length 73
  IN4 w0.076: v1(179.14,81.68) 179.82,81.01 181.99,81.01 182.22,81.24 185.09,81.24 187.11,79.22 187.11,62.95 176.6,52.45 176.6,50.4 168.34,42.14 168.34,32.62 168.29,32.57 168.29,32.11 168.21,32.03 167.79,32.03 167.7,31.94 167.7,31.82 167.79,31.73 168.21,31.73 168.29,31.65 168.29,31.47 168.21,31.4 167.79,31.4 167.7,31.31 167.7,31.18 167.79,31.09 168.21,31.09 168.29,31.02 168.29,28.14 v1(168.95,27.48)
  BOTTOM w0.089: v1(179.14,81.68) 178.83,82 U6.AR3
  BOTTOM w0.102: JDIMM1.194 169.2,27.23 v1(168.95,27.48)
DDR_A_DQS0: length 79.4
  IN4 w0.076: v1(145.42,86.1) 145.23,85.91 142.71,85.91 142.53,85.73 141.01,85.73 136.79,81.52 136.79,74.46 135.01,72.68 135.01,68.34 134.5,67.83 134.5,62.99 120.42,48.9 120.42,47.89 111.01,38.48 111.01,29.36 111.31,29.06 112,29.06 v1(112.22,28.84)
  BOTTOM w0.076: U6.AJ53 145.42,86.04 v1(145.42,86.1)
  BOTTOM w0.102: JDIMM1.12 112.2,27.25 112.11,27.34 111.97,27.34 111.83,27.48 111.83,27.85 111.72,27.96 111.72,29.02 111.92,29.22 112.08,29.22 112.22,29.08 v1(112.22,28.84)
DDR_A_DQS1: length 72.8
  IN4 w0.076: v1(145.42,82.04) 145.42,82.27 145.18,82.51 143.93,82.51 143.91,82.52 142.21,82.52 139.92,80.22 139.92,72.59 139.84,72.51 139.84,72.02 138.19,70.37 138.19,67.05 137.63,66.49 137.63,65.16 138.05,64.74 138.05,61.1 119.23,42.28 119.23,41.38 119.06,41.21 118.16,41.21 118.05,41.1 118.05,40.94 118.16,40.83 119.18,40.83 119.38,40.63 119.38,40.35 119.18,40.15 117.09,40.15 116.98,40.04 116.98,39.88 117.09,39.77 119.05,39.77 119.26,39.55 119.26,39.25 119.05,39.04 116.75,39.04 116.67,38.97 116.67,37.5 116.75,37.42 117.07,37.42 117.15,37.5 v1(117.15,37.78)
  BOTTOM w0.076: U6.AP52 145.77,82.39 v1(145.42,82.04)
  BOTTOM w0.102: JDIMM1.29 117.3,35.36 117.84,35.91 117.84,37.28 117.61,37.52 117.41,37.52 v1(117.15,37.78)
DDR_A_DQS2: length 64.8
  IN4 w0.076: v1(122.78,37.02) 123.08,37.33 123.26,37.33 123.4,37.47 123.4,39.01 124.78,40.38 124.78,40.62 124.46,40.94 124.46,41.04 124.62,41.21 124.73,41.21 125.05,40.89 125.28,40.89 125.6,41.2 125.6,41.48 124.81,42.27 124.81,42.43 124.92,42.54 125.08,42.54 125.86,41.76 126.14,41.76 126.34,41.96 126.34,42.24 125.54,43.05 125.54,43.16 125.7,43.32 125.81,43.32 126.1,43.03 126.39,43.03 126.59,43.23 126.59,43.51 126.29,43.81 126.29,43.92 126.45,44.08 126.56,44.08 126.88,43.76 127.12,43.76 127.37,44.01 127.37,44.24 127.05,44.56 127.05,44.67 127.21,44.83 127.32,44.83 127.64,44.51 127.87,44.51 128.12,44.76 128.12,45 127.8,45.32 127.8,45.43 128.29,45.92 128.29,47.14 141.16,60.01 141.16,69.1 142.84,70.78 142.84,78.95 143.07,79.18 144.97,79.18 v1(145.36,78.79)
  BOTTOM w0.102: JDIMM1.47 122.7,35.47 122.5,35.67 122.43,35.67 122.33,35.77 122.33,37.16 122.46,37.29 122.52,37.29 v1(122.78,37.02) ; v1(145.36,78.79) 145.36,78.84 145.07,79.13 U6.AW53
DDR_A_DQS3: length 64.6
  IN4 w0.076: v1(149.61,78.01) 149.33,78.28 149.26,78.28 149.2,78.23 149.2,77.38 148.77,76.94 148.06,76.94 147.9,76.78 147.9,74.56 146.87,73.53 146.87,70.5 144.13,67.76 144.13,58.78 131.26,45.91 131.26,41.23 128.97,38.94 128.97,31.31 129.04,31.24 129.28,31.24 129.45,31.07 129.45,30.72 129.28,30.55 129.04,30.55 128.97,30.47 128.97,29.29 128.82,29.15 128.48,29.15 128.33,28.99 v1(128.33,28.84)
  BOTTOM w0.089: U6.BA46 150.06,77.56 v1(149.61,78.01)
  BOTTOM w0.102: JDIMM1.64 127.8,27.1 127.6,27.29 127.6,28.99 127.85,29.23 128.16,29.23 128.33,29.05 v1(128.33,28.84)
