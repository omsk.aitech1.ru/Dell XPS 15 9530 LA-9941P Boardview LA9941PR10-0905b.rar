# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_GTX_C_HRX_N13: length 32.7
  TOP w0.114: v1(173.48,104.3) 173.31,104.47 173.06,104.47 172.76,104.76 172.76,105.83 173.16,106.22 176.12,106.22 177.04,105.3 178.55,105.3 178.57,105.32 179.48,105.32 179.5,105.3 181.62,105.3 188.53,98.39 195.23,98.39 196.55,99.71 CV563.2
  BOTTOM w0.089: v1(173.48,104.3) 173.5,104.3 U6.B10
PEG_GTX_C_HRX_N14: length 37.9
  TOP w0.114: v1(173.48,103.62) 173.59,103.51 173.59,103.4 173.48,103.28 172.76,103.28 172.17,103.88 172.17,105.95 172.94,106.72 180.91,106.72 188.69,98.94 v9(191.63,98.94) 194.94,98.94 196.4,100.4 200.41,100.4 200.49,100.31 200.49,100.03 200.61,99.91 200.89,99.91 CV565.2
  BOTTOM w0.089: v1(173.48,103.62) U6.C10
PEG_GTX_C_HRX_N15: length 38.7
  TOP w0.114: v1(173.48,102.22) 173.48,102.03 173.32,101.87 173.11,101.87 171.32,103.66 171.32,106.12 172.65,107.45 181.22,107.45 v9(187.02,101.65) 188.52,100.15 193.61,100.15 195.24,101.78 198.4,101.78 198.49,101.69 198.49,101.2 198.58,101.11 CV567.2
  BOTTOM w0.089: U6.E10 v1(173.48,102.22)
PEG_GTX_C_HRX_P0: length 29.4
  TOP w0.114: CV531.2 198.64,85.6 198.09,85.6 197.71,85.23 197.38,85.23 197.27,85.34 197.27,85.75 197.03,86 196.5,86 196.26,85.75 196.26,85.34 196.15,85.23 195.81,85.23 195.69,85.34 195.69,85.75 195.45,86 194.93,86 194.69,85.75 194.69,85.34 194.57,85.23 194.23,85.23 194.12,85.34 194.12,85.75 193.88,86 193.35,86 193.11,85.75 193.11,85.34 193,85.23 191.56,85.23 190.07,83.74 v9(189.55,83.74) 186.43,83.74 183.81,86.36 183.81,87.26 183.36,87.71 183.02,87.71 182.85,87.54 182.69,87.54 182.45,87.78 182.45,87.95 182.62,88.11 182.62,88.45 181.78,89.29 181.78,90.69 181.04,91.42 181.04,91.64 180.79,91.89 180.6,91.89 180.47,91.77 180.47,91.58 180.6,91.46 v1(180.61,91.46)
  BOTTOM w0.089: U6.Y1 180.24,91.84 180.61,91.48 v1(180.61,91.46)
PEG_GTX_C_HRX_P1: length 29.4
  TOP w0.114: CV533.2 200.6,84.51 v9(194.24,84.51) 191.86,84.51 190.35,83.01 186.16,83.01 181.27,87.9 180.91,87.9 179.44,89.36 179.44,91.26 179.2,91.5 179.02,91.5 178.64,91.88 178.3,91.88 177.88,91.46 v1(177.77,91.46)
  BOTTOM w0.089: v1(177.77,91.46) 177.77,91.48 U6.Y4
PEG_GTX_C_HRX_P2: length 32.7
  TOP w0.114: v1(179.88,93.06) 180.03,92.9 180.03,92.55 180.32,92.26 181.42,92.26 182.22,91.46 182.22,89.55 184.3,87.47 184.3,86.57 186.53,84.34 187.22,84.34 187.24,84.32 187.79,84.32 187.81,84.34 189.13,84.34 189.35,84.57 189.35,86.38 189.47,86.49 189.81,86.49 189.93,86.38 189.93,85.29 190.15,85.07 190.7,85.07 190.93,85.29 190.93,86.38 191.04,86.49 191.39,86.49 191.5,86.38 191.5,85.95 191.73,85.72 192.28,85.72 192.5,85.95 192.5,86.38 192.62,86.49 200.7,86.49 CV535.2
  BOTTOM w0.089: U6.V2 179.53,92.71 v1(179.88,93.06)
PEG_GTX_C_HRX_P3: length 32.2
  TOP w0.114: 182.1,92.75 181.38,93.48 179.02,93.48 178.92,93.38 178.92,93.16 179.02,93.06 v1(179.18,93.06) ; 182.1,92.75 182.93,91.93 182.93,89.85 185.01,87.76 185.01,86.86 186.2,85.67 186.7,85.67 186.95,85.93 186.95,87.09 187.07,87.2 187.41,87.2 187.52,87.09 187.52,85.31 187.78,85.05 188.27,85.05 188.53,85.31 188.53,87.09 188.64,87.2 197.91,87.2 198.16,87.45 198.16,87.82 198.26,87.93 198.5,87.93 CV537.2 ; 182.1,92.75 v9(182.1,92.74)
  BOTTOM w0.089: v1(179.18,93.06) 179.09,93.06 178.83,92.8 U6.V3
PEG_GTX_C_HRX_P4: length 31.4
  TOP w0.114: v1(177.77,92.22) 177.76,92.23 177.76,92.98 178.84,94.05 181.81,94.05 183.68,92.18 183.68,91.26 183.66,91.24 183.66,90.69 183.68,90.67 183.68,90.1 185.87,87.91 v9(193.15,87.91) 195.5,87.91 195.76,88.17 195.76,88.87 195.85,88.97 196.19,88.97 196.31,88.85 196.31,88.15 196.55,87.91 197.07,87.91 197.31,88.15 197.31,88.85 197.43,88.97 200.51,88.97 CV539.2
  BOTTOM w0.089: v1(177.77,92.22) 177.43,91.88 U6.Y5
PEG_GTX_C_HRX_P5: length 29.7
  TOP w0.114: v1(180.59,96.31) 180.74,96.16 180.74,95.68 181.04,95.37 181.5,95.37 182.94,93.93 184.39,92.48 184.39,90.4 186.16,88.62 187.98,88.62 188.22,88.86 188.22,89.41 188.34,89.52 188.68,89.52 188.79,89.41 188.79,88.86 189.03,88.62 189.56,88.62 189.8,88.86 189.8,89.41 189.91,89.52 193.78,89.52 193.88,89.42 193.88,88.9 194.16,88.62 194.66,88.62 194.91,88.88 194.91,89.82 195.03,89.93 198.78,89.93 CV541.2
  BOTTOM w0.089: v1(180.59,96.31) 180.59,96.08 180.68,95.99 180.88,95.99 180.99,96.11 180.99,96.76 180.74,97.02 180.24,97.02 180.16,96.93 180.16,96.79 U6.M1
PEG_GTX_C_HRX_P6: length 33.2
  TOP w0.114: CV543.2 200.52,91.24 199.5,91.24 199.41,91.16 198.33,91.16 198.22,91.04 198.22,90.88 197.98,90.64 197.46,90.64 197.22,90.88 197.22,91.37 197.09,91.49 196.77,91.49 196.64,91.37 196.64,90.88 196.4,90.64 195.88,90.64 195.64,90.88 195.64,91.37 195.51,91.49 195.2,91.49 195.07,91.37 195.07,90.88 194.83,90.64 194.31,90.64 194.07,90.88 194.07,91.04 193.95,91.16 193.61,91.16 193.49,91.04 193.49,90.49 193.24,90.23 187.52,90.23 187.41,90.12 187.41,89.59 187.16,89.34 186.66,89.34 186.41,89.59 186.41,90.12 186.29,90.23 185.56,90.23 185.1,90.69 185.1,93.07 184.29,93.89 184.24,93.89 183.83,94.29 183.83,94.34 182.31,95.87 182.12,96.06 182.12,96.13 181.43,96.81 180.12,96.81 179.38,97.54 178.96,97.54 178.85,97.43 178.85,97.25 178.97,97.12 v1(179.18,97.12)
  BOTTOM w0.089: U6.L3 178.83,97.48 v1(179.18,97.12)
PEG_GTX_C_HRX_P7: length 33.1
  TOP w0.114: v1(179.17,96.34) 178.73,95.91 178.27,95.91 177.62,96.56 177.62,97.24 178.68,98.31 179.76,98.31 180.35,97.72 181.83,97.72 186.06,93.5 186.06,92.56 186.07,92.54 186.07,91.98 186.06,91.96 186.06,91.29 186.18,91.16 186.58,91.16 186.7,91.29 186.7,92.17 186.96,92.42 187.48,92.42 187.72,92.18 187.72,91.75 187.84,91.63 188.18,91.63 188.29,91.75 188.29,92.18 188.53,92.42 189.06,92.42 189.3,92.18 189.3,91.75 189.41,91.63 190.62,91.63 190.87,91.38 190.87,91.3 191.01,91.16 192.3,91.16 193.56,92.42 v9(194.22,92.42) 196.59,92.42 197.02,92.85 CV545.2
  BOTTOM w0.089: v1(179.17,96.34) 179.17,96.38 U6.M3
PEG_GTX_C_HRX_P8: length 32.4
  TOP w0.114: v1(182.13,98.19) 181.91,98.41 181.84,98.41 181.71,98.54 181.71,98.67 181.85,98.81 182.37,98.81 182.82,98.36 182.82,98.2 182.6,97.98 182.6,97.65 182.99,97.27 183.31,97.27 183.53,97.49 183.7,97.49 183.94,97.25 183.94,97.09 183.71,96.86 183.71,96.54 184.1,96.15 184.42,96.15 184.65,96.38 184.81,96.38 185.05,96.13 185.05,95.97 184.83,95.75 184.83,95.42 185.22,95.04 185.54,95.04 185.76,95.26 185.92,95.26 186.17,95.02 186.17,94.86 185.94,94.63 185.94,94.31 187.28,92.97 189.78,92.97 189.9,92.86 189.9,92.38 190.15,92.13 190.65,92.13 190.9,92.38 190.9,92.86 191.01,92.97 191.36,92.97 191.45,92.88 191.45,92.06 191.72,91.78 192.22,91.78 192.47,92.03 192.47,92.86 192.59,92.97 196.12,92.97 196.68,93.53 200.39,93.53 200.48,93.44 200.48,93.21 200.58,93.11 CV547.2
  BOTTOM w0.089: U6.L1 180.17,97.59 180.17,97.73 180.26,97.82 180.48,97.82 180.84,97.47 181.48,97.47 181.68,97.68 181.68,97.84 182.03,98.19 182.09,98.19
  BOTTOM w0.114: 182.09,98.19 v1(182.13,98.19)
PEG_GTX_C_HRX_P9: length 28.4
  TOP w0.114: CV550.2 198.7,94.59 196.73,94.59 195.87,93.73 v9(190.64,93.73) 188.46,93.73 188.14,94.05 187.98,94.05 187.76,93.82 187.44,93.82 187.05,94.21 187.05,94.53 187.27,94.76 187.27,94.92 184.44,97.75 184.44,98 182.81,99.63 179.97,99.63 179.81,99.47 179.81,98.91 179.58,98.69 177.95,98.69 177.78,98.51 177.78,97.72 177.48,97.42 177.27,97.42 177.08,97.24 v1(177.08,97.12)
  BOTTOM w0.089: v1(177.08,97.12) 177.43,96.78 U6.M5
PEG_GTX_C_HRX_P10: length 34
  TOP w0.114: CV552.2 200.7,97.92 197.04,97.92 195.67,96.55 189.03,96.55 182.29,103.28 v9(180.05,103.28) 179.48,103.28 179.24,103.53 178.72,103.53 177.72,104.53 175.54,104.53 175.27,104.8 175.27,105.02 v1(175.08,105.21)
  BOTTOM w0.089: U6.A9 174.61,104.53 174.52,104.53 174.38,104.67 174.38,105.17 174.83,105.62 175.34,105.62 175.51,105.45 175.51,105.06 175.25,104.81 175.09,104.81 174.96,104.94 174.96,105.1 v1(175.08,105.21)
PEG_GTX_C_HRX_P11: length 31.5
  TOP w0.114: CV558.2 198.78,97.17 196.99,97.17 195.87,96.05 192.87,96.05 192.63,95.81 192.63,95.58 192.52,95.46 192.29,95.46 192.17,95.58 192.17,95.81 191.93,96.05 191.52,96.05 191.28,95.81 191.28,95.58 191.17,95.46 190.94,95.46 190.83,95.58 190.83,95.81 190.59,96.05 188.82,96.05 182.59,102.28 v9(181.52,102.28) 179.77,102.28 179.03,103.02 178.48,103.02 177.27,104.24 175.6,104.24 175.28,103.92 175.28,103.45 175.16,103.33 174.91,103.33 174.79,103.21 174.79,103.04 174.91,102.92 v1(175.11,102.92)
  BOTTOM w0.089: v1(175.11,102.92) 174.78,103.24 U6.C9
PEG_GTX_C_HRX_P12: length 31.7
  TOP w0.114: v1(175.08,101.48) 174.79,101.48 174.69,101.37 174.69,101.13 174.79,101.02 175.32,101.02 175.34,101.04 176.19,101.04 176.21,101.02 178.92,101.02 179.37,100.58 v9(181.09,100.58) 183.19,100.58 188.64,95.13 189.43,95.13 189.81,94.75 195.58,94.75 196.34,95.51 197.18,95.51 197.29,95.63 197.29,96.22 197.53,96.46 198.05,96.46 198.3,96.22 198.3,96.02 198.41,95.9 200.56,95.9 CV560.2
  BOTTOM w0.089: U6.F9 174.74,101.14 v1(175.08,101.48)
PEG_GTX_C_HRX_P13: length 32.7
  TOP w0.114: CV562.2 198.73,98.82 198.53,99.03 198.53,99.33 198.36,99.49 196.64,99.49 195.32,98.18 188.44,98.18 181.53,105.09 v9(179,105.09) 176.95,105.09 176.03,106.01 173.25,106.01 172.98,105.74 172.98,104.85 173.15,104.68 173.36,104.68 173.48,104.8 v1(173.48,105.02)
  BOTTOM w0.089: U6.A10 v1(173.48,105.02)
PEG_GTX_C_HRX_P14: length 38
  TOP w0.114: CV564.2 200.7,100.61 196.31,100.61 194.85,99.16 191.93,99.16 191.91,99.18 191.35,99.18 191.32,99.16 188.78,99.16 182.46,105.48 181,106.94 172.85,106.94 171.96,106.04 171.96,103.79 172.67,103.07 173.3,103.07 v1(173.48,102.88)
  BOTTOM w0.089: U6.D10 173.82,102.54 v1(173.48,102.88)
PEG_GTX_C_HRX_P15: length 38.8
  TOP w0.114: CV566.2 195.15,102 193.52,100.36 188.61,100.36 187.39,101.59 187.39,101.62 187,102.02 186.96,102.02 181.31,107.67 172.57,107.67 171.11,106.21 171.11,103.57 173.02,101.66 173.34,101.66 v1(173.48,101.52)
  BOTTOM w0.089: v1(173.48,101.52) 173.66,101.52 173.86,101.33 U6.F10
PEG_GTX_HRX_N0: length 9.3
  TOP w0.114: CV532.1 200.28,85.44 203.02,85.44 v9(204.46,86.87) 205.32,87.74 206.44,87.74 206.88,88.19 206.88,88.45 v1(207.07,88.64)
  BOTTOM w0.089: UV1.AJ14 206.71,89 v1(207.07,88.64)
PEG_GTX_HRX_N1: length 10
  TOP w0.114: CV534.1 202,84.11 v9(203.08,84.11) 203.76,84.11 204.38,84.73 204.38,85.72 205.83,87.17 206.78,87.17 207.48,87.87 208.18,87.87 208.47,88.16 208.47,88.38 208.69,88.6 v1(208.7,88.6)
  BOTTOM w0.089: v1(208.7,88.6) UV1.AG14
PEG_GTX_HRX_N2: length 8.8
  TOP w0.114: CV536.1 202.19,86.8 202.58,86.8 202.93,87.16 202.98,87.16 203.4,87.57 203.4,87.75 203.29,87.86 203.29,88.2 203.66,88.57 204,88.57 v9(204.3,88.27) 204.34,88.23 204.34,88.22 204.47,88.09 204.63,88.09 204.88,88.34 204.88,88.5 204.4,88.97 204.4,89.31 204.77,89.68 205.11,89.68 205.22,89.57 205.39,89.57 205.71,89.9 205.97,89.9 v1(206.26,90.19)
  BOTTOM w0.089: UV1.AJ15 v1(206.26,90.19)
PEG_GTX_HRX_N3: length 7.4
  TOP w0.114: CV538.1 200.28,87.94 202.01,87.94 v9(203.88,89.82) 204.8,90.74 205.1,90.74 v1(205.41,91.04)
  BOTTOM w0.089: UV1.AK16 v1(205.41,91.04)
PEG_GTX_HRX_N4: length 7.1
  TOP w0.114: v1(207.05,91.1) 206.92,91.1 206.74,91.28 206.74,91.47 206.47,91.74 205.02,91.74 202.7,89.42 CV540.1
  BOTTOM w0.089: v1(207.05,91.1) UV1.AJ17
PEG_GTX_HRX_N5: length 11
  TOP w0.114: CV542.1 200.28,90.23 202.79,90.23 204.82,92.26 206.88,92.26 207.23,91.92 208.2,91.92 208.53,91.59 208.53,91.26 v1(208.7,91.1)
  BOTTOM w0.089: v1(208.7,91.1) UV1.AG17
PEG_GTX_HRX_N6: length 5.7
  TOP w0.114: v1(206.26,92.66) 205.82,93.1 205.07,93.1 203.68,91.71 CV544.1
  BOTTOM w0.089: UV1.AJ18 206.62,92.3 v1(206.26,92.66)
PEG_GTX_HRX_N7: length 6.6
  TOP w0.114: CV546.1 200.19,92.2 203.84,92.2 205.15,93.51 v1(205.41,93.51)
  BOTTOM w0.089: UV1.AK19 205.77,93.15 v1(205.41,93.51)
PEG_GTX_HRX_N8: length 6.1
  TOP w0.114: v1(207.05,93.6) 206.55,94.1 204.29,94.1 204.23,94.17 202.39,94.17 202.22,94 CV548.1
  BOTTOM w0.089: v1(207.05,93.6) UV1.AJ20
PEG_GTX_HRX_N9: length 10.1
  TOP w0.114: v1(208.7,93.6) 208.53,93.76 208.53,94.03 208.04,94.52 204.74,94.52 204.46,94.8 203.69,94.8 203.67,94.82 202.88,94.82 202.86,94.8 200.28,94.8 CV551.1
  BOTTOM w0.089: v1(208.7,93.6) UV1.AG20
PEG_GTX_HRX_N10: length 6.9
  TOP w0.114: v1(206.23,95.32) 205.95,95.6 205.95,96.37 205.58,96.74 204.26,96.74 v9(202.92,98.07) 202.63,98.36 202.06,98.36 CV557.1
  BOTTOM w0.089: UV1.AJ21 206.65,94.9 v1(206.23,95.32)
PEG_GTX_HRX_N11: length 7
  TOP w0.114: CV559.1 200.22,96.81 202.22,96.81 202.45,96.58 202.45,96.13 202.7,95.88 204.18,95.88 204.34,95.72 v2(204.98,95.72) v1(205.36,96.09)
  BOTTOM w0.089: v1(205.36,96.09) 205.8,95.65 UV1.AK22
PEG_GTX_HRX_N12: length 7
  TOP w0.114: v1(206.93,95.98) 206.93,95.18 206.48,94.72 205.14,94.72 204.68,95.18 203.86,95.18 203.65,95.39 CV561.1
  BOTTOM w0.089: v1(206.93,95.98) 206.93,96.33 206.76,96.5 UV1.AJ23
PEG_GTX_HRX_N13: length 11
  TOP w0.114: CV563.1 200.24,99.42 202.22,99.42 204.48,97.16 207.92,97.16 208.53,96.54 208.53,96.26 v1(208.7,96.1)
  BOTTOM w0.089: v1(208.7,96.1) UV1.AG23
PEG_GTX_HRX_N14: length 6.7
  TOP w0.114: CV565.1 202.84,99.96 202.97,99.83 202.97,98.95 204.56,97.36 205.84,97.36 v1(206.22,97.73)
  BOTTOM w0.089: v1(206.22,97.73) UV1.AJ24
PEG_GTX_HRX_N15: length 8.5
  TOP w0.114: CV567.1 200.28,101.44 202.36,101.44 v9(203.03,100.77) 203.69,100.11 203.69,98.82 204.36,98.15 204.71,98.15 205.14,98.58 v1(205.37,98.58)
  BOTTOM w0.089: v1(205.37,98.58) UV1.AK25
PEG_GTX_HRX_P0: length 9.4
  TOP w0.114: v1(206.22,88.57) 206.31,88.66 206.54,88.66 206.67,88.53 206.67,88.27 206.35,87.96 205.23,87.96 204.56,87.28 204.49,87.28 204,86.79 204,86.72 202.93,85.66 200.28,85.66 CV531.1
  BOTTOM w0.089: UV1.AK14 205.8,89 v1(206.22,88.57)
PEG_GTX_HRX_P1: length 10
  TOP w0.114: v1(207.89,88.6) 208.12,88.6 208.26,88.47 208.26,88.25 208.09,88.08 207.39,88.08 206.69,87.38 205.74,87.38 204.17,85.81 204.17,84.82 203.67,84.32 203.41,84.32 203.4,84.34 202.63,84.34 202.62,84.32 202.38,84.32 CV533.1
  BOTTOM w0.089: v1(207.89,88.6) 207.5,88.99 UV1.AH14
PEG_GTX_HRX_P2: length 8.8
  TOP w0.114: v1(206.26,89.39) 205.97,89.68 205.8,89.68 205.48,89.36 205.13,89.36 205.02,89.47 204.86,89.47 204.62,89.22 204.62,89.06 205.09,88.59 205.09,88.25 204.72,87.88 204.34,87.88 203.87,88.35 203.75,88.35 203.5,88.11 203.5,87.95 203.62,87.84 203.62,87.48 v9(202.88,86.75) 202.72,86.58 202.19,86.58 CV535.1
  BOTTOM w0.089: UV1.AK15 205.85,89.8 v1(206.26,89.39)
PEG_GTX_HRX_P3: length 7.5
  TOP w0.114: CV537.1 200.28,87.73 202.1,87.73 203.73,89.37 203.77,89.37 204.3,89.9 204.3,89.94 204.89,90.52 205.14,90.52 v1(205.41,90.25)
  BOTTOM w0.089: v1(205.41,90.25) 205.01,90.65 UV1.AL16
PEG_GTX_HRX_P4: length 7.1
  TOP w0.114: CV539.1 202.53,89.21 202.79,89.21 205.11,91.53 206.38,91.53 206.53,91.38 206.53,91.25 206.38,91.1 v1(206.2,91.1)
  BOTTOM w0.089: v1(206.2,91.1) UV1.AK17
PEG_GTX_HRX_P5: length 10.9
  TOP w0.114: v1(207.9,91.1) 208.22,91.1 208.32,91.2 208.32,91.5 208.11,91.7 207.14,91.7 206.79,92.05 204.91,92.05 202.88,90.01 200.28,90.01 CV541.1
  BOTTOM w0.089: v1(207.9,91.1) UV1.AH17
PEG_GTX_HRX_P6: length 5.7
  TOP w0.114: CV543.1 202.22,90.82 202.35,90.95 202.35,91.39 202.45,91.49 202.68,91.49 202.8,91.38 202.8,91.25 202.91,91.14 203.14,91.14 203.25,91.25 203.25,91.38 203.37,91.49 203.77,91.49 205.1,92.82 205.25,92.82 v1(205.41,92.66)
  BOTTOM w0.089: UV1.AK18 205.77,92.3 v1(205.41,92.66)
PEG_GTX_HRX_P7: length 6.6
  TOP w0.114: CV545.1 199.95,92.78 200.3,92.42 202.85,92.42 202.96,92.53 202.96,92.75 203.07,92.85 v2(203.19,92.85) 203.32,92.85 203.42,92.75 203.42,92.53 203.54,92.42 203.75,92.42 204.61,93.28 v1(204.61,93.51)
  BOTTOM w0.089: v1(204.61,93.51) 204.97,93.15 UV1.AL19
PEG_GTX_HRX_P8: length 6
  TOP w0.114: CV547.1 202.23,93.11 202.35,93.23 202.35,93.82 202.48,93.95 204.14,93.95 204.2,93.89 205.69,93.89 205.78,93.8 205.78,93.61 205.91,93.48 206.09,93.48 v1(206.2,93.6)
  BOTTOM w0.089: v1(206.2,93.6) UV1.AK20
PEG_GTX_HRX_P9: length 10.1
  TOP w0.114: v1(207.9,93.6) 207.95,93.55 208.22,93.55 208.29,93.62 208.29,93.97 207.95,94.31 204.65,94.31 204.37,94.59 v9(203.29,94.59) 200.28,94.59 CV550.1
  BOTTOM w0.089: v1(207.9,93.6) UV1.AH20
PEG_GTX_HRX_P10: length 6.8
  TOP w0.114: CV552.1 202.32,98.14 202.51,98.14 203.08,97.57 203.12,97.57 204.17,96.52 205.49,96.52 205.73,96.28 205.73,95.45 205.59,95.32 v1(205.38,95.32)
  BOTTOM w0.089: v1(205.38,95.32) 205.8,94.9 UV1.AK21
PEG_GTX_HRX_P11: length 7
  TOP w0.114: CV558.1 200.35,97.02 202.31,97.02 202.67,96.67 202.67,96.22 202.79,96.09 203,96.09 203.12,96.21 v2(203.12,96.45) 203.12,96.6 203.24,96.72 203.45,96.72 203.58,96.6 203.58,96.21 203.69,96.09 v1(204.56,96.09)
  BOTTOM w0.089: UV1.AL22 205,95.65 v1(204.56,96.09)
PEG_GTX_HRX_P12: length 7.2
  TOP w0.114: CV560.1 202.53,95.61 203.74,95.61 203.95,95.4 204.77,95.4 205.23,94.94 206.39,94.94 206.72,95.27 206.72,95.58 v1(206.34,95.96)
  BOTTOM w0.089: v1(206.34,95.96) UV1.AK23
PEG_GTX_HRX_P13: length 10.9
  TOP w0.114: v1(207.9,96.1) 208.21,96.1 208.32,96.22 208.32,96.45 207.83,96.94 204.39,96.94 202.13,99.2 200.33,99.2 CV562.1
  BOTTOM w0.089: v1(207.9,96.1) UV1.AH23
PEG_GTX_HRX_P14: length 6.8
  TOP w0.114: v1(205.37,97.73) 205.37,97.89 205.26,97.99 205.05,97.99 204.95,97.89 204.95,97.68 204.85,97.58 204.65,97.58 203.21,99.02 v9(203.21,99.4) 203.21,99.9 202.93,100.18 202.45,100.18 202.34,100.29 202.34,100.74 202.22,100.85 CV564.1
  BOTTOM w0.089: v1(205.37,97.73) UV1.AK24
PEG_GTX_HRX_P15: length 8.3
  TOP w0.114: v1(204.57,98.58) 204.71,98.58 204.89,98.77 204.89,98.87 204.75,99.01 204.39,99.01 204.14,98.76 204.07,98.76 203.91,98.91 203.91,100.2 203.4,100.71 203.4,100.74 203,101.13 202.98,101.13 202.45,101.66 200.28,101.66 CV566.1
  BOTTOM w0.089: v1(204.57,98.58) UV1.AL25
PEG_HTX_C_GRX_N0: length 8
  BOTTOM w0.102: 202.2,87.72 202.22,87.73 202.23,87.73 202.27,87.77 202.28,87.77 202.42,87.91 202.97,87.91 203.24,87.64 203.61,87.64 203.96,87.3 UV1.AM12
  BOTTOM w0.114: CU16.2 199.47,86.52 199.7,86.52 199.92,86.29 199.92,85.5 200.02,85.4 200.39,85.4 200.49,85.5 200.49,85.74 200.48,85.76 200.48,86.31 200.49,86.33 200.49,86.5 200.79,86.8 201.28,86.8 201.54,87.05 202.2,87.72
PEG_HTX_C_GRX_N1: length 8.1
  BOTTOM w0.114: UV1.AM14 203.97,89 203.59,88.62 203.15,88.62 202.93,88.41 202.19,88.41 201.13,87.34 200.56,87.34 200.54,87.32 199.69,87.32 199.67,87.34 197.85,87.34 197.61,87.1 197.07,87.1 CU15.2
PEG_HTX_C_GRX_N2: length 6
  BOTTOM w0.114: CU14.2 199.48,88.6 200.06,88.6 200.39,88.27 200.74,88.27 200.94,88.47 200.94,88.64 200.49,89.08 200.49,89.4 200.76,89.66 201.25,89.66 201.71,89.2 201.89,89.2 202.18,89.48 202.46,89.48 202.6,89.62 UV1.AP15
PEG_HTX_C_GRX_N3: length 8.3
  BOTTOM w0.114: UV1.AM15 203.85,89.45 203.25,89.45 203.02,89.68 203.02,89.98 202.85,90.16 200.55,90.16 v9(200.2,89.81) 199.83,89.44 197.84,89.44 197.74,89.33 197.21,89.33 CU13.2
PEG_HTX_C_GRX_N4: length 6.2
  BOTTOM w0.114: CU12.2 199.47,90.71 199.62,90.71 200.13,91.22 v9(200.95,91.22) 201.65,91.22 201.76,91.11 202.88,91.11 203,91.23 203,91.71 203.15,91.86 203.84,91.86 UV1.AM17
PEG_HTX_C_GRX_N5: length 6
  BOTTOM w0.114: CU11.2 197.31,91.75 199.46,91.75 199.71,92.01 202.31,92.01 UV1.AP18
PEG_HTX_C_GRX_N6: length 5.4
  BOTTOM w0.114: UV1.AM18 203.93,92.3 203.48,92.75 203.22,92.75 203.09,92.89 201.14,92.89 201.13,92.9 200.57,92.9 200.55,92.89 200.43,92.89 200.18,93.13 CU10.2
PEG_HTX_C_GRX_N7: length 8.1
  BOTTOM w0.114: CU9.2 197.09,94.07 197.66,94.07 197.89,93.84 201.81,93.84 202.06,93.6 202.71,93.6 202.97,93.86 202.97,93.88 202.97,94.07 203.25,94.35 203.85,94.35 UV1.AM20
PEG_HTX_C_GRX_N8: length 3.9
  BOTTOM w0.114: UV1.AP21 202.29,94.49 202.09,94.49 201.97,94.62 201.32,94.62 201.3,94.63 200.75,94.63 200.73,94.62 200.01,94.62 199.73,94.9 199.47,94.9 CU8.2
PEG_HTX_C_GRX_N9: length 7.8
  BOTTOM w0.114: UV1.AM21 203.77,95.23 203.25,95.23 203.1,95.38 200.37,95.38 v9(200.14,95.61) 199.81,95.94 197.71,95.94 197.64,96.01 197.24,96.01 CU7.2
PEG_HTX_C_GRX_N10: length 5.5
  BOTTOM w0.114: UV1.AM23 203.94,96.5 203.5,96.07 203.2,96.07 203.03,95.89 200.62,95.89 200.07,96.44 CU6.2
PEG_HTX_C_GRX_N11: length 6.3
  BOTTOM w0.114: CU5.2 197.31,98.04 199.8,98.04 200.04,97.79 200.07,97.79 200.46,97.4 200.46,97.37 200.82,97.01 202.31,97.01 UV1.AP24
PEG_HTX_C_GRX_N12: length 5.9
  BOTTOM w0.114: CU4.2 199.4,99.15 199.89,99.15 201.16,97.88 203.06,97.88 203.19,97.76 203.44,97.76 203.9,97.3 UV1.AM24
PEG_HTX_C_GRX_N13: length 8.6
  BOTTOM w0.114: UV1.AM26 203.85,99.35 203.25,99.35 203.02,99.11 203.02,98.8 202.86,98.65 201.43,98.65 200.73,99.35 200.73,99.38 200.34,99.77 200.31,99.77 199.95,100.13 197.31,100.13 CU3.2
PEG_HTX_C_GRX_N14: length 7
  BOTTOM w0.114: UV1.AP27 202.6,99.6 202.5,99.5 202.07,99.5 201.93,99.36 201.73,99.36 201.71,99.38 201.54,99.55 201.54,99.73 201.66,99.85 201.66,100.21 201.25,100.62 200.91,100.62 200.79,100.5 200.61,100.5 200.43,100.68 200.43,100.83 v9(200.66,101.06) 200.82,101.22 200.82,101.59 200.57,101.85 200.05,101.85 199.8,101.59 199.8,101.39 199.62,101.21 199.44,101.21 CU2.2
PEG_HTX_C_GRX_N15: length 8.4
  BOTTOM w0.114: UV1.AM27 203.91,99.8 203.45,100.26 203.2,100.26 201.66,101.8 200.89,102.56 200.54,102.56 200.52,102.58 199.96,102.58 199.94,102.56 196.99,102.56 CU1.2
PEG_HTX_C_GRX_P0: length 8
  BOTTOM w0.102: UV1.AN12 203.49,87.21 203.49,87.02 203.39,86.92 203.19,86.92 202.98,87.13 202.98,87.62 202.89,87.71 202.5,87.71 202.36,87.56
  BOTTOM w0.114: CU32.2 199.48,86.3 199.61,86.3 199.71,86.2 199.71,85.41 199.93,85.18 200.48,85.18 200.71,85.41 v9(200.71,86.04) 200.71,86.41 200.88,86.58 201.37,86.58 202.36,87.56
PEG_HTX_C_GRX_P1: length 8
  BOTTOM w0.114: UV1.AN14 203.47,89.07 203.47,89.13 203.36,89.23 203.03,89.23 202.96,89.16 202.96,88.74 202.84,88.62 202.1,88.62 201.04,87.56 v9(200.26,87.56) 197.76,87.56 197.52,87.32 197.46,87.32 196.98,87.8 CU31.2
PEG_HTX_C_GRX_P2: length 6
  BOTTOM w0.114: CU30.2 199.47,88.38 199.97,88.38 200.3,88.05 200.83,88.05 201.15,88.38 201.15,88.73 200.71,89.17 200.71,89.31 200.85,89.45 201.16,89.45 201.62,88.98 201.98,88.98 202.27,89.26 202.51,89.26 202.6,89.18 UV1.AP14
PEG_HTX_C_GRX_P3: length 8.3
  BOTTOM w0.114: CU29.2 196.98,89.89 197.32,89.55 197.65,89.55 197.75,89.65 199.74,89.65 199.83,89.75 199.83,89.78 200.23,90.18 200.26,90.18 200.46,90.37 202.94,90.37 203.11,90.2 203.78,90.2 203.85,90.13 203.85,89.9 203.74,89.8 UV1.AN15
PEG_HTX_C_GRX_P4: length 6.2
  BOTTOM w0.114: UV1.AN17 203.7,91.5 203.94,91.26 203.94,91.11 203.78,90.94 203.6,90.94 203.47,91.08 203.2,91.08 203.02,90.89 201.67,90.89 201.56,91 201.26,91 201.22,90.97 200.68,90.97 200.65,91 200.24,91 199.75,90.52 199.73,90.52 199.71,90.49 199.48,90.49 CU28.2
PEG_HTX_C_GRX_P5: length 6
  BOTTOM w0.114: UV1.AP17 202.31,91.79 199.8,91.79 199.55,91.53 197.31,91.53 CU27.2
PEG_HTX_C_GRX_P6: length 5.4
  BOTTOM w0.114: CU26.2 199.48,92.59 199.48,92.68 199.71,92.92 200.09,92.92 200.34,92.67 v9(200.85,92.67) 203,92.67 203.08,92.59 203.08,92.5 202.97,92.4 202.97,92.19 203.06,92.1 203.2,92.1 UV1.AN18
PEG_HTX_C_GRX_P7: length 8
  BOTTOM w0.114: UV1.AN20 203.47,93.93 203.47,93.61 203.38,93.53 203.28,93.53 203.18,93.62 203.06,93.62 202.98,93.54 202.98,93.42 203.05,93.35 203.05,93.22 202.95,93.13 202.82,93.13 202.57,93.38 201.97,93.38 201.72,93.63 197.8,93.63 197.57,93.85 197.44,93.85 196.98,93.39 CU25.2
PEG_HTX_C_GRX_P8: length 3.9
  BOTTOM w0.114: CU24.2 199.48,94.68 199.64,94.68 199.92,94.4 v9(201.03,94.4) 201.88,94.4 202,94.28 202.32,94.28 UV1.AP20
PEG_HTX_C_GRX_P9: length 7.8
  BOTTOM w0.114: UV1.AN21 203.4,94.64 203.34,94.58 203.17,94.58 203.12,94.53 203.01,94.53 202.95,94.59 202.95,94.88 203.07,95 203.07,95.1 203.01,95.16 200.25,95.16 199.69,95.72 197.62,95.72 197.55,95.8 197.33,95.8 196.98,95.44 CU23.2
PEG_HTX_C_GRX_P10: length 5.5
  BOTTOM w0.114: CU22.2 199.14,97.23 199.71,96.65 200.16,96.65 200.71,96.11 202.94,96.11 203.01,96.18 203.01,96.66 203.09,96.74 203.3,96.74 203.4,96.64 UV1.AN23
PEG_HTX_C_GRX_P11: length 6.3
  BOTTOM w0.114: UV1.AP23 202.3,96.8 200.73,96.8 v9(200.1,97.43) 199.71,97.82 197.31,97.82 CU21.2
PEG_HTX_C_GRX_P12: length 5.9
  BOTTOM w0.114: UV1.AN24 203.4,97.11 203.26,96.98 203.07,96.98 202.96,97.09 202.96,97.4 203.02,97.46 203.02,97.62 202.97,97.67 201.07,97.67 199.8,98.94 199.47,98.94 199.14,98.61 CU20.2
PEG_HTX_C_GRX_P13: length 8.6
  BOTTOM w0.114: CU19.2 197.31,99.92 199.86,99.92 200,99.78 v9(200.37,99.41) 201.34,98.43 203,98.43 203.11,98.54 203.73,98.54 203.83,98.64 203.83,99.01 203.73,99.11 203.5,99.11 203.4,99.01 UV1.AN26
PEG_HTX_C_GRX_P14: length 7.1
  BOTTOM w0.114: UV1.AP26 202.6,99.2 202.51,99.29 202.16,99.29 202.02,99.15 201.64,99.15 201.55,99.23 201.32,99.46 201.32,99.82 201.45,99.94 201.45,100.12 201.16,100.41 201,100.41 200.88,100.29 200.52,100.29 200.22,100.59 200.22,100.95 200.61,101.34 200.61,101.5 200.48,101.63 200.14,101.63 200.01,101.5 200.01,101.3 199.71,100.99 199.5,100.99 CU18.2
PEG_HTX_C_GRX_P15: length 8.4
  BOTTOM w0.114: CU17.2 197.42,102.12 197.42,102.24 197.52,102.35 v9(200.24,102.35) 200.8,102.35 201.44,101.71 201.44,101.71 202.95,100.2 202.95,99.73 203.1,99.58 203.34,99.58 203.4,99.64 UV1.AN27
PEG_HTX_GRX_N0: length 32.3
  BOTTOM w0.089: U6.T1 180.16,94.34 180.16,94.5 180.25,94.59 180.62,94.59 180.67,94.54 180.67,94.1 180.72,94.05 180.75,94.05 180.76,94.06 180.78,94.06
  BOTTOM w0.114: CU16.1 197.82,86.44 195.13,86.44 195.11,86.46 194.55,86.46 194.53,86.44 v9(192.57,86.44) 191.11,86.44 190.41,87.15 190,87.15 189.28,86.42 188.99,86.42 188.55,86.85 188.55,87.01 189.47,87.93 189.47,88.29 188.87,88.89 188.51,88.89 187.73,88.11 187.29,88.11 186.9,88.5 186.56,88.5 185.94,87.88 185.77,87.88 185.54,88.11 185.54,88.29 186.16,88.91 186.16,89.25 185.79,89.62 185.45,89.62 184.79,88.96 184.61,88.96 184.39,89.18 184.39,89.36 185.05,90.02 185.05,90.36 184.68,90.73 184.34,90.73 183.55,89.94 183.37,89.94 183.15,90.17 183.15,90.35 183.93,91.13 183.93,91.47 181.34,94.06 180.78,94.06
PEG_HTX_GRX_N1: length 30.5
  IN4 w0.089: 181.96,94.14 181.94,94.14 181.93,94.15 179.96,94.15 179.84,94.03 178.96,94.03 178.75,94.24 178.75,94.42 v1(178.51,94.66)
  IN4 w0.107: v1(190.39,89.06) 190.6,89.27 190.6,90.02 191.01,90.42 193.93,90.42 194.06,90.55 194.06,91.47 193.93,91.59 190.98,91.59 190.35,92.22 184.48,92.22 182.57,94.14 181.96,94.14
  BOTTOM w0.089: U6.T4 178.13,94.29 v1(178.51,94.66)
  BOTTOM w0.114: CU15.1 191.25,87.01 v9(190.86,87.4) 190.54,87.72 190.54,88.91 v1(190.39,89.06)
PEG_HTX_GRX_N2: length 33.2
  IN4 w0.089: v1(178.51,95.48) 178.6,95.48 178.98,95.85 180.4,95.85 181.18,95.07 181.93,95.07 181.94,95.08 181.96,95.08
  IN4 w0.107: v1(192.18,89.05) 192.18,89.4 192.27,89.48 195.36,89.48 195.69,89.81 195.69,92.4 195.36,92.73 192.65,92.73 192.22,93.16 184.87,93.16 182.96,95.08 181.96,95.08
  BOTTOM w0.089: v1(178.51,95.48) 178.13,95.1 U6.R4
  BOTTOM w0.114: CU14.1 198.22,88.85 197.72,88.34 197.63,88.34 197.36,88.61 191.94,88.61 191.89,88.66 191.89,88.75 v1(192.18,89.05)
PEG_HTX_GRX_N3: length 30.7
  BOTTOM w0.089: 181.01,94.61 181,94.61 180.98,94.62 180.92,94.62 180.76,94.78 180.1,94.78 179.79,95.09 U6.R2
  BOTTOM w0.114: 181.01,94.61 181.5,94.61 181.95,94.16 182.29,94.16 183.01,94.89 183.19,94.89 183.42,94.66 183.42,94.48 182.69,93.76 182.69,93.42 183.06,93.05 183.4,93.05 184.13,93.77 184.31,93.77 184.53,93.55 184.53,93.37 183.8,92.64 183.8,92.3 184.17,91.93 184.51,91.93 185.58,93 185.76,93 185.98,92.77 185.98,92.59 184.92,91.53 184.92,91.19 185.29,90.82 185.63,90.82 186.71,91.9 186.89,91.9 187.12,91.68 187.12,91.5 186.03,90.41 186.03,90.07 186.44,89.66 186.82,89.66 187.12,89.97 187.23,89.97 187.65,89.56 192.53,89.56 192.67,89.42 192.83,89.42 192.85,89.4 193.4,89.4 193.42,89.42 v9(194.93,89.42) 195.74,89.42 CU13.1
PEG_HTX_GRX_N4: length 34.8
  IN4 w0.089: v1(176.37,95.49) 176.37,94.96 176.26,94.86 175.9,94.86 175.59,94.55 175.59,91.94 175.93,91.6 176.54,91.6 177.6,92.65 178,92.65 178.21,92.45 182.2,92.45 182.2,92.46 182.22,92.44
  IN4 w0.107: 182.22,92.44 182.45,92.21 182.45,88.98 182.71,88.72 187.81,88.72 188.23,89.15 v1(188.23,91)
  BOTTOM w0.089: U6.R6 176.73,95.13 v1(176.37,95.49)
  BOTTOM w0.114: v1(188.23,91) 188.23,91 187.94,90.7 187.94,90.58 188.03,90.48 193.34,90.48 193.56,90.7 197.39,90.7 197.64,90.45 197.73,90.45 198.22,90.94 CU12.1
PEG_HTX_GRX_N5: length 33.1
  IN4 w0.089: 181.96,93.43 181.94,93.43 181.93,93.44 178.08,93.44 177.35,94.17 177.35,94.42 v1(177.11,94.66)
  IN4 w0.107: v1(188.96,91) 189.14,91.19 189.14,91.41 189.04,91.51 185.93,91.51 185.82,91.4 185.82,90.88 186.01,90.69 187.04,90.69 187.3,90.43 187.3,89.7 187.04,89.44 185.08,89.44 184.84,89.68 184.84,91.4 184.73,91.51 184.31,91.51 184.2,91.4 184.2,89.7 183.94,89.44 183.42,89.44 183.17,89.7 183.17,92.53 182.27,93.43 181.96,93.43
  BOTTOM w0.089: v1(177.11,94.66) 176.73,94.29 U6.T6
  BOTTOM w0.114: v1(188.96,91) 189.08,91.13 189.08,91.13 189.1,91.16 189.1,91.5 189.35,91.75 194.77,91.75 195.1,92.09 CU11.1
PEG_HTX_GRX_N6: length 35.2
  BOTTOM w0.089: 180.72,99.66 180.7,99.66 180.68,99.65 180.16,99.65 179.67,99.16 U6.J2
  BOTTOM w0.114: 180.72,99.66 181.84,99.66 183.27,98.23 183.27,97.89 182.47,97.08 182.47,96.92 182.71,96.68 182.87,96.68 183.68,97.48 184.02,97.48 184.39,97.11 184.39,96.77 183.58,95.97 183.58,95.81 183.83,95.56 183.99,95.56 184.79,96.37 185.13,96.37 185.5,96 185.5,95.66 184.7,94.85 184.7,94.69 184.94,94.45 185.1,94.45 185.91,95.25 186.25,95.25 186.6,94.9 186.76,94.9 187.93,96.08 188.27,96.08 188.64,95.71 188.64,95.37 186.84,93.57 186.84,93.21 187.25,92.8 187.49,92.8 188.24,93.55 188.57,93.55 189.32,92.8 190.04,92.8 190.06,92.82 190.61,92.82 190.63,92.8 v9(193.03,92.8) 197.33,92.8 197.41,92.88 197.96,92.88 CU10.1
PEG_HTX_GRX_N7: length 30.3
  IN4 w0.107: v1(189.3,94.37) 189.11,94.55 189.11,95.91 188.85,96.17 188.21,96.17 187.95,95.91 187.95,95.05 187.82,94.92 187.54,94.92 187.41,95.05 187.41,95.91 187.16,96.17 186.63,96.17 186.37,95.91 186.37,94.72 186.24,94.59 185.96,94.59 185.84,94.72 185.84,97.37 185.47,97.74 185.47,98.26 185.23,98.5 184.72,98.5 184.48,98.26 184.48,97.74 184.38,97.64 184.06,97.64 183.95,97.74 183.95,98.26 183.71,98.5 183.2,98.5 182.96,98.26 182.96,97.74 182.86,97.64 180.93,97.64 179.8,98.77 179.41,98.77 178.97,99.21 178.97,99.3 v1(179.21,99.54)
  BOTTOM w0.089: v1(179.21,99.54) 178.83,99.16 U6.J3
  BOTTOM w0.114: v1(189.3,94.37) 189.09,94.16 189.09,94.03 189.28,93.84 194.92,93.84 195.25,93.51 195.48,93.51 195.7,93.72 195.7,93.81 CU9.1
PEG_HTX_GRX_N8: length 34.5
  BOTTOM w0.089: 181.08,100.6 181.05,100.6 181.03,100.59 179.81,100.59 179.69,100.46 179.32,100.46 178.99,100.14 178.99,100.05 178.91,99.97 U6.G3
  BOTTOM w0.114: 181.08,100.6 181.92,100.6 183.01,99.52 183.17,99.52 184.2,100.55 184.62,100.55 184.91,100.26 184.91,99.84 183.88,98.81 183.88,98.65 184.12,98.4 184.28,98.4 185.4,99.52 185.82,99.52 186.11,99.23 186.11,98.81 184.99,97.7 184.99,97.53 185.23,97.29 185.4,97.29 186.52,98.41 186.93,98.41 187.23,98.12 187.23,97.7 186.11,96.58 186.11,96.42 186.4,96.13 186.65,96.13 187.77,97.24 188.12,97.24 189.12,96.24 v9(191.96,96.24) 192.56,96.24 192.76,96.04 192.76,94.69 192.89,94.56 193.87,94.56 193.89,94.58 194.45,94.58 194.46,94.56 194.83,94.56 195.14,94.88 197.33,94.88 197.4,94.95 197.94,94.95 CU8.1
PEG_HTX_GRX_N9: length 32.3
  IN4 w0.107: v1(177.81,99.54) 177.67,99.68 177.52,99.68 177.43,99.59 177.43,99.38 177.27,99.22 177.27,98.84 178.31,97.8 179.55,97.8 180.43,96.92 184.82,96.92 185.09,96.65 185.09,94.3 185.51,93.88 191.73,93.88 191.86,94.01 191.86,94.83 191.79,94.9 191.61,94.9 191.35,95.16 191.35,95.91 191.61,96.17 192.67,96.17 192.91,95.93 192.91,93.57 193.04,93.45 193.7,93.45 193.83,93.57 193.83,94.84 v1(193.47,95.19)
  BOTTOM w0.089: U6.J5 177.43,99.16 v1(177.81,99.54)
  BOTTOM w0.114: CU7.1 194.25,96.28 193.64,95.67 193.64,95.36 v1(193.47,95.19)
PEG_HTX_GRX_N10: length 32.8
  BOTTOM w0.089: U6.E3 179.17,101.26 179.91,101.26 179.93,101.28 182.11,101.28 182.13,101.26 ; 182.14,101.26 182.23,101.26
  BOTTOM w0.114: 182.23,101.26 183.73,101.26 183.97,101.5 183.97,102.58 184.1,102.7 184.42,102.7 184.54,102.58 184.54,101.28 184.81,101.01 185.38,101.01 185.98,101.61 186.16,101.61 186.38,101.39 186.38,101.21 185.78,100.6 185.78,100.26 186.15,99.89 186.49,99.89 187.12,100.53 187.3,100.53 187.53,100.3 187.53,100.13 186.89,99.49 186.89,99.15 187.26,98.78 187.6,98.78 188.36,99.54 188.54,99.54 188.76,99.31 188.76,99.13 188.01,98.38 188.01,98.04 188.38,97.67 188.72,97.67 189.46,98.41 189.64,98.41 189.86,98.19 189.86,98.01 189.29,97.44 189.29,97.07 189.59,96.77 v9(190.36,96.77) 193.19,96.77 193.21,96.75 193.76,96.75 193.78,96.77 197.28,96.77 197.35,96.7 197.96,96.7 CU6.1 ; 182.13,101.26 182.14,101.26
PEG_HTX_GRX_N11: length 32
  IN4 w0.107: v1(178.54,100.38) 178.37,100.2 178.23,100.2 178.16,100.28 178.16,100.48 178,100.64 178,100.74 178.11,100.85 178.89,100.85 180.73,99.01 186.18,99.01 186.33,98.86 186.33,96.92 186.58,96.66 187.29,96.66 187.53,96.9 187.53,97.32 187.66,97.44 187.94,97.44 188.06,97.32 188.06,96.9 188.3,96.66 188.87,96.66 189.11,96.9 189.11,97.32 189.24,97.44 189.52,97.44 189.65,97.32 189.65,94.71 189.91,94.45 190.61,94.45 190.87,94.71 190.87,96.52 191.01,96.66 193.58,96.66 193.84,96.91 193.84,98.1 193.99,98.25 194.63,98.25 194.77,98.1 194.77,97.95 194.42,97.59 v1(194.42,97.59)
  BOTTOM w0.089: v1(178.54,100.38) 178.14,99.97 U6.G4
  BOTTOM w0.114: CU5.1 194.88,98.37 194.56,98.06 194.56,97.74 v1(194.42,97.59)
PEG_HTX_GRX_N12: length 32.6
  IN4 w0.107: v1(191.8,97.52) 192.16,97.88 192.16,98.14 192.44,98.43 192.85,98.43 192.98,98.55 192.98,99.48 192.85,99.61 191.11,99.61 190.98,99.48 190.98,99.09 190.77,98.87 188.49,98.87 188.23,99.13 188.23,99.93 188.49,100.19 188.86,100.19 188.99,100.31 188.99,101.32 188.86,101.45 188.2,101.45 188.09,101.34 188.09,100.81 187.83,100.55 187.36,100.55 187.1,100.81 187.1,101.34 187,101.45 181.93,101.45 180.89,102.48 178.39,102.48 178.12,102.21 178.12,101.82 178.17,101.77 178.28,101.77 v1(178.5,101.99)
  BOTTOM w0.089: v1(178.5,101.99) 178.13,102.36 U6.D4
  BOTTOM w0.114: v1(191.8,97.52) 191.86,97.58 191.86,98.04 192.04,98.22 193.67,98.22 194.53,99.08 197.28,99.08 197.54,99.34 198.14,99.34 CU4.1
PEG_HTX_GRX_N13: length 29.7
  IN4 w0.107: v1(190.47,97.52) 190.47,97.52 190.82,97.87 190.82,98.07 190.74,98.16 187.85,98.16 187.49,98.51 187.49,99.59 187.36,99.72 186.64,99.72 186.4,99.96 186.4,100.6 186.27,100.73 185.99,100.73 185.86,100.6 185.86,99.96 185.62,99.72 185.12,99.72 184.88,99.96 184.88,100.6 184.75,100.73 184.47,100.73 184.35,100.6 184.35,99.96 184.11,99.72 183.6,99.72 183.36,99.96 183.36,100.6 183.23,100.73 182.95,100.73 182.83,100.6 182.83,99.96 182.59,99.72 181.82,99.72 180.26,101.29 177.58,101.29 177.13,101.73 177.13,101.84 177.02,101.95 176.95,101.95 176.73,101.72 v1(176.73,101.56)
  BOTTOM w0.089: U6.E6 176.44,101.84 v1(176.73,101.56)
  BOTTOM w0.114: CU3.1 194.9,100.47 193.39,98.95 191.61,98.95 190.63,97.97 190.63,97.68 v1(190.47,97.52)
PEG_HTX_GRX_N14: length 31.3
  IN4 w0.107: v1(189.5,99.6) 189.51,99.6 189.86,99.95 189.86,100.35 190.13,100.62 192.06,100.62 192.19,100.75 192.19,101.42 192.06,101.55 190.19,101.55 189.58,102.16 183.21,102.16 181.57,103.79 177.88,103.79 177.44,103.36 177.04,103.36 176.74,103.05 v1(176.74,102.91)
  BOTTOM w0.089: v1(176.74,102.91) 177.07,103.24 U6.C5
  BOTTOM w0.114: v1(189.5,99.6) 189.56,99.66 189.56,100.11 189.75,100.3 193.58,100.3 194.46,101.18 197.29,101.18 197.54,101.42 198.13,101.42 CU2.1
PEG_HTX_GRX_N15: length 29.9
  IN4 w0.107: v1(186.47,103.72) 186.47,103.12 186.22,102.87 185.26,102.87 185,103.13 185,104.54 184.81,104.73 184.35,104.73 184.24,104.63 184.24,103.75 183.98,103.49 183.52,103.49 183.26,103.75 183.26,104.63 183.15,104.73 176.3,104.73 175.47,103.9 175.47,103.5 175.73,103.25 176,103.25 176.09,103.33 176.09,103.46 v1(175.91,103.63)
  BOTTOM w0.089: v1(175.91,103.63) 176.23,103.94 U6.B6
  BOTTOM w0.114: v1(186.47,103.72) 186.1,103.35 186.1,103.18 188.18,101.1 193.04,101.1 194.06,102.12 195.73,102.12 196.06,102.45 CU1.1
PEG_HTX_GRX_P0: length 32.3
  BOTTOM w0.089: 180.78,93.85 180.77,93.85 180.76,93.86 180.64,93.86 180.53,93.97 180.04,93.97 179.73,94.28 U6.T2
  BOTTOM w0.114: CU32.1 197.95,86.23 v9(194.83,86.23) 192.86,86.23 192.85,86.21 192.29,86.21 192.27,86.23 191.02,86.23 190.32,86.93 190.09,86.93 189.37,86.2 188.9,86.2 188.34,86.76 188.34,87.1 189.26,88.02 189.26,88.2 188.78,88.68 188.6,88.68 187.82,87.9 187.2,87.9 186.81,88.29 186.65,88.29 186.03,87.67 185.68,87.67 185.32,88.02 185.32,88.38 185.94,88.99 185.94,89.16 185.7,89.4 185.54,89.4 184.88,88.74 184.52,88.74 184.17,89.09 184.17,89.45 184.83,90.11 184.83,90.27 184.59,90.51 184.43,90.51 183.64,89.73 183.28,89.73 182.93,90.08 182.93,90.44 183.72,91.22 183.72,91.38 181.25,93.85 180.78,93.85
PEG_HTX_GRX_P1: length 30.5
  IN4 w0.089: v1(179.21,94.66) 178.96,94.42 178.96,94.33 179.05,94.24 179.75,94.24 179.87,94.36 181.93,94.36 181.94,94.37 181.96,94.37
  IN4 w0.107: v1(190.97,89.06) 190.83,89.2 190.83,89.93 191.1,90.2 194.02,90.2 194.28,90.46 194.28,91.56 194.02,91.82 191.07,91.82 190.44,92.45 184.58,92.45 182.66,94.37 181.96,94.37
  BOTTOM w0.089: v1(179.21,94.66) 178.83,94.29 U6.T3
  BOTTOM w0.114: v1(190.97,89.06) 190.75,88.84 190.75,87.84 191.38,87.22 195.48,87.22 195.73,87.46 195.73,87.56 CU31.1
PEG_HTX_GRX_P2: length 33.2
  IN4 w0.089: 181.96,94.85 181.95,94.85 181.94,94.86 181.09,94.86 180.31,95.64 179.65,95.64 179.6,95.59 179.6,95.11 179.54,95.05 179.21,95.05 179.1,95.16 179.1,95.37 v1(179.21,95.48)
  IN4 w0.107: 181.96,94.85 182.86,94.85 184.78,92.94 192.12,92.94 192.56,92.51 195.27,92.51 195.47,92.31 195.47,89.91 195.27,89.71 192.17,89.71 191.96,89.49 191.96,89.4 191.6,89.05 v1(191.6,89.05)
  BOTTOM w0.089: v1(179.21,95.48) 178.83,95.1 U6.R3
  BOTTOM w0.114: CU30.1 198.15,88.13 197.54,88.13 197.28,88.39 191.85,88.39 191.67,88.57 191.67,88.98 v1(191.6,89.05)
PEG_HTX_GRX_P3: length 30.7
  BOTTOM w0.089: U6.R1 180.23,95.44 180.32,95.53 180.46,95.53 180.57,95.42 180.57,95.02 180.62,94.97 180.86,94.97 181.01,94.83
  BOTTOM w0.114: CU29.1 195.71,89.64 195.23,89.64 195.21,89.66 194.65,89.66 194.63,89.64 v9(193.13,89.64) 192.76,89.64 192.62,89.77 187.74,89.77 187.32,90.18 187.03,90.18 186.73,89.88 186.53,89.88 186.25,90.16 186.25,90.32 187.33,91.41 187.33,91.77 186.98,92.12 186.62,92.12 185.54,91.03 185.38,91.03 185.13,91.28 185.13,91.44 186.2,92.51 186.2,92.86 185.85,93.21 185.49,93.21 184.42,92.15 184.26,92.15 184.02,92.39 184.02,92.55 184.75,93.28 184.75,93.64 184.4,93.99 184.04,93.99 183.31,93.26 183.15,93.26 182.91,93.5 182.91,93.67 183.63,94.39 183.63,94.75 183.28,95.1 182.92,95.1 182.2,94.38 182.04,94.38 181.59,94.83 181.01,94.83
PEG_HTX_GRX_P4: length 34.7
  IN4 w0.089: v1(177.12,95.5) 177,95.62 176.85,95.62 176.74,95.51 176.74,95.32 176.58,95.16 176.58,94.88 176.35,94.65 175.98,94.65 175.8,94.46 175.8,92.03 176.02,91.81 176.45,91.81 177.51,92.86 178.09,92.86 178.29,92.66 182.31,92.66
  IN4 w0.107: 182.31,92.66 182.32,92.66 182.68,92.3 182.68,89.08 182.8,88.95 187.72,88.95 188.01,89.24 188.01,90.65 187.65,91 v1(187.65,91)
  BOTTOM w0.089: v1(177.12,95.5) 177.43,95.19 U6.R5
  BOTTOM w0.114: v1(187.65,91) 187.72,90.93 187.72,90.49 187.94,90.27 193.43,90.27 193.65,90.49 197.3,90.49 197.55,90.23 198.14,90.23 CU28.1
PEG_HTX_GRX_P5: length 33.1
  IN4 w0.089: 181.96,93.65 181.94,93.65 181.93,93.64 178.17,93.64 177.56,94.25 177.56,94.42 v1(177.81,94.66)
  IN4 w0.107: v1(189.54,91) 189.37,91.18 189.37,91.51 189.14,91.74 185.84,91.74 185.6,91.5 185.6,90.78 185.92,90.46 186.94,90.46 187.07,90.34 187.07,89.79 186.94,89.66 185.17,89.66 185.06,89.77 185.06,91.5 184.82,91.74 184.22,91.74 183.97,91.49 183.97,89.79 183.85,89.66 183.52,89.66 183.39,89.79 183.39,92.62 182.36,93.65 181.96,93.65
  BOTTOM w0.089: v1(177.81,94.66) 177.43,94.29 U6.T5
  BOTTOM w0.114: v1(189.54,91) 189.32,91.22 189.32,91.41 189.44,91.53 194.86,91.53 195.19,91.87 195.48,91.87 196.06,91.29 CU27.1
PEG_HTX_GRX_P6: length 35.2
  BOTTOM w0.089: 180.72,99.44 180.63,99.36 180.63,98.89 180.54,98.81 180.39,98.81 180.23,98.97 U6.J1
  BOTTOM w0.114: 180.72,99.44 181.75,99.44 183.06,98.14 183.06,97.98 182.25,97.17 182.25,96.83 182.62,96.46 182.96,96.46 183.77,97.27 183.93,97.27 184.17,97.02 184.17,96.86 183.37,96.06 183.37,95.72 183.74,95.35 184.08,95.35 184.88,96.15 185.04,96.15 185.29,95.91 185.29,95.75 184.48,94.94 184.48,94.6 184.85,94.23 185.19,94.23 186,95.04 186.16,95.04 186.51,94.69 186.85,94.69 188.02,95.86 188.18,95.86 188.43,95.62 188.43,95.46 186.63,93.66 186.63,93.12 187.16,92.58 187.58,92.58 188.33,93.33 188.48,93.33 189.23,92.58 v9(190.33,92.58) 192.73,92.58 192.75,92.56 193.3,92.56 193.32,92.58 197.42,92.58 197.5,92.66 197.81,92.66 CU26.1
PEG_HTX_GRX_P7: length 30.3
  IN4 w0.107: v1(178.51,99.54) 178.74,99.3 178.74,99.11 179.31,98.54 179.71,98.54 180.84,97.41 182.95,97.41 183.19,97.65 183.19,98.17 183.3,98.28 183.62,98.28 183.72,98.17 183.72,97.65 183.96,97.41 184.47,97.41 184.71,97.65 184.71,98.17 184.82,98.28 185.14,98.28 185.24,98.17 185.24,97.65 185.61,97.28 185.61,94.63 185.87,94.37 186.34,94.37 186.6,94.63 186.6,95.82 186.72,95.94 187.06,95.94 187.19,95.82 187.19,94.95 187.45,94.69 187.91,94.69 188.17,94.95 188.17,95.82 188.3,95.94 188.76,95.94 188.89,95.82 188.89,94.54 v1(188.71,94.37)
  BOTTOM w0.089: v1(178.51,99.54) 178.13,99.16 U6.J4
  BOTTOM w0.114: CU25.1 195.16,93.29 194.83,93.63 189.19,93.63 188.88,93.94 188.88,94.21 v1(188.71,94.37)
PEG_HTX_GRX_P8: length 34.5
  BOTTOM w0.089: 181.12,100.39 181.11,100.39 181.1,100.4 181.05,100.4 181.02,100.42 179.91,100.42 179.77,100.27 179.4,100.27 179.19,100.06 179.19,100 179.27,99.91 179.47,99.91 U6.G2
  BOTTOM w0.114: CU24.1 197.83,94.73 197.49,94.73 197.42,94.66 195.23,94.66 194.92,94.35 v9(194.17,94.35) 192.8,94.35 192.55,94.6 192.55,95.95 192.47,96.02 192.25,96.02 192.24,96.01 191.68,96.01 191.66,96.02 189.03,96.02 188.03,97.03 187.86,97.03 186.74,95.91 186.31,95.91 185.89,96.33 185.89,96.67 187.01,97.79 187.01,98.03 186.84,98.19 186.61,98.19 185.49,97.07 185.15,97.07 184.78,97.44 184.78,97.78 185.9,98.9 185.9,99.14 185.73,99.31 185.49,99.31 184.37,98.19 184.03,98.19 183.66,98.56 183.66,98.9 184.7,99.93 184.7,100.17 184.53,100.34 184.29,100.34 183.26,99.3 182.92,99.3 181.83,100.39 181.12,100.39
PEG_HTX_GRX_P9: length 32.2
  IN4 w0.107: v1(177.04,99.54) 177.04,98.74 177.3,98.49 178.21,97.57 179.46,97.57 180.33,96.7 184.72,96.7 184.86,96.55 184.86,94.21 185.42,93.65 191.83,93.65 192.09,93.91 192.09,94.92 191.89,95.12 191.71,95.12 191.58,95.25 191.58,95.82 191.71,95.94 192.58,95.94 192.68,95.84 192.68,93.48 192.94,93.22 193.79,93.22 194.05,93.48 v1(194.05,95.19)
  BOTTOM w0.089: v1(177.04,99.54) 176.73,99.23 U6.J6
  BOTTOM w0.114: CU23.1 195.66,95.79 195.66,95.89 195.49,96.06 194.34,96.06 193.85,95.58 193.85,95.39 v1(194.05,95.19)
PEG_HTX_GRX_P10: length 32.8
  BOTTOM w0.089: 182.16,101.47 182.13,101.45 179.95,101.45 179.87,101.52 179.87,101.89 179.77,101.99 179.63,101.99 179.53,101.89 U6.E2
  BOTTOM w0.114: CU22.1 197.81,96.91 197.44,96.91 197.36,96.99 v9(193.48,96.99) 190.66,96.99 190.64,97.01 190.08,97.01 190.06,96.99 189.68,96.99 189.51,97.16 189.51,97.35 190.08,97.92 190.08,98.28 189.73,98.63 189.37,98.63 188.63,97.88 188.47,97.88 188.22,98.13 188.22,98.29 188.98,99.04 188.98,99.4 188.63,99.75 188.27,99.75 187.51,99 187.35,99 187.11,99.24 187.11,99.4 187.74,100.04 187.74,100.39 187.39,100.75 187.03,100.75 186.4,100.11 186.24,100.11 186,100.35 186,100.51 186.6,101.12 186.6,101.48 186.25,101.83 185.89,101.83 185.29,101.22 184.9,101.22 184.76,101.37 184.76,102.67 184.51,102.92 184.01,102.92 183.76,102.67 183.76,101.59 183.64,101.47 182.16,101.47
PEG_HTX_GRX_P11: length 32
  IN4 w0.107: v1(177.78,100.32) 177.78,100.84 178.01,101.08 178.98,101.08 180.83,99.24 186.27,99.24 186.55,98.96 186.55,97.01 186.68,96.88 187.2,96.88 187.31,96.99 187.31,97.41 187.56,97.67 188.03,97.67 188.29,97.41 188.29,96.99 188.4,96.88 188.78,96.88 188.89,96.99 188.89,97.41 189.15,97.67 189.61,97.67 189.87,97.41 189.87,94.8 190,94.68 190.51,94.68 190.64,94.8 190.64,96.61 190.91,96.88 193.49,96.88 193.61,97.01 193.61,98.19 193.89,98.47 194.72,98.47 195,98.19 v1(195,97.59)
  BOTTOM w0.089: U6.G5 177.61,99.97 177.78,100.14 v1(177.78,100.32)
  BOTTOM w0.114: CU21.1 196.06,97.56 195.47,98.16 194.97,98.16 194.78,97.97 194.78,97.81 v1(195,97.59)
PEG_HTX_GRX_P12: length 32.6
  IN4 w0.107: v1(177.73,101.99) 177.89,102.15 177.89,102.3 178.3,102.71 180.98,102.71 182.02,101.67 187.09,101.67 187.33,101.43 187.33,100.9 187.46,100.77 187.74,100.77 187.86,100.9 187.86,101.43 188.1,101.67 188.96,101.67 189.22,101.41 189.22,100.22 188.96,99.96 188.58,99.96 188.46,99.83 188.46,99.23 188.58,99.1 190.68,99.1 190.76,99.18 190.76,99.57 191.02,99.83 192.94,99.83 193.2,99.57 193.2,98.46 192.94,98.2 192.54,98.2 192.38,98.05 v1(192.38,97.52)
  BOTTOM w0.089: U6.E4 178.13,101.6 178.12,101.6 v1(177.73,101.99)
  BOTTOM w0.114: CU20.1 198.22,98.62 197.71,99.12 197.63,99.12 197.37,98.87 194.62,98.87 193.75,98.01 192.13,98.01 192.08,97.95 192.08,97.83 v1(192.38,97.52)
PEG_HTX_GRX_P13: length 29.7
  IN4 w0.107: v1(191.05,97.52) 191.05,98.17 190.83,98.38 187.94,98.38 187.72,98.61 187.72,99.68 187.45,99.95 186.73,99.95 186.62,100.06 186.62,100.7 186.36,100.96 185.9,100.96 185.64,100.7 185.64,100.06 185.53,99.95 185.21,99.95 185.1,100.06 185.1,100.7 184.85,100.96 184.38,100.96 184.12,100.7 184.12,100.06 184.01,99.95 183.69,99.95 183.59,100.06 183.59,100.7 183.33,100.96 182.86,100.96 182.6,100.7 182.6,100.06 182.49,99.95 181.92,99.95 180.36,101.51 177.67,101.51 177.36,101.83 177.36,101.93 177.12,102.17 176.74,102.17 v1(176.69,102.22)
  BOTTOM w0.089: v1(176.69,102.22) 176.37,102.54 U6.D6
  BOTTOM w0.114: v1(191.05,97.52) 190.84,97.73 190.84,97.88 191.7,98.74 193.48,98.74 194.99,100.25 195.48,100.25 196.06,99.67 CU19.1
PEG_HTX_GRX_P14: length 31.3
  IN4 w0.107: v1(176.73,103.58) 177.35,103.58 177.79,104.02 181.67,104.02 183.3,102.38 189.68,102.38 190.29,101.78 192.16,101.78 192.42,101.52 192.42,100.66 192.16,100.4 190.23,100.4 190.09,100.26 v1(190.09,99.6)
  BOTTOM w0.089: v1(176.73,103.58) 177.08,103.94 U6.B5
  BOTTOM w0.114: v1(190.09,99.6) 189.78,99.91 189.78,100.02 189.84,100.08 193.67,100.08 194.55,100.96 197.38,100.96 197.63,101.21 197.73,101.21 198.22,100.71 CU18.1
PEG_HTX_GRX_P15: length 30
  IN4 w0.107: v1(175.91,102.86) 175.76,103.02 175.63,103.02 175.25,103.41 175.25,104 176.21,104.96 183.24,104.96 183.48,104.72 183.48,103.85 183.61,103.72 183.89,103.72 184.02,103.85 184.02,104.72 184.25,104.96 184.91,104.96 185.23,104.64 185.23,103.23 185.36,103.1 186.13,103.1 186.24,103.21 186.24,103.36 185.89,103.72 v1(185.88,103.72)
  BOTTOM w0.089: v1(175.91,102.86) 176.29,103.24 U6.C6
  BOTTOM w0.114: CU17.1 195.83,101.9 194.15,101.9 193.13,100.88 188.09,100.88 185.88,103.09 v1(185.88,103.72)
PEX_TSTCLK_OUT: length 3.1
  TOP w0.102: RV286.2 205.51,100.01 205.51,99.1 205.73,98.88 206.15,98.88 206.23,98.8 v1(206.23,98.69)
  BOTTOM w0.089: UV1.AJ26 206.54,99 v1(206.23,98.69)
PEX_TSTCLK_OUT#: length 2.5
  TOP w0.102: v1(206.23,99.37) 206.04,99.19 205.85,99.19 205.74,99.3 205.74,100.27 RV286.1
  BOTTOM w0.089: v1(206.23,99.37) 205.85,99 UV1.AK26
PHASE1: length 51.8
  IN2 w1.016: 114.04,70.24 123.38,70.24 126.25,73.11 126.25,99.49 125.51,100.23 125.51,109.14 124.98,109.67 124.98,110.98
  vias: v2(111.06,71.69) v9(112.59,70.7) v9(113.07,71.13) v9(125.01,112.86) v9(125.01,112.2)
PHASE2: length 3.2
  BOTTOM w1.016: 120.52,107.83 121.41,108.72 121.41,110.69
  vias: v2(121.42,113.62)
PLT_RST#: length 284.9
  TOP w0.076: 168.38,16.41 168.37,16.42 v3(168.16,16.42)
  TOP w0.089: UE1.M5 167.53,16.41 168.15,16.41 v3(168.16,16.42) ; 168.78,16.01 168.38,16.41
  TOP w0.102: 168.78,16.01 169.01,15.78 170.45,15.78 RE57.2 ; UH5.4 259.36,11.28 CM22.1 RH155.1 256.26,12.01 255.93,12.34 254.23,12.34 253.49,11.6 v3(250.26,11.6) ; U1.16 204.08,12.33 v1(203.71,12.71) ; v8(129.7,109.53) 130,109.23 RU12.2 131,109.23 v1(131.7,109.93)
  GND1 w0.089: v3(168.16,16.42) 168.25,16.52 v4(168.59,16.52)
  GND1 w0.102: v3(250.26,11.6) 249.9,11.6 v4(249.57,11.27)
  IN1 w0.076: 160.65,21.24 161.68,20.21 161.68,18.98 161.92,18.74 161.92,17.73 162.75,16.9 162.75,16.58 163.09,16.24 165.48,16.24 165.66,16.43 168.51,16.43 v4(168.59,16.52)
  IN1 w0.102: 160.65,21.24 160.65,21.24 151.75,21.24 151.1,21.89 151.1,22.98 150.2,23.88 150.2,26.57 151.45,27.81 151.45,31.04 148.3,34.18 148.3,43.77 136.94,55.13 136.94,64.52 137.34,64.92 137.34,86.16 136.93,86.57 136.93,90.46 139.1,92.63 v1(139.51,92.63)
  IN2 w0.102: v1(203.71,12.71) 204.2,12.22 207.49,12.22 209.5,14.23 211.52,14.23 213.73,16.44 217.25,16.44 221.64,12.05 233.64,12.05 234.93,13.34 235.68,13.34 236.33,12.69 239.56,12.69 239.81,12.94 241.19,12.94 242.09,12.04 248.8,12.04 v4(249.57,11.27)
  IN3 w0.076: 168.78,16.34 168.72,16.34 168.59,16.47 v4(168.59,16.52)
  IN3 w0.102: v1(203.71,12.71) 203.08,12.09 195.04,12.09 193.67,13.46 186.13,13.46 184.19,15.4 169.72,15.4 168.78,16.34
  IN4 w0.102: v1(280.61,23.95) 281.13,23.43 281.13,17.33 279.19,15.4 272.65,15.4 272.01,14.76 267.72,14.76 266.86,13.9 265.49,13.9 v6(263.94,12.35) 254.72,12.35 254.01,11.64 253.04,11.64 252.79,11.39 249.69,11.39 v4(249.57,11.27)
  GND3 w0.102: v6(263.94,12.35) 263.94,12.35 264.3,12 v7(264.3,11.87)
  BOTTOM w0.102: JTB1.30 265.3,10.23 264.3,11.23 v7(264.3,11.87) ; v1(131.7,109.93) 133.47,108.15 UU2.2 133.47,102.38 133.21,102.12 129.93,102.12 129.6,101.79 129.6,101.02 130.36,100.26 131.23,100.26 133.16,98.33 133.16,97.04 134.07,96.12 135,96.12 135.36,95.77 135.36,93.74 135.87,93.23 138.91,93.23 v1(139.51,92.63) ; v1(280.61,23.95) 280.86,24.2 JSSD.17
PLTRST_VGA#: length 75.7
  TOP w0.102: UH4.4 241.15,43.97 RH154.1 241.15,44.46 241.59,44.91 243.5,44.91 244.13,45.54 v8(244.13,50.12) 244.13,51.21 242.1,53.25 v1(242.1,60.78)
  IN1 w0.076: v4(207.43,87.51) 207.39,87.47 207.39,85.16 206.69,84.46 206.69,77.48 206.85,77.32
  IN1 w0.102: 206.85,77.32 211.9,72.27 217.44,72.27 220.8,68.91 228.42,68.91 232.62,64.7 238.41,64.7 241.04,62.07 241.04,61.54 241.81,60.78 v1(242.1,60.78)
  GND3 w0.089: v7(207.08,87.72) 207.21,87.72 v4(207.43,87.51)
  BOTTOM w0.102: v7(207.08,87.72) 207.06,87.72 206.65,87.31 UV1.AJ12
PM_CLKRUN#: length 84.7
  TOP w0.089: v1(261.1,23.89) 260.78,24.21 259.63,24.21 259.24,23.82 257.22,23.82 256.4,22.99 255.74,22.99 RH136.2 RH120.2
  TOP w0.102: U1.15 207.6,11.68 v2(208.84,12.91) 209.63,13.7 210.94,13.7 213.16,15.92 218.26,15.92 222.2,11.98 229.54,11.98 230.62,13.06 v1(230.62,13.88)
  IN1 w0.102: v4(229.59,24.65) 230.02,24.22 230.02,19.75 228.59,18.32 228.59,15.91 v1(230.62,13.88)
  IN2 w0.089: 254.47,21.94 258.5,21.94 258.69,22.13 259.89,22.13 260.7,22.94 260.7,23.48 v1(261.1,23.89)
  IN2 w0.102: 254.47,21.94 254.42,21.99 242.19,21.99 241.93,21.73 238.5,21.73 235.38,24.85 232.83,24.85 232.14,24.17 230.07,24.17 v4(229.59,24.65)
  BOTTOM w0.102: v1(261.1,23.89) 261.4,24.19 U7.AN7
