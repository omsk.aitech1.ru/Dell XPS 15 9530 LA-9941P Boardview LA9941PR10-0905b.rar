# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_P2: length 36.6
  IN1 w0.089: v1(275.82,35.8) 275.68,35.94 275.58,35.94 274.37,34.73 274.37,30.14 275.24,29.28 275.24,25.77 274.92,25.45 274.92,21.81 274.08,20.98 274.08,19.94 273.88,19.74 273.88,17.92 274.85,16.96 274.85,14.54 274.32,14.01 274.32,13.26 273.83,12.76 273.83,12.17 273.37,11.71 272.88,11.71 272.1,10.92 270.14,10.92 269.35,11.71 268.44,11.71 268.32,11.59 268.32,11.48 268.57,11.23 v1(268.59,11.23)
  BOTTOM w0.089: v1(275.82,35.8) 275.74,35.88 275.38,35.88 275.31,35.95 274.95,35.95 274.65,36.25 U7.C36
  BOTTOM w0.102: v1(268.59,11.23) 268.31,11.51 268.31,11.97 268.36,12.02 268.44,12.02 268.5,12.08 JTB1.13
USB20_P3: length 38.2
  IN1 w0.089: v1(276.99,35.51) 277.08,35.42 277.46,35.42 277.68,35.19 277.68,30.74 276.01,29.07 276.01,25.2 275.78,24.97 275.78,24.39 276.35,23.82 276.35,21.21 275.52,20.38 275.52,18.56 276.24,17.83 276.24,12.71 275.06,11.52 v1(275.06,9.33)
  BOTTOM w0.089: U7.C34 274.34,35.56 274.82,35.56 274.98,35.72 275.26,35.72 275.3,35.69 275.41,35.69 275.77,35.32 276.15,35.32 276.34,35.51 v1(276.99,35.51)
  BOTTOM w0.102: v1(275.06,9.33) 275.06,10 274.43,10.63 272.22,10.63 270.9,11.95 JTB1.1
USB20_P4: length 37.5
  IN1 w0.089: v1(273.79,9.32) 273.39,9.72 273.39,10.03 274.34,10.98 274.34,11.72 275.59,12.98 275.59,17.14 274.53,18.19 274.53,19.41 274.74,19.61 274.74,20.62 275.35,21.23 275.35,25.27 275.62,25.54 275.62,29.46 274.88,30.2 274.88,33.17 275.66,33.95 275.66,34.2 275.83,34.37 275.96,34.37 v1(276.22,34.1)
  BOTTOM w0.089: v1(276.22,34.1) 275.66,34.1 275.45,34.32 275.45,34.73 275.27,34.91 274.97,34.91 274.83,34.77 274.48,34.77 274.21,35.03 U7.D33
  BOTTOM w0.102: v1(273.79,9.32) 273.6,9.51 273.6,9.71 273.37,9.94 271.82,9.94 270.15,11.61 269.86,11.61 269.6,11.86 269.6,11.96 269.7,12.06 JTB1.7
USB20_P9: length 342.9
  IN3 w0.13: v4(275.07,34.16) 274.88,34.35 274.76,34.35 274.42,34.02 274.42,30.52 274.84,30.1 274.84,29.26 275.65,28.45 275.65,26.14 274.38,24.86 274.38,22.64 273.33,21.58 272.18,21.58 271.2,20.6 268.33,20.6 268.14,20.42 262.65,20.42 262.27,20.8 260.63,20.8 260.18,20.35 256.53,20.35 255.26,21.62 249.85,21.62 248.88,22.59 248.27,22.59 247.2,23.66 235.58,23.66 234.61,24.62 232.82,24.62 231.86,23.66 228.12,23.66 227.69,23.22 221.98,23.22 221.55,23.66 200.81,23.66 197.06,27.4 197.06,30.85 196.41,31.5 181.82,31.5 181.72,31.4 180.58,31.4 169.65,42.32 160.87,42.32 160.08,43.11 108.49,43.11 102.27,36.89 75.95,36.89 74.55,35.49 70.47,35.49 69.4,36.56 65.88,36.56 65.42,37.02 55.14,37.02 52.75,39.4 49.9,39.4 43.52,45.79 43.52,47.18 41.69,49.01 35.88,49.01 29.88,55 29.88,60.28 30.94,61.33 30.94,73.91 31.64,74.61 31.64,83.34 32.4,84.1 32.4,90.77 30.14,93.03 30.14,103.18 30.67,103.72 31.62,103.72 v1(31.76,103.86)
  GND3 w0.089: v7(274.66,33.83) 274.66,33.83 274.67,33.83 274.69,33.82 274.69,33.84 274.71,33.81 274.73,33.81 v4(275.07,34.16)
  BOTTOM w0.089: v7(274.66,33.83) 274.64,33.81 U7.C30
  BOTTOM w0.102: v1(31.76,103.86) 31.65,103.74 30.96,103.74 30.37,104.34 30.37,104.73 30.39,104.75 30.39,105.31 30.37,105.33 30.37,105.53 29.81,106.08 28.73,106.08 28.41,106.41 LI4.4 27.88,106.41 RI9.1
USB20_P9_R: length 33.3
  IN4 w0.089: v1(29.75,114.11) 29.35,114.52 28.95,114.52 28.49,114.05 28.49,111.48 27.87,110.86 27.34,110.86 v1(26.94,110.46)
  BOTTOM w0.102: v1(29.75,114.11) 29.38,114.49 28.71,114.49 28.45,114.74 28.45,116.81 27.94,117.33 27.74,117.33 26.6,116.19 DI3.3 26.02,116.82 25.87,116.97 25.4,116.97 23.79,115.36 23.79,111.71 22.97,110.89 20.94,110.89 20.65,110.59 JTS.3 ; v1(26.94,110.46) 26.56,110.84 25.64,110.84 24.6,109.8 24.6,106.33 24.85,106.08 25.28,106.08 25.6,106.41 LI4.3 26.63,106.41 RI9.2
USB20_P12: length 31.3
  IN1 w0.089: v1(267.32,11.25) 267.14,11.43 267.14,11.94 267.83,12.63 269.99,12.63 270.68,11.94 271.99,11.94 272.42,12.36 272.42,12.66 272.68,12.92 273.05,12.92 273.65,13.52 273.65,14.28 274.15,14.79 274.15,16.72 273.23,17.65 273.23,19.72 273.42,19.92 273.42,20.74 273.13,21.03 273.13,21.36 274.52,22.76 274.52,25.9 274.85,26.23 274.85,28.99 272.98,30.86 272.98,31.74 v1(273.03,31.78)
  BOTTOM w0.089: U7.F26 272.92,31.99 272.92,31.89 v1(273.03,31.78)
  BOTTOM w0.102: v1(267.32,11.25) 267.11,11.46 267.11,11.87 267.3,12.06 JTB1.19
USB8723_TEST: length 2.3
  TOP w0.102: RI468.1 24.38,61.55 v2(25.12,61.55) UI5.22
USB_D_PD#: length 287.1
  TOP w0.102: UE36.7 147.93,20.51 148.08,20.36 148.73,20.36 148.93,20.55 148.93,22.67 149.36,23.11 153.32,23.11 v1(153.79,22.64) ; v2(30.59,65.86) 30.09,65.35 28.99,65.35 28.74,65.1 UI5.12 28.74,64.23 28.94,64.03 v3(29.27,64.03)
  GND1 w0.102: v3(29.27,64.03) v5(28.7,64.03)
  IN1 w0.102: v1(153.79,22.64) 154.06,22.92 161.79,22.92 164.93,26.06 171.22,26.06 172.21,27.05 175.42,27.05 176.85,25.62 205.18,25.62 206.67,24.14 212.77,24.14 217.38,19.53 224.04,19.53 224.39,19.17 224.39,18.27 226.31,16.35 226.31,14.63 v1(227.87,13.06) ; v4(27.94,63.48) 28.48,64.03 v5(28.7,64.03)
  IN2 w0.102: v4(27.94,63.48) 27.49,63.04 27.49,59.82 30,57.32 30,55.01 31.89,53.11 31.89,50.33 33.97,48.24 36.3,48.24 39.83,44.71 42.87,44.71 47.8,39.78 50.03,39.78 51.3,38.51 54.07,38.51 55.01,37.57 60.72,37.57 61.13,37.17 65.24,37.17 66.2,36.21 68.67,36.21 69.53,35.35 76.32,35.35 76.74,35.78 88.86,35.78 90.53,34.11 100.16,34.11 107.8,26.47 133.54,26.47 134.2,25.81 152.19,25.81 153.01,24.99 153.01,23.42 v1(153.79,22.64)
  IN3 w0.102: v1(227.87,13.06) 228.36,12.58 234.35,12.58 235.37,13.6 243.15,13.6 244.64,12.11 244.64,10.4 v4(244.54,10.29)
  IN4 w0.102: v4(244.54,10.29) 244.54,9.74 244.8,9.48 246.56,9.48 247.72,10.64 248.76,10.64 249.15,10.26 249.99,10.26 250.31,10.58 251.92,10.58 252.83,9.68 261.72,9.68 v6(261.86,9.81)
  GND3 w0.102: v7(262.1,10.07) 262.1,10.05 v6(261.86,9.81)
  BOTTOM w0.102: JTB1.46 v7(262.1,10.07)
USB_ILIM_SEL: length 358.4
  TOP w0.102: v3(146.9,16.09) 146.93,16.12 UE36.22 ; US2.4 23.58,78.16 23.67,78.25 23.67,79.31 v1(23.09,79.9)
  GND1 w0.102: v3(146.9,16.09) 146.9,16.9 v4(147,17)
  IN1 w0.102: v4(233.57,20.38) 236.09,17.86 v4(236.09,15.97)
  IN2 w0.102: v4(233.57,20.38) 233.57,20.5 232.82,21.25 200.29,21.25 198.84,19.81 193.76,19.81 192.66,18.71 175.17,18.71 174.13,17.67 171.72,17.67 170.94,18.44 169.8,18.44 168.9,17.53 168.37,17.53 v4(168.29,17.62) ; v4(144.04,17.11) 143.31,17.11 141.13,19.29 128.73,19.29 128.1,18.66 124.02,18.66 123.91,18.55 122.7,18.55 121.93,19.32 116.73,19.32 116.11,19.93 107.59,19.93 101.08,26.45 96.49,26.45 96.23,26.2 93.58,26.2 91.58,28.19 81.7,28.19 80.84,29.05 80.84,29.58 80.36,30.06 73.06,30.06 72.32,29.32 65.28,29.32 63.43,31.16 63.43,33.48 62.59,34.32 59.84,34.32 59.44,34.73 52.93,34.73 52.44,35.22 41.48,35.22 39.44,33.19 36.54,33.19 32.95,29.6 31.64,29.6 27.06,25.03 v4(23.58,25.03)
  IN3 w0.076: v4(168.29,17.62) 166.69,17.62 165.31,18.99 162.24,18.99 162.05,18.8 162.05,18.23 161.33,17.51 161.33,16.53 161.1,16.3 160.65,16.3
  IN3 w0.102: v4(144.04,17.11) 144.12,17.18 146.82,17.18 v4(147,17) 147.18,17.18 149.29,17.18 149.61,17.51 156.73,17.51 157.94,16.3 160.65,16.3 ; v1(269.17,11.31) 268.82,11.67 264.65,11.67 264.09,12.23 260.63,12.23 259.9,12.96 253.59,12.96 251.9,14.65 245.7,14.65 244.75,15.6 241.48,15.6 240.3,16.79 236.9,16.79 v4(236.09,15.97) ; v1(23.09,79.9) 22.27,79.08 22.27,77.29 22.07,77.09 22.07,75.16 22.95,74.28 22.95,69.84 26.43,66.36 26.43,58.15 25.44,57.16 25.44,55.43 22.44,52.43 22.44,51.57 v1(21.43,50.56)
  IN4 w0.102: v4(23.58,25.03) 22.97,25.64 22.97,28.99 23.79,29.8 28.71,29.8 30.01,31.1 30.01,36.68 30.52,37.19 30.52,40.62 29.39,41.75 29.39,42.01 29.15,42.25 28.29,42.25 26.35,44.18 26.35,46.77 25.54,47.58 22.54,47.58 21.43,48.7 v1(21.43,50.56)
  GND3 w0.076: v7(168.29,18.13) v4(168.29,17.62)
  BOTTOM w0.102: v1(21.43,50.56) 21.78,50.2 v2(23.66,50.2) 23.79,50.2 24.41,50.82 US1.4 ; JTB1.10 269.3,11.19 v1(269.17,11.31) ; v7(168.29,18.13) 168.3,18.14 168.3,20.65 168.03,20.91 RE61.1
USB_MCARD1_DET#: length 9.7
  TOP w0.102: v2(278,28.43) 277.58,28.85 v1(277.45,28.85)
  IN2 w0.089: 277.14,28.14 272.8,28.14 272.4,27.75 272.4,26.9 272.54,26.77 272.54,26.82 v4(272.59,26.82)
  IN2 w0.102: v1(277.45,28.85) 277.45,28.35 277.24,28.14 277.14,28.14
  GND3 w0.089: v7(272.26,27.44) 272.39,27.32 272.39,27.01 v4(272.59,26.82)
  BOTTOM w0.089: U7.H15 271.99,27.72 v7(272.26,27.44)
  BOTTOM w0.102: RH177.2 277.59,28.71 v1(277.45,28.85)
USB_OC0#: length 307.2
  TOP w0.102: v1(27.49,54.15) 27.74,53.91 v1(30.03,53.91) ; v1(20.94,74.43) 20.85,74.52 US2.13
  IN2 w0.102: v1(20.94,74.43) 22.59,72.78 22.59,69.91 24.4,68.1 24.4,64.63 25.87,63.17 25.87,61.76 24.78,60.67 24.78,59.35 27.09,57.04 27.09,54.55 v1(27.49,54.15) ; v1(113.21,24.49) 112.45,25.25 107.22,25.25 99.58,32.89 86.88,32.89 86.05,33.72 82.64,33.72 82.33,34.03 67.07,34.03 65.34,35.76 65.34,35.92 64.91,36.35 60.79,36.35 60.38,36.76 54.68,36.76 53.74,37.7 50.97,37.7 49.7,38.97 47.46,38.97 46.85,39.58 44.49,39.58 40.38,43.7 38.42,43.7 37.05,45.07 34.39,45.07 31.48,47.98 31.48,52.92 30.49,53.91 v1(30.03,53.91)
  IN3 w0.102: v1(113.21,24.49) 113.91,25.19 120.5,25.19 121.99,23.69 126.29,23.69 127.91,25.31 130.05,25.31 131.89,23.48 135.19,23.48 136.95,25.23 152.89,25.23 153.82,24.3 158.97,24.3 160.53,25.86 170.85,25.86 171.53,25.18 173.12,25.18 174.65,23.65 175.76,23.65 178.29,21.13 182.77,21.13 183.93,19.97 189.81,19.97 194.82,14.96 197.42,14.96 198.04,14.33 205.49,14.33 v4(206.54,15.38)
  IN4 w0.102: v4(269.24,16.77) 269,17.01 265.05,17.01 263.71,15.67 262.36,15.67 261.87,16.15 257.17,16.15 256.33,15.32 253.18,15.32 252.35,14.49 243.51,14.49 243.15,14.13 236.8,14.13 236.62,13.95 234.26,13.95 233.69,13.38 229.36,13.38 228.78,13.96 227.05,13.96 226.48,13.38 224.78,13.38 221.21,16.95 212.16,16.95 211.64,17.46 206.89,17.46 206.48,17.05 206.48,15.45 v4(206.54,15.38)
  GND3 w0.102: v7(269.69,16.77) v4(269.24,16.77)
  BOTTOM w0.089: 269.69,19.66 269.69,21.27 269.76,21.34 269.76,21.79 269.46,22.09 U7.P3
  BOTTOM w0.102: v7(269.69,16.77) 269.86,16.94 RPH29.1 269.86,17.82 269.69,17.99 269.69,19.66 ; US1.13 27.05,53.6 27.49,54.05 v1(27.49,54.15) 27.49,55.28 v2(27.85,55.63)
USB_OC1#: length 31.1
  IN2 w0.102: v4(276.64,14.97) 274.16,17.46 274.16,18.42 v4(274.93,19.19)
  IN4 w0.089: 268.41,19.66 268.33,19.75 v6(268.16,19.75)
  IN4 w0.102: v4(274.93,19.19) 274.84,19.1 272.04,19.1 271.62,19.52 270.33,19.52 270.12,19.3 268.77,19.3 268.41,19.66 ; v6(270.29,9.99) 270.43,9.85 271.7,9.85 271.96,10.1 271.96,11.26 272.6,11.9 274.2,11.9 276.64,14.34 v4(276.64,14.97)
  GND3 w0.089: v7(268.09,20.19) 268.09,19.82 v6(268.16,19.75)
  GND3 w0.102: v6(270.29,9.99) 270.19,10.09 v7(269.7,10.09)
  BOTTOM w0.089: U7.V1 268.09,21.4 v7(268.09,20.19) 268.09,20.15
  BOTTOM w0.102: v7(263.58,18.32) 264.01,18.74 264.52,18.74 264.93,19.15 267.09,19.15 v2(267.58,19.64) 268.09,20.15 ; JTB1.8 v7(269.7,10.09)
USB_OC2#: length 6.9
  BOTTOM w0.089: U7.U2 268.63,22.11 269.06,21.68 269.06,21.51 269.25,21.32 269.25,19.61
  BOTTOM w0.102: RPH30.3 266.8,18.08 267.26,18.54 268.79,18.54 269.25,18.99 269.25,19.61
USB_OC3#: length 6.5
  BOTTOM w0.089: U7.P1 269.45,21.64 269.45,19.61
  BOTTOM w0.102: RPH30.4 267.3,18.07 267.42,18.19 267.93,18.19 268.53,17.6 v2(268.59,17.6) 268.86,17.6 269.45,18.19 269.45,19.61
USB_OC4#: length 5.9
  BOTTOM w0.089: U7.M3 270.28,22.1 270.59,21.79 270.59,21.06 270.3,20.77 270.3,19.66
  BOTTOM w0.102: RPH29.4 271.36,18.55 v2(270.42,19.49) 270.3,19.61 270.3,19.66
USB_OC5#: length 6.1
  BOTTOM w0.089: U7.T1 268.65,21.56 269.04,21.17 269.04,19.61
  BOTTOM w0.102: 269.04,19.61 269.04,19.32 v2(268.66,18.94) 268.46,18.74 266.97,18.74 266.3,18.07 RPH30.2
USB_OC6#: length 5
  BOTTOM w0.089: U7.N2 269.97,22.03 269.97,21.15 269.89,21.07 269.89,19.66
  BOTTOM w0.102: RPH29.2 270.36,18.08 269.89,18.54 269.89,19.66
USB_OC7#: length 4.7
  BOTTOM w0.089: 270.1,19.66 270.1,20.9 270.28,21.08 U7.M1
  BOTTOM w0.102: RPH29.3 270.86,18.29 270.1,19.06 270.1,19.66
USBCHG_DET#_D: length 10.4
  TOP w0.102: DE10.2 DE16.2 ; DE16.2 186.07,13.6 RE44.1 RE50.2 185.52,12.06 QE1.2 ; DE16.2 DE15.2 DE18.2 186.19,17.03 v2(185.93,17.29)
USBCHG_DET_D: length 4.3
  TOP w0.102: QE1.1 181.02,13.03 180.72,13.33 RE341.1 RE59.2 180.11,12.4 v2(181.02,11.49)
USBP0_D+: length 2.6
  BOTTOM w0.102: US1.10 24.91,55 25.03,55.11 25.03,55.3 25,55.32 25,55.94 25.03,55.96 25.03,56.19 24.72,56.5 LI1.1
USBP0_D-: length 2.6
  BOTTOM w0.102: LI1.4 25.57,56.5 25.23,56.16 v9(25.23,55.58) 25.23,55.17 25.41,55 US1.11
USBP0_R_D+: length 21.3
  IN4 w0.089: v1(23.28,55.51) 23.06,55.29 23.06,54.9 22.75,54.59 21.71,54.59 19.68,56.62 16.45,56.62 15.54,55.71 JUSB1.3
  BOTTOM w0.102: v1(23.28,55.51) 23.1,55.69 23.1,56.15 22.87,56.38 22.29,56.38 22.19,56.47 22.19,56.84 22.29,56.93 22.64,56.93 DI2.2 22.12,57.33 22.03,57.42 22.03,57.82 22.52,58.31 23.09,58.31 24.22,59.44 24.35,59.44 24.37,59.42 24.93,59.42 24.95,59.44 25.09,59.44 25.22,59.31 25.22,59.19 25.1,59.07 24.81,59.07 24.72,58.99 LI1.2
USBP0_R_D-: length 21
  IN4 w0.089: v1(22.7,55.51) 22.87,55.33 22.87,54.98 22.67,54.78 21.78,54.78 19.76,56.8 16.45,56.8 15.54,57.71 JUSB1.2
  BOTTOM w0.102: LI1.3 25.57,58.88 25.43,59.02 25.43,59.4 25.18,59.65 v9(24.65,59.65) 24.14,59.65 23,58.51 22.43,58.51 21.82,57.9 21.82,57.54 21.6,57.33 DI2.3 21.5,56.93 21.86,56.93 21.98,56.81 21.98,56.39 22.2,56.17 22.79,56.17 22.89,56.06 22.89,55.71 v1(22.7,55.51)
USBP1_D+: length 3.9
  TOP w0.102: LI7.1 17.38,76.5 17.62,76.73 17.62,77.2 17.89,77.47 18.68,77.47 18.86,77.66 US2.10
USBP1_D-: length 3.9
  TOP w0.102: US2.11 19.46,77.16 19.39,77.22 19.39,77.37 19.31,77.45 18.95,77.45 18.74,77.24 v9(18.27,77.24) 17.95,77.24 17.82,77.11 17.82,76.97 17.96,76.84 18.09,76.84 18.23,76.69 LI7.4
USBP1_R_D+: length 21.4
  TOP w0.102: LI7.2 17.38,74.08 17.65,73.81 17.65,73.49 17.87,73.27 18.61,73.27 18.63,73.25 19.19,73.25 19.21,73.27 20.01,73.27 20.37,73.63 v1(20.37,73.89)
  IN4 w0.089: v6(19.56,70.82) 19.44,70.95 18.45,70.95 17.29,72.11 17.29,74.32 16.85,74.76 15.94,74.76 15.39,74.21 JUSB3.3
  GND3 w0.102: v6(19.56,70.82) 19.69,70.95 19.85,70.95 v7(19.97,70.82)
  BOTTOM w0.102: v7(19.97,70.82) 20.08,70.93 20.55,70.93 20.85,70.63 20.85,70.25 DI5.2 21.23,70.28 21.23,70.61 21.51,70.88 21.64,70.88 22.24,71.48 22.24,72.73 21.77,73.19 20.57,73.19 20.37,73.39 v1(20.37,73.89)
USBP1_R_D-: length 21.4
  TOP w0.102: v1(19.78,73.89) 20,73.68 20,73.55 19.92,73.48 v9(18.91,73.48) 17.96,73.48 17.86,73.58 17.86,73.71 18.23,74.08 LI7.3
  IN4 w0.089: JUSB3.2 15.38,76.21 16.14,75.45 16.14,75.09 16.29,74.94 16.92,74.94 17.47,74.39 17.47,72.18 18.53,71.13 19.44,71.13 v6(19.56,71.25)
  GND3 w0.102: v7(19.97,71.25) 19.85,71.13 19.69,71.13 v6(19.56,71.25)
  BOTTOM w0.102: v1(19.78,73.89) 20.16,73.52 20.16,73.3 20.48,72.98 21.69,72.98 22.03,72.64 22.03,71.57 21.55,71.09 21.37,71.09 21.23,71.23 21.23,71.8 DI5.3 20.85,71.83 20.85,71.24 20.75,71.14 20.08,71.14 v7(19.97,71.25)
USBRBIAS: length 4.8
  TOP w0.089: v2(273.86,31.76) 273.41,31.31 RH143.1 272.87,31.36 271.67,31.36 v1(271.26,31.77)
  BOTTOM w0.102: U7.K26 271.26,32.12 v1(271.26,31.77) 271.26,31.41 U7.K24
VCIN0_PH: length 108.3
  TOP w0.089: HU101.1 RU118.1 148.23,85.44 147.96,85.71 142.17,85.71 ; 162.24,14.17 162.53,14.46 162.53,14.91 UE1.C2
  TOP w0.102: v3(161.27,12.33) 161.27,12.71 162.24,13.69 162.24,14.17 ; 142.17,85.71 v2(141.9,85.71) 140.2,85.71 134.69,80.21 134.69,72.17 v1(133.91,71.38)
  GND1 w0.102: v5(160.95,12.31) 161.24,12.31 v3(161.27,12.33)
  IN1 w0.102: v5(160.95,12.31) 160.94,12.32 158.94,12.32 157.81,13.45 157.81,14.11 153.36,18.56 149.49,18.56 147.65,20.4 147.08,20.4 146.39,21.09 146.39,23.79 143.74,26.45 143.74,31.65 142.96,32.43 139.27,32.43 137.81,33.9 137.81,44.72 134.45,48.07 134.45,67.85 133.39,68.92 133.39,70.86 v1(133.91,71.38)
VCIN1_PH: length 6
  TOP w0.089: 163.03,14.23 163.03,14.91 UE1.D2
  TOP w0.102: v2(161.06,11.25) 161.66,11.85 PR118.1 PC111.1 163.03,11.87 PR116.2 162.52,13.22 162.52,13.67 163.03,14.18 163.03,14.23
VCORE_VDDP: length 6.7
  TOP w0.102: v2(122.22,111.55) 122.56,111.21 PR712.2
  TOP w0.254: PR712.2 123.33,112.36 v9(123.41,112.43) 123.61,112.64 123.61,113.28 PC708.2
  BOTTOM w0.203: PU700.22 124,113.66 123.89,113.55 123.6,113.55 ; 123.6,113.55 123.6,112.63 v9(123.41,112.43) ; 123.6,113.55 PU700.23
VCOUT0_PH#: length 10.9
  TOP w0.089: UE1.E4 163.51,15.89 163.45,15.89 v1(163.26,15.69)
  TOP w0.102: RE32.1 v3(170.61,13.22)
  GND1 w0.102: v3(170.61,13.22) 170.15,13.22 v4(169.96,13.02)
  IN2 w0.076: v1(163.26,15.69) 163.6,15.35 164.15,15.35 164.53,14.97 166.97,14.97 168.34,13.6
  IN2 w0.102: v4(169.96,13.02) 169.53,13.44 168.49,13.44 168.34,13.6
  BOTTOM w0.076: v2(163.36,15.02) 163.26,15.12 v1(163.26,15.69)
VR_HOT_CPU: length 2.6
  BOTTOM w0.203: PR722.2 124.85,119.66 124.8,119.6 PU700.5
VR_ON: length 146.3
  TOP w0.076: v3(165.9,14.17) 165.87,14.2 165.87,14.57 UE1.J1
  TOP w0.102: v1(121.3,122.61) 121.67,122.61 v8(122.16,123.1)
  GND1 w0.076: v3(165.9,14.17) 165.9,14.27 v4(166.24,14.61)
  IN1 w0.076: 160.65,18.6 160.8,18.45 160.8,17.53 161.18,17.15 161.26,17.15 161.58,16.84 161.58,16.6 162.55,15.63 162.84,15.63 163.11,15.35 165.07,15.35 165.13,15.28 165.52,15.28 166.19,14.61 v4(166.24,14.61)
  IN1 w0.102: 160.65,18.6 159.61,19.64 157.34,19.64 156.87,19.17 149.75,19.17 148.93,19.99 148.93,21.9 147.71,23.11 147.71,25.62 145.86,27.47 145.86,44.06 135.42,54.5 135.42,76.95 136.02,77.55 136.02,84.99 135.19,85.82 v1(135.19,88.72)
  IN2 w0.102: v1(135.19,88.72) 135.17,88.72 134.66,89.23 134.66,93.48 133.08,95.06 133.08,112.91 132.28,113.71 132.28,119.63 129.45,122.46 125.95,122.46 124.39,124.02 121.11,124.02 120.76,123.68 120.76,122.74 120.89,122.61 v1(121.3,122.61)
  GND3 w0.076: v7(166.81,14.75) 166.38,14.75 v4(166.24,14.61)
  BOTTOM w0.254: PR710.1 v1(121.3,122.61)
VR_ON_VCORE: length 3.7
  BOTTOM w0.203: PR710.2 121.86,120.28 122.19,120.28 v2(122.69,119.77) 123.6,118.86 PU700.2
VR_SVID_ALRT#: length 41.6
  IN3 w0.13: v1(118.81,119.77) 119.63,119.77 121.03,121.17 122.89,121.17 123.4,120.67 126.67,120.67 127.48,119.86 128.92,119.86 129.45,119.32 129.45,108.05 136.38,101.12 136.38,99.75 137.83,98.31 v1(138.11,98.31)
  BOTTOM w0.102: v1(138.11,98.31) 137.73,98.31 137.6,98.43 v2(137.6,98.69) 137.6,99.19 137.86,99.45 138.76,99.45 RU91.2 RU93.1 ; PR705.1 v1(118.81,119.77)
VR_SVID_CLK: length 41.3
  TOP w0.102: v1(123.3,122.78) 123.06,122.54 PR706.1
  IN3 w0.13: v1(123.3,122.78) 123.3,122.64 124.69,121.25 126.92,121.25 127.72,120.45 129.16,120.45 130.04,119.57 130.04,108.36 137.09,101.31 137.09,99.96 v1(138.11,98.95)
  BOTTOM w0.089: 142.17,99 143.32,99 143.68,98.65 143.99,98.65 144.24,98.39 145.46,98.39 U6.J52
  BOTTOM w0.102: v1(138.11,98.95) 138.18,98.88 v2(139.18,98.88) 139.44,98.88 139.57,99 142.17,99
VR_SVID_DAT: length 47.9
  IN3 w0.13: v1(118.81,118.88) 119.57,118.88 121.27,120.59 122.64,120.59 123.15,120.08 126.43,120.08 127.24,119.27 128.67,119.27 128.87,119.08 128.87,107.8 135.75,100.92 135.75,99.5 137.56,97.68 v1(138.11,97.68)
  BOTTOM w0.089: U6.J50 146.86,98.38 145.73,98.38 145.54,98.2 144.14,98.2 143.89,98.45 143,98.45 142.23,97.68 142.17,97.68
  BOTTOM w0.102: v1(138.11,97.68) 138.2,97.59 v2(138.75,97.59) 139.41,97.59 RU90.2 140.84,97.68 142.17,97.68 ; PR703.1 v1(118.81,118.88)
VSB_N_001: length 9.6
  TOP w0.102: v2(115.26,10.79) PR108.2
  TOP w0.254: PQ102.3 115.86,12.38 115.75,12.27 115.65,12.27 PR108.2 115.45,11.69 v1(116.13,11.69) ; PR107.2 121.09,11.01 v3(121.09,11.95)
  GND1 w0.254: v3(121.09,11.95) 120.69,11.95 v5(120.58,11.84)
  IN1 w0.254: v1(116.13,11.69) 120.44,11.69 v5(120.58,11.84)
VSB_N_002: length 5.9
  TOP w0.102: PR112.2 113.24,14.36 112.72,13.84 110.76,13.84 v2(110.44,13.52)
  TOP w0.254: PR112.2 113.3,13.4 PQ103.2 113.55,12.77 PC110.1
VSB_N_003: length 3.9
  TOP w0.102: PQ103.1 112.46,10.99 112.24,10.78 v2(111.42,10.78)
  TOP w0.254: PR108.1 114.22,12.01 112.71,12.01 112.46,11.76 PQ103.1
VSET: length 5
  TOP w0.102: v1(254.13,50.55) 253.95,50.38 RZ601.1 RZ600.2
  BOTTOM w0.102: v1(254.13,50.55) 254.13,49.42 254.29,49.26 v2(254.42,49.26) 254.65,49.26 254.95,49.56 UZ600.4
WAKE#: length 12.5
  TOP w0.102: v1(273.19,14.74) v2(273.7,14.74) 273.92,14.74 274.97,15.79 RPH4.7
  BOTTOM w0.089: 271.58,19.06 270.78,19.86 270.78,21.8 270.98,22 270.98,22.31 271.09,22.42 U7.K3
  BOTTOM w0.102: v1(273.19,14.74) 272.02,15.91 272.02,18.62 271.58,19.06
WAKE_PCH#: length 152.8
  TOP w0.089: RH170.2 269.74,25.55 v1(269.53,25.76) ; 166.72,21.72 166.72,21.04 166.53,20.85 166.53,20.41 UE1.L12
  TOP w0.102: v3(270.69,14.31) 270.73,14.36 272.14,14.36 272.25,14.25 274.2,14.25 274.51,14.56 275.59,14.56 276.66,13.5 276.66,11.13 RH173.2 275.56,10.04 v1(275.55,10.04) ; 166.72,21.72 166.72,22.45 RE76.2 168.36,22.77 170.65,22.77 v2(171.21,23.33) 172.12,24.24 175.17,24.24 175.45,24.52 183.87,24.52 188.02,20.37 188.02,11.67 188.68,11.01 v1(188.68,11.01)
  GND1 w0.102: v3(270.69,14.31) 270.41,14.31 v5(270.37,14.36)
  IN1 w0.076: 270.22,19.66 270.22,20.33 269.84,20.71 269.84,23.11 270.12,23.39 270.12,23.73 270.12,23.74 270.12,24.56 269.97,24.7 269.97,25.32 v1(269.53,25.76)
  IN1 w0.102: v5(270.37,14.36) 270.1,14.63 270.1,18.44 270.22,18.56 270.22,19.66
  IN2 w0.102: v1(275.55,10.04) 275.25,9.74 272.98,9.74 272.3,9.05 250.05,9.05 249.88,9.22 246.21,9.22 244.61,10.82 236.55,10.82 236.34,10.62 221.06,10.62 216.66,15.02 214.32,15.02 210.3,11 190.38,11 190.16,11.22 188.9,11.22 v1(188.68,11.01)
  BOTTOM w0.089: U7.R11 269.31,25.98 v1(269.53,25.76)
WL_OFF#: length 57.9
  TOP w0.089: v2(260.97,22.64) 260.98,22.63 RH243.2 262.12,23.3 v1(262.12,23.3)
  IN1 w0.076: v1(262.12,23.3) 262.12,22.28 259.56,19.72 259.56,19.66
  IN1 w0.102: v4(260.76,14.01) 260.74,14.02 260.74,15.76 259.56,16.94 259.56,19.66
  IN2 w0.102: v4(260.76,14.01) 260.99,13.77 264.04,13.77 264.98,12.84 266.71,12.84 267.08,13.21 270.24,13.21 v4(270.87,12.58)
  IN3 w0.089: v4(273.72,26.84) 274.36,26.84 274.45,26.94
  IN3 w0.102: v1(262.12,23.3) 262.93,22.49 267.69,22.49 268.01,22.81 268.01,27.7 268.31,28 269.36,28 270.07,28.71 273.75,28.71 274.7,27.76 274.7,27.19 274.45,26.94
  IN4 w0.102: v6(265.97,12.05) 268.59,12.05 269.38,12.84 270.61,12.84 v4(270.87,12.58)
  GND3 w0.089: v7(274.25,26.9) 274.11,26.77 273.82,26.77 273.74,26.84 v4(273.72,26.84)
  GND3 w0.102: v7(265.8,11.72) 265.8,11.87 v6(265.97,12.05)
  BOTTOM w0.089: 277.14,27.09 276.86,26.81 274.99,26.81 274.8,26.62 274.53,26.62 v7(274.25,26.9) ; U7.AL6 262.41,23.59 v1(262.12,23.3)
  BOTTOM w0.102: JTB1.26 266.1,10.65 265.7,11.05 265.7,11.62 v7(265.8,11.72) ; 277.14,27.09 277.61,27.55 RPH2.4
WLAN_WAKE#: length 7.2
  TOP w0.102: UE36.21 146.43,16.1 146.59,15.94 146.59,15.21 146.66,15.15 146.66,13.86 146.56,13.76 145.96,13.76 v2(145.88,13.69) 145.77,13.57 145.77,12.47 RE66.2 146.32,11.82 DE12.2
XDP_BPM#0: length 15
  TOP w0.089: 142.34,102.59 142.35,102.57 142.35,101.27 143,100.62 143,97.25 143.63,96.61 146.22,96.61 146.42,96.41 146.42,95.65 146.79,95.27 v1(146.79,94.2)
  TOP w0.102: JXDP.21 v2(141.76,103.05) 141.88,103.05 142.34,102.59
  BOTTOM w0.089: U6.R51 146.47,94.52 v1(146.79,94.2)
XDP_BPM#1: length 15.1
  TOP w0.102: JXDP.23 141.74,103.55 142.56,102.73 142.56,101.34 143.25,100.65 143.25,97.27 143.72,96.81 146.57,96.81 v2(146.68,96.69) 147.19,96.18 147.19,95.38 v1(147.51,95.07)
  BOTTOM w0.089: U6.R50 147.17,94.76 147.2,94.76 v1(147.51,95.07)
XDP_DBRESET#: length 215.3
  TOP w0.102: v1(136.87,113.24) 136.33,113.77 135.29,113.77 134.87,113.36 132.01,113.36 131.51,112.85 v2(131.51,112.3) 131.96,111.85 131.96,111.03 RU35.1 131.81,110.43 132.7,109.55 JXDP.48
  IN1 w0.076: v1(136.87,113.24) 136.89,113.26 140.5,113.26 140.84,113.61 145.52,113.61 150.16,108.97 171.16,108.97 174.5,105.63 174.5,104.97 175.13,104.34 179.58,104.34 182.67,101.25 182.67,90.84 190.39,83.12 191.5,83.12 197.98,76.64 197.98,73.29 210.09,61.18 214.31,61.18 215.59,59.9 230.52,59.9 230.57,59.85 237.17,59.85 253.45,43.57 254.03,43.57 254.37,43.24 254.37,35.28 254.53,35.12 254.53,33.13 v4(254.72,32.93)
  IN2 w0.089: v1(261.96,20.4) 261.96,21.85 262.72,22.61 262.72,26.5 262.11,27.11 255.81,27.11 255.46,27.47 255.46,30.84 254.63,31.67 254.63,32.84 v4(254.72,32.93)
  IN3 w0.089: 142.17,102.88 142.94,102.12 v1(143.06,102.12)
  IN3 w0.13: v1(136.87,113.24) 136.87,112.78 137.96,111.69 138.98,111.69 140.77,109.9 140.77,104.29 142.17,102.88
  BOTTOM w0.089: v1(143.06,102.12) 143.06,101.86 143.25,101.67 143.76,101.67 144,101.43 144.89,101.43 145.07,101.25 U6.F53 ; U7.AM1 262.15,21.35 261.96,21.17 v1(261.96,20.4)
XDP_PRDY#: length 8.1
  TOP w0.089: v1(144.71,95.83) 144.51,96.03 143.21,96.03 143.17,96.07 v2(142.86,96.07) 142.22,96.07 142.17,96.03
  TOP w0.102: JXDP.5 140.85,99.05 141.49,98.41 141.49,96.23 141.69,96.03 142.17,96.03
  BOTTOM w0.089: U6.N53 144.71,95.9 v1(144.71,95.83)
XDP_PREQ#: length 8.8
  TOP w0.089: 142.17,95.77 143.97,95.77 v2(144.32,95.41) 144.87,95.41 145.28,95.83 v1(145.44,95.83)
  TOP w0.102: 142.17,95.77 142.14,95.77 142.12,95.75 141.68,95.75 141.29,96.15 141.29,98.05 140.79,98.55 JXDP.3
  BOTTOM w0.089: v1(145.44,95.83) 145.44,95.93 U6.N52
XDP_RST#_R: length 2.3
  TOP w0.102: RU12.1 132,109.05 JXDP.46
XDP_TCK: length 31.3
  TOP w0.102: v8(141.97,111.69) 141.62,112.05 JXDP.57 138.45,112.05 136.85,110.44 136.85,105.82 136.36,105.33 136.36,103.78 135.89,103.31 135.89,96.62 136.36,96.15 136.36,95.22 v1(135.95,94.81)
  BOTTOM w0.089: U6.N54 143.81,96.26 142.89,95.33 142.34,95.33
  BOTTOM w0.102: 142.34,95.33 140.65,95.33 RU67.1 v1(135.95,94.81)
XDP_TDI: length 31
  TOP w0.089: v1(147.57,95.86) 147.57,95.83 v8(148.07,95.33)
  TOP w0.102: v1(136.27,113.22) 136.27,112.34 135.48,111.55 JXDP.56
  IN3 w0.089: 142.17,101.18 142.2,101.18 142.94,100.44 142.94,98.28 143.6,97.62 144.03,97.62 144.51,98.1 147,98.1 147.57,97.53 v1(147.57,95.86)
  IN3 w0.102: 142.17,101.18 141.05,101.18 140.47,101.76 140.27,101.96 140.27,109.7 138.77,111.19 137.08,111.19 136.27,112.01 v1(136.27,113.22)
  BOTTOM w0.089: U6.N49 147.57,95.96 v1(147.57,95.86)
XDP_TDO: length 33
  TOP w0.102: v8(135.77,93) 135.55,93.23 135.55,95.39 v1(135.95,95.8) 135.69,96.06 135.69,103.39 136.16,103.86 136.16,105.41 136.44,105.69 136.44,107.85 135.82,108.47 135.82,110.36 135.63,110.55 JXDP.52
  BOTTOM w0.102: U6.M49 147.45,96.65 143.57,96.65 142.87,95.96 RU66.1 140.22,95.32 138.05,95.32 137.57,95.8 v1(135.95,95.8)
XDP_TMS: length 30.8
  TOP w0.089: v1(146.09,97.45) 146.09,97.65 v8(146.67,98.23)
  TOP w0.102: v1(132.01,112.65) 132.62,112.05 JXDP.58
  IN3 w0.089: 142.17,99.83 142.37,99.64 142.37,97.32 143.26,96.43 145.07,96.43 v1(146.09,97.45)
  IN3 w0.102: v1(132.01,112.65) 132.95,111.72 134.07,111.72 135.82,109.96 135.82,108.44 137.48,106.79 139.61,106.79 139.86,106.54 139.86,100.58 140.61,99.84 142.17,99.84 142.17,99.83
  BOTTOM w0.089: U6.M51 v1(146.09,97.45)
XDP_TRST#: length 25.3
  TOP w0.089: v8(144.31,98.28) 144.73,97.86 v1(144.73,97.48)
  TOP w0.102: v1(136.44,108.59) 136.44,110.39 135.78,111.05 JXDP.54
  IN3 w0.089: v1(144.73,97.48) 144,96.76 143.39,96.76 142.7,97.45 142.7,99.84 142.5,100.04 142.17,100.04
  IN3 w0.102: 142.17,100.04 140.7,100.04 140.07,100.67 140.07,106.62 139.69,106.99 138.04,106.99 v1(136.44,108.59)
  BOTTOM w0.089: v1(144.73,97.48) 145.07,97.14 U6.M53
  BOTTOM w0.102: v1(136.44,108.59) RU68.1
XTAL25_IN: length 5.8
  BOTTOM w0.089: 263.5,42.2 263.5,42.18 v2(262.96,41.63) 262.65,41.33 262.65,40.08 262.56,39.98 U7.AL44
  BOTTOM w0.102: 263.5,42.2 263.59,42.3 RH89.2 263.19,42.97 CH28.1 263.19,44.41 YH2.3
XTAL25_OUT: length 7.9
  BOTTOM w0.089: 262.68,42.2 262.68,41.83 262.46,41.61 262.46,40.16 262.37,40.06 262.37,40.06 262.26,39.95 262.26,39.93 262.26,39.48 U7.AM43
  BOTTOM w0.102: YH2.1 262.32,45.6 CH27.1 262.68,43.16 RH89.1 262.68,42.2
XTAL_5505_IN: length 7.8
  TOP w0.102: U12.2 23.09,23.73 23.44,23.38 v2(25.06,23.38) 25.31,23.38 25.65,23.03 25.65,22.79 CA97.1 25.59,22.12 25.59,20.39 YA2.3
XTAL_5505_OUT: length 7.2
  TOP w0.102: YA2.1 25.89,21.11 25.79,21.22 25.79,22.07 CA96.1 25.86,22.72 25.86,23.24 25.36,23.73 23.53,23.73 23.03,24.23 U12.3
XTALOUTBUFF: length 19.5
  BOTTOM w0.102: UV1.J4 223.78,80.22 223.78,78.13 223.76,78.11 223.76,77 224.19,76.56 224.19,75.53 223.76,75.1 v2(223.76,67.65) 223.76,67.47 224.05,67.18 224.05,64.49 223.51,63.95 223.51,62.98 223.35,62.82 223.07,62.82 222.91,62.98 RPH32.1
XTALSSIN: length 18.7
  BOTTOM w0.089: UV1.H1 223.96,77.96 223.96,77.32
  BOTTOM w0.102: 223.96,77.32 224.45,76.84 224.45,75.5 223.96,75.01 223.96,70.68 224.26,70.39 v2(224.26,69.1) 224.26,62.78 223.77,62.3 222.9,62.3 222.41,62.79 RPH32.2
N05583: length 0.5
  TOP w0.102: v9(65.29,16.65) v2(65.29,16.11)
  vias: v9(60.82,20.38) v9(60.83,16.65) v9(60.94,21.03) v9(61.47,16.65) v9(61.57,21.03) v9(62.1,16.65) v9(62.27,21.03) v9(62.74,16.65) v9(62.9,21.03) v9(63.37,16.65) v9(63.54,21.07) v9(64.01,16.65) v9(64.64,16.65)
N3514407: length 4
  TOP w0.203: PU300.5 47.97,34.4 47.6,34.77 v2(45.77,34.77) 44.99,34.77 PR305.2
N3514423: length 3.4
  TOP w0.203: PU300.3 48.77,34.77
  TOP w0.254: 48.77,34.77 49.31,35.32 PC307.1 50.34,35.89 PR335.2
N6647607: length 3.8
  TOP w0.102: v1(73.79,31.91) v2(73.79,31.21)
  TOP w0.508: v1(73.79,31.91) 73.39,32.3 PD200.1
  BOTTOM w0.508: PR213.1 73.43,32.27 v1(73.79,31.91)
N6650847:
  vias: v2(69.91,22.74) v9(69.25,22.49) v9(70.22,18.07) v9(70.22,17.44) v9(70.22,16.8) v9(70.93,18.1) v9(70.93,17.46) v9(70.93,16.83)
N6654636: length 3.3
  BOTTOM w0.102: v2(65.64,24.75) 65.72,24.82 65.72,25.31 66.03,25.61 66.03,25.71 66.94,26.63 PR208.1
N6663158: length 4.7
  BOTTOM w0.102: v2(90.79,28.81) 91.21,29.23 PQ208.4
  BOTTOM w0.254: PR227.2 93.23,30.47 93.53,30.17 93.53,29.41 93.36,29.23 PQ208.4
N6682547: length 12.6
  BOTTOM w0.102: v2(59.93,24.19) 59.35,24.77 PQ200.4
  BOTTOM w0.254: PQ201.4 65.27,24.29 65.19,24.37 65.19,25.18 65.34,25.33 PR207.1 65.2,25.98 63.74,27.44 59.82,27.44 59.35,26.97 PQ200.4
N6682601: length 1.5
  BOTTOM w0.102: PD201.1 72.97,26.61 v2(72.86,26.5)
N12536479: length 4.3
  TOP w0.102: v1(84.06,24.21) 84.06,23.87 v2(83.49,23.3)
  TOP w0.254: v1(84.06,24.21) PR225.1 83.15,25.82 PC228.2
  BOTTOM w0.254: PQ207.2 84.26,24.4 v1(84.06,24.21)
N17034077: length 4.3
  TOP w0.203: PR306.1 52.75,34.35 51.42,34.35 50.8,34.97 v2(50.57,34.97) 50.23,34.97 49.57,34.31 PU300.1
N17034092: length 2
  TOP w0.102: PR338.1 46.8,29.19 45.93,29.19 45.72,28.98 v2(45.72,28.29)
N17198654: length 2.6
  TOP w0.089: v1(207.9,86.05) 207.9,85.43 RV479.1 207.06,85.36 v2(206.75,85.06)
  BOTTOM w0.089: UV1.AG10 208.3,85.65 v1(207.9,86.05)
N17766075: length 4
  TOP w0.102: v2(223.01,128.58) 222.83,128.4 222.83,127.76 222.76,127.68 222.2,127.68 221.85,127.34 RV349.1 RV348.1 220.79,128.2 CV643.1
N17832487: length 4.1
  BOTTOM w0.089: UV5.J1 220.3,114.75
  BOTTOM w0.102: RV352.2 221.88,112.35 v2(220.95,113.28) 220.3,113.93 220.3,114.75
N17860472: length 11.6
  BOTTOM w0.089: UV5.J13 219.85,125.72 219.85,126.27 219.21,126.91 219.21,126.96
  BOTTOM w0.102: 219.21,126.96 218.86,127.31 212.99,127.31 RV354.2 v8(211.65,124.82)
N17888940: length 14.3
  TOP w0.089: v1(222.2,86.95) 222.01,87.14 RV327.1
  BOTTOM w0.102: UV1.J27 222.63,99.13 222.63,91.69 222.85,91.48 222.85,89.49 222.63,89.28 222.63,87.38 v1(222.2,86.95)
N17889477: length 18.9
  TOP w0.089: v1(221.2,85.89) 220.33,85.89 RV328.1 219.8,86.41 v2(219.8,87.23)
  BOTTOM w0.102: UV1.H27 223.87,99.9 222.83,98.87 222.83,91.78 223.05,91.56 223.05,89.41 222.83,89.19 222.83,86.27 222.45,85.89 v1(221.2,85.89)
N17890015: length 17.4
  TOP w0.089: v2(221.22,84.32) v1(221.22,85.23) 220.09,85.23 RV329.1
  BOTTOM w0.102: UV1.H25 223.81,98.15 223.04,97.37 223.04,91.86 223.25,91.65 223.25,89.32 223.04,89.11 223.04,86.19 222.33,85.48 221.46,85.48 v1(221.22,85.23)
N17929472: length 6.4
  BOTTOM w0.102: UV1.F2 225.92,79 226.35,78.57 226.35,77.83 227.4,76.78 228.52,76.78 229.61,75.69 RV330.1
N17930576: length 6.8
  BOTTOM w0.102: v2(229.02,72.65) 228.84,72.83 228.84,73.36 228.66,73.54 RV332.1 227.83,74.68 227.83,76.06 225.9,77.99 UV1.F1
N18066258: length 3.3
  TOP w0.102: QV22.1 229.23,115.46 RV357.2 ; RV357.2 v2(230.28,115.45) ; RV357.2 RV359.2
N18135138: length 2.5
  TOP w0.089: v1(224.7,88.6) 224.67,88.57 RV346.2 224.83,87.96 225.06,88.18 225.83,88.18 v2(225.87,88.22)
  BOTTOM w0.102: UV1.G14 225.1,89 v1(224.7,88.6)
N18135149: length 2.5
  TOP w0.089: RV347.2 v1(225.55,94.43) 225.55,93.71 v2(225.18,93.34)
  BOTTOM w0.089: v1(225.55,94.43) 225.12,94 UV1.G20
N18386177: length 5.3
  TOP w0.102: RV361.1 202.79,128.02 RV362.1 203.7,128.03 CV668.1 203.71,128.11 204.11,128.52 206.84,128.52 v2(206.91,128.58)
N18928736: length 4.3
  BOTTOM w0.102: UU3.2 131.62,67.78 RU51.2 129.9,67.83 RU76.2 129.9,68.76 v2(130.14,68.99)
N19849916: length 1.7
  TOP w0.102: v2(192.05,118.84) 191.44,119.45 PC614.2
N19912586: length 1.6
  TOP w0.102: v2(171.66,116.85) 171.65,116.84 PR822.1
  vias: v1(169.34,118.38) v1(169.34,117.77)
N20180024: length 5.5
  BOTTOM w0.102: v2(134.48,118.73) 134.69,118.51 PR815.2
  BOTTOM w0.254: PR817.1 136.84,121.91 136.84,120.69 PC820.1 135.63,119.48 PR815.2
N20194225: length 6.7
  BOTTOM w0.102: v2(137.22,118.19) 137.23,118.2 PC811.1
  BOTTOM w0.254: PR804.2 137.38,120.12 138.06,119.44 PR807.2 138.21,118.22 PC811.1 138.82,118.2 139.73,117.28 PR809.1
N21723775: length 1.5
  TOP w0.102: PT601.1 191.27,122.51 v1(191.27,121.98)
  BOTTOM w0.102: PU600.1 v1(191.27,121.98)
N23212224: length 3.5
  BOTTOM w0.102: JKBL.3 230.8,22.09 230.58,22.31 R30.2 230.86,22.93 v2(231.84,23.91)
N23484074: length 2.2
  BOTTOM w0.102: RN18.1 34.28,37.95 UN1.16
N23484361: length 4.6
  BOTTOM w0.102: UN1.7 35.78,32.31 v2(36.12,31.97) 36.57,31.97 37.25,31.3 37.25,31.22 37.67,30.79 37.88,30.79 RN42.2
N25669355: length 11.5
  BOTTOM w0.089: UV6.J13 201.84,125.7 201.84,126.5 201.46,126.89 197.27,126.89 197.22,126.94 195.81,126.94 195.78,126.97
  BOTTOM w0.102: 195.78,126.97 195.69,127.06 194.68,127.06 RV365.2 v2(193.64,124.82)
N25669840: length 3.9
  BOTTOM w0.102: RV363.2 202.63,113.18 v2(202.63,113.55) 202.63,114.81 202.27,115.18 UV6.J1
N30765189: length 2.5
  TOP w0.102: v2(209.95,15.31) 209.68,15.59 R2.2 207.92,16.48 C8.1
N35393149: length 6
  BOTTOM w0.102: UV1.AP29 202.6,101.81 201.74,102.68 201.74,103 201.51,103.23 RV290.1 199.18,103.23 198.61,103.79 v2(198.61,104.53)
N37456018: length 3.6
  BOTTOM w0.102: RE54.2 173.67,22.56 CE58.1 172.67,22.3 QZ24.5 171.6,22.3 171.44,22.13 171.44,21.75 171.54,21.65 QZ24.6
N48708347: length 2.7
  BOTTOM w0.102: v2(128.28,16.09) 128.27,16.07 PC404.2
  BOTTOM w0.508: PR400.1 PC404.2
N48708367: length 1.5
  TOP w0.203: PU400.7 122.63,17.84 122.43,18.04 PR409.2
N48708425: length 2
  TOP w0.203: PU400.9 123.09,17.04 122.19,16.14 PR406.2
N48711271: length 60.8
  TOP w0.254: v1(123.57,108.02) v2(126.06,105.53) 127.52,104.07 127.52,82.48 125.03,79.99 120.89,79.99 119.52,78.62 v1(118.68,78.62)
  IN4 w0.254: v1(127.32,123.52) 129.6,121.23 129.6,114.79 123.57,108.75 v1(123.57,108.02)
  BOTTOM w0.254: PH700.2 118.27,78.19 118.68,78.6 v1(118.68,78.62) ; v1(127.32,123.52) 127.32,122.82 127.11,122.61 PR727.2 PR724.1
N48711504:
  vias: v1(112.58,83.07) v1(113.19,83.07) v2(112.63,83.85)
N49558169: length 1.8
  TOP w0.102: PR743.2 v2(116.2,80.72)
N50583534: length 5.5
  TOP w0.254: PC711.1 125.4,113.8 v1(126.58,113.8) 126.58,113.38 126.38,113.18 v2(126.38,112.44) 126.38,112.1 PR725.1
  BOTTOM w0.203: v1(126.58,113.8) 126.46,113.68 126.17,113.68 126,113.85 PU700.17
N50650291: length 5.1
  BOTTOM w0.102: v2(117.84,115.78) 117.97,115.65 119.72,115.65 120.29,116.22 PR704.2
  BOTTOM w0.203: PR704.2 121.32,116.22 121.52,116.02 PU700.28
N50662090: length 2.7
  BOTTOM w0.203: PU700.30 121.94,116.82 120.76,118 PR709.2
N50663336: length 2.5
  BOTTOM w0.203: PR707.2 121.09,117.11 v2(121.42,116.77) 121.78,116.42 PU700.29
N51036953: length 3.3
  BOTTOM w0.203: PU700.14 127.19,115.62 127.28,115.52 v2(127.95,115.52) 128.85,115.52 PC722.1
  BOTTOM w0.254: PC722.1 PR734.1
N51069821: length 3.9
  BOTTOM w0.102: v2(131.48,109.02) 130.62,109.89 PR747.2
  BOTTOM w0.254: PR747.2 129.73,110.04 PC730.1 PC731.1
N51091911: length 5.6
  TOP w0.254: PR730.1 127.71,112.16 v2(127.71,113.33) v1(127.71,114.08) PC714.1
  BOTTOM w0.203: v1(127.71,114.08) 127.71,114.36 127.25,114.82 PU700.16
N51163915: length 2.3
  TOP w0.102: v2(216.98,60.49) 216.33,59.84 RZ10.2 216.28,59.46 QZ5.6
N51163924: length 18.7
  TOP w0.102: QZ5.3 213.79,58.16 213.99,58.36 213.99,59.67 v1(213.59,60.08) ; v1(204.66,68.27) 204.15,68.78 v2(204.15,69.69) RZ11.2
  IN3 w0.102: v1(204.66,68.27) 206.54,68.27 212.3,62.51 212.3,61.36 v1(213.59,60.08)
N51197016: length 38.4
  IN4 w0.254: v1(253.25,76.21) 253.68,75.78 255.51,75.78 255.82,75.48 255.82,71.97 v1(255.31,71.46)
  BOTTOM w0.254: PC510.2 PR507.2 228.47,71.45 229.11,72.08 231.06,72.08 233.6,74.62 v2(235.77,74.62) 241.65,74.62 243.6,76.57 244.95,76.57 246.72,78.34 248.68,78.34 249.82,77.2 252.26,77.2 v1(253.25,76.21)
N52118688: length 4.6
  TOP w0.254: PR510.1 234.07,69.22 v1(234.04,69.25) 233.38,68.59 PC506.1
  BOTTOM w0.102: v2(234.53,69.53) 234.25,69.25 v1(234.04,69.25)
  BOTTOM w0.254: v1(234.04,69.25) 234.04,68.96 233.47,68.39 PU500.7
N52999986: length 64.6
  TOP w0.254: v1(21.24,89.76) v2(24.57,89.76) PL101.2
  IN2 w0.254: v1(21.24,89.76) 21.09,89.62 21.09,88.1 24.06,85.12 29.41,85.12 32.57,81.96 32.57,71.03 32.14,70.6 32.14,62.22 33.69,60.67 33.69,54.96 39.44,49.21 42.37,49.21 v1(45.11,46.46)
N55060104: length 4.3
  TOP w0.102: QN2.5 227.6,58.24 RN26.2 ; RN26.2 v2(226.95,56.42) ; RN26.2 226.95,57.59 QN2.6
N55155843: length 2.7
  TOP w0.102: QV30.1 82.9,34.23 ; 82.9,34.23 82.99,34.23 83.2,34.44 83.2,34.74 82.75,35.19 RV413.2 ; 82.9,34.23 v2(83.49,33.65)
N55341619: length 11.7
  BOTTOM w0.089: UV10.J13 252.32,104.88 252.74,105.29 253.68,105.29 253.88,105.49
  BOTTOM w0.102: RV391.2 v2(254.25,113.25) 254.47,113.04 254.47,106.08 253.88,105.49
N55342064: length 3.9
  BOTTOM w0.089: UV10.J1 242.07,104.36 241.71,104.36
  BOTTOM w0.102: RV389.2 239.91,103.44 v2(240.42,103.94) 240.84,104.36 241.71,104.36
N55342363: length 3
  TOP w0.102: v2(254.39,105.54) 254.39,105.18 254.87,104.69 RV387.1 ; RV388.1 RV387.1 ; RV387.1 255.67,104.5 CV718.1
N55351604: length 3
  TOP w0.102: CV693.1 255.19,85.03 RV374.1 RV375.1 v2(255.19,87.92)
N55351739: length 4.9
  BOTTOM w0.102: UV9.J1 242.22,86.85 242.01,87.05 v2(240.37,87.05) 240.07,87.05 239.8,87.32 238.76,87.32 238.38,86.94 RV378.2
N55351833: length 10.7
  BOTTOM w0.089: 253.88,85.79 253.17,86.49 252.54,86.49 252.19,86.85 UV9.J13
  BOTTOM w0.102: 253.88,85.79 254.13,85.54 v2(254.13,78.52) RV380.2
N55360027: length 2
  TOP w0.089: RV344.2 218.12,101.35 v1(217.93,101.16) 217.93,101.1 v2(217.55,100.72)
  BOTTOM w0.089: v1(217.93,101.16) 218.39,100.7 UV1.R28
N55376079: length 7.9
  BOTTOM w0.102: CZ8.1 210.75,69.43 CZ6.1 RZ5.2 209.08,68.46 v2(209.04,68.42) 207.55,66.94 205.29,66.94
N66076440: length 2.1
  TOP w0.102: v2(171.46,17.81) 171.78,17.5 171.78,17.28 171.52,17.03 RE13.2 CE11.1
N76227960: length 6.9
  TOP w0.102: RA60.1 RA61.1 13.42,27.87 12.38,27.87 11.64,28.61 v2(11.64,29.12) 11.64,29.57 v1(11.52,29.7)
  BOTTOM w0.102: CA75.1 11.54,30.44 11.54,29.73 v1(11.52,29.7) 11.47,29.65 UA5.10
N76228019: length 6.7
  TOP w0.102: v1(10.9,29.7) 10.9,28.03 v2(11.75,27.19) 12.74,27.19 RA61.2
  BOTTOM w0.102: UA5.9 10.82,29.61 v1(10.9,29.7) 10.9,29.92 10.34,30.49 CA76.1
N76426526: length 2.2
  TOP w0.102: QZ17.6 207.7,68.38 RZ15.2 v2(208.84,68.52)
N76474852: length 3.1
  TOP w0.102: RZ6.2 205.22,64.84 204.57,65.49 v2(204.57,65.73) 204.57,65.91 204.76,66.1 QZ17.3
N85751893: length 2
  TOP w0.102: PR504.2 v2(249.25,67.26)
N87586804: length 2.2
  TOP w0.089: v1(265.01,25.08) 264.44,24.51 264.44,23.72 T6.1
  BOTTOM w0.102: U7.AD10 265.31,25.38 v1(265.01,25.08)
N89512774: length 1.5
  BOTTOM w0.254: PQ203.3 69.44,29.46 v1(68.49,28.51)
  vias: v2(68.58,29.21)
N89512778: length 5
  BOTTOM w0.102: v2(66.15,31.86) 66.81,31.86 67.17,31.5 67.17,30.84 67.25,30.76 PQ203.6
  BOTTOM w0.254: PQ203.6 PQ203.5 67.12,30.11 67.04,30.04 PR211.1 PR204.2
N89512794: length 4.4
  BOTTOM w0.102: PR212.2 70.78,29.17 71.59,28.35 72.53,28.35 v2(72.66,28.23)
  BOTTOM w0.254: PQ203.2 70.04,30.11 70.12,30.04 PC213.1 70.55,30.01 PR212.2
N89515927: length 6.6
  TOP w0.102: v2(63.03,24.05) 63.56,24.58 v1(63.75,24.58)
  IN4 w0.254: v6(66.05,27.96) 66.05,26.88 v1(63.75,24.58)
  GND3 w0.254: v7(66.05,28.43) v6(66.05,27.96)
  BOTTOM w0.254: PR200.1 66.91,28.43 v7(66.05,28.43)
N89520789:
  vias: v2(111.26,92.39)
N91124401: length 1.8
  BOTTOM w0.102: 17.17,108.15 v2(18.97,108.15)
N94674399: length 2.4
  TOP w0.102: RTCR1.1 v2(253.93,61.43)
  TOP w0.508: RTCD1.2 254.06,60.09 RTCR1.1
N96795421: length 3.4
  BOTTOM w0.254: U7.R28 268.93,32.71 U7.U26 U7.R26 268.93,32.03 v1(269.33,31.64) 268.93,31.25 U7.R24 268.93,31.21 v1(269.3,30.84)
  vias: v2(269.84,31.22)
N97573639: length 24.9
  TOP w0.508: v1(259.33,46.62) v2(259.33,47.53) 259.33,48.97 259.97,49.6
  IN1 w0.508: v1(259.33,46.62) 259.31,46.64 257.8,46.64 257.39,46.24 257.39,44.51 258.1,43.8 262.34,43.8 265.21,40.93 265.21,40.17 266.84,38.54 266.84,37.45 267.29,37 v1(267.29,33.28)
N98184072: length 21
  TOP w0.089: v2(256.5,38.69) 255.81,39.38 255.28,39.38
  TOP w0.508: CH75.1 268.53,41.52 v1(268.55,41.5)
  IN2 w0.508: v4(265.19,41.83) 264.91,42.11 262.95,42.11 262.57,41.73 261.49,41.73 260.86,42.36 257.11,42.36 256.41,41.66 256.3,41.66
  IN4 w0.508: v4(265.19,41.83) 266.23,41.83 266.96,41.11 268.17,41.11 v1(268.55,41.5)
  BOTTOM w0.254: v1(261.05,30.17) 261.41,30.54 U7.AP22 U7.AR22 U7.AT22 260.1,30.54 v1(260.1,30.17) ; U7.AK22 262.86,30.55 262.46,30.55 U7.AM22 262.33,30.35 v1(262,30.02) 262,29.94 U7.AM20 262.06,29.34 262.06,29.06 U7.AM18
  vias: v1(254.95,41.22) v1(254.95,40.58) v1(255.54,40.6) v1(255.59,41.22)
N100081938: length 2.1
  TOP w0.102: U22.13 33.06,98.9 33.77,99.61 RV429.2
N100123145: length 4.4
  TOP w0.102: v2(35.7,102.34) 35.7,102.07 35.01,101.38 34.22,101.38 33.77,100.92 RV458.2 33.76,100.9 U22.18
N100135407: length 2.7
  TOP w0.102: U22.23 30.57,103.74 v2(30.47,103.84) 29.84,104.47 RV444.2
N104640372: length 6.2
  TOP w0.102: RD8.2 172.65,36.52 v1(172.4,36.27) 172.36,36.27 171.87,36.76 v2(171.87,36.91)
  BOTTOM w0.102: JDIMM1.197 170.1,35.89 170.87,36.66 172.01,36.66 v1(172.4,36.27)
N104640401: length 3.8
  TOP w0.102: RD9.2 172.59,35.57 v1(172.53,35.63) 172.49,35.59 v2(172.02,35.59)
  BOTTOM w0.102: v1(172.53,35.63) 172.46,35.69 171.51,35.69 171.3,35.48 JDIMM1.201
N104706821: length 4.5
  TOP w0.102: v2(244.3,31.08) 244.74,31.53 RD16.2 245.38,32.27 v1(245.51,32.39)
  BOTTOM w0.102: JDIMM2.197 244.6,33.3 v1(245.51,32.39)
N104706826: length 3.5
  TOP w0.102: v1(245.87,35.76) 246.01,35.62 RD15.2 246.01,34.16 v2(245.74,33.89)
  BOTTOM w0.102: JDIMM2.201 245.8,35.69 v1(245.87,35.76)
N107416912: length 8.5
  BOTTOM w0.089: UV1.E1 226.7,77.85 227.23,77.32
  BOTTOM w0.102: v2(232.93,74.86) 232.83,74.76 RV501.2 RV8.2 230.57,75.7 229.17,77.1 227.45,77.1 227.23,77.32
N108767585: length 0.8
  TOP w0.102: v2(80.87,20.11) 80.71,19.95 v1(80.14,19.95)
  vias: v1(80.14,19.34)
N108866597: length 4.3
  TOP w0.102: PU202.3 111.79,16.38 v2(111.17,16.99)
  TOP w0.254: PC252.1 PR282.2 113.3,16.19 113.11,16.38 PU202.3
N108866653: length 2.1
  TOP w0.254: PT200.1 114.29,20.89 PC250.1 PR281.2
N108873638: length 2.9
  TOP w0.203: PU300.20 50.75,33.17 51.2,33.62 v2(51.61,33.62) 52.58,33.62 PR341.1
N109409461: length 4.3
  BOTTOM w0.102: v2(31.71,32.06) 32.7,31.07 RN17.1
  BOTTOM w0.254: RN17.1 33.01,31.43 34.28,32.7 UN1.10
N109777135: length 5.4
  TOP w0.102: QV39.2 200.81,66.69 200.57,66.93 RV289.1 199.66,69.53 v2(199.43,69.77)
N109801948: length 5.6
  TOP w0.102: QZ19.1 212.28,55.44 211.96,55.76 v2(211.96,57.27) 211.96,58.29 RZ12.2 212.48,58.81 QZ5.2
N109970739: length 3.1
  TOP w0.203: PR350.1 52.19,33.13 51.14,33.13 50.78,32.77 PU300.19
N110156589: length 5.1
  TOP w0.102: v1(143.51,19.25) 143.51,19.75 143.82,20.05 UE36.13
  BOTTOM w0.102: RE74.1 143.77,20.07 143.51,19.81 v1(143.51,19.25) 144.93,19.25 v2(145.35,18.83)
N110678802: length 2.7
  BOTTOM w0.102: PC706.1 120.01,111.09 v2(120.38,110.73)
  BOTTOM w0.508: PC706.1 120.01,113.1 PR713.2
N110678827: length 2.8
  BOTTOM w0.102: PC727.1 123.47,109.8 v2(123.33,109.94)
  BOTTOM w0.508: PC727.1 PR740.2
N110682945: length 2
  BOTTOM w0.102: v2(131.84,115.58) 131.76,115.65 PR739.1
  BOTTOM w0.254: PC722.2 130.74,115.65 PR739.1
N110700740: length 1.8
  BOTTOM w0.102: PR824.2 v2(135.58,123.95)
  BOTTOM w0.254: PR824.2 136.54,123.96 PC821.1
N110703687: length 3.5
  TOP w0.102: v2(161.07,124.25) 161.22,124.1 PC809.1
  TOP w0.508: PR806.2 161.2,122.22 PC809.1
N110725812: length 2
  TOP w0.102: PC726.1 127.68,121.66 v2(127.8,121.78)
  TOP w0.254: PC726.1 PR736.2
N110740517: length 1.3
  TOP w0.102: PC224.1 v2(77,15.68)
N110805086: length 1.2
  BOTTOM w0.102: v2(58.25,33.13) 58.65,33.53 PQ230.2
N110807082: length 3.6
  BOTTOM w0.102: v2(40.57,37.52) PR294.1
  BOTTOM w0.254: PC261.2 41.62,38.1 PR294.1 42.38,36.76 PQ231.5
N110807094: length 3
  BOTTOM w0.254: PQ231.6 43.36,37.41 43.53,37.59 PC261.1 44.23,38.62 PR292.2
N110807104: length 3.2
  BOTTOM w0.102: v2(47.66,36.63) PR291.2
  BOTTOM w0.254: PQ231.2 45.68,36.76 PR293.1 PR291.2
N110833422: length 1.1
  TOP w0.102: v9(162.56,118.32) 163.29,118.32 v2(163.52,118.55)
  vias: v9(162.56,117.69)
N110836828: length 3.6
  TOP w0.102: v2(178.57,121.74) PC838.1
  TOP w0.508: PR830.2 176.82,121.62 PC838.1
N110836908: length 1.3
  TOP w0.102: v2(176.85,120.16) 176.58,119.9 v1(175.64,119.9)
  vias: v1(175,119.92)
N110922537: length 2.8
  TOP w0.102: v2(236.4,65.86) PC504.1
  TOP w0.508: PR501.2 234.44,65.35 PC504.1
N110935137: length 2
  BOTTOM w0.102: PC718.1 128.97,118.95 v2(129.42,118.5)
  BOTTOM w0.254: PC718.1 128.97,119.39 PR732.2
N110935195: length 2.2
  BOTTOM w0.102: v2(130.11,123.15) 129.92,122.96 PR738.2
  BOTTOM w0.254: PR738.2 PC725.1
N110935541: length 2.8
  BOTTOM w0.102: PC800.1 146.29,116.8 v2(146.54,117.05)
  BOTTOM w0.508: PC800.1 PR801.2
N110936515: length 1.6
  BOTTOM w0.102: PC813.1 145.82,127.53 v2(146.57,128.28)
N110936719: length 2
  BOTTOM w0.102: v2(137.25,127.8) 137.38,127.67 PR827.2
  BOTTOM w0.254: PR827.2 PC824.1
N110936976: length 2.8
  TOP w0.102: v2(179.82,128.15) 180.26,127.71 PR832.2
  TOP w0.508: PR832.2 PC839.1
N111031508: length 3.1
  TOP w0.102: v2(112.38,19.86) 112.51,19.73 PR280.2
  TOP w0.254: PR280.2 112.01,18.31 112.01,17.79 112.12,17.68 PU202.1
N111036757: length 2.7
  BOTTOM w0.254: PU800.13 141.03,125.08 v2(140.43,125.67) 139.86,126.25 PR852.2
N111036762: length 2.6
  BOTTOM w0.254: PU800.14 141.53,125.37 140.75,126.14 PR851.2
N111036767: length 2.4
  BOTTOM w0.254: PR850.2 141.64,126.18 142.03,125.8 v2(142.03,125.71) PU800.15
N111046328: length 42.2
  TOP w0.254: v1(127.52,108.64) 127.67,108.64 128.32,108 128.32,107.49 128.66,107.15 v2(128.66,106.4) 128.66,104.58 128.28,104.2 128.28,82.15 124.34,78.21 121.7,78.21 v1(121.14,78.77)
  BOTTOM w0.254: v1(127.52,108.64) 127.13,109.04 PR749.1 ; PH701.2 124.98,79.51 123.79,79.51 123.25,78.98 121.35,78.98 v1(121.14,78.77)
N111069434: length 4.5
  TOP w0.102: v1(192.92,124.87) 193.23,125.18 PR600.2 193.65,125.63 PR602.2 193.22,126.41 193.39,126.59 193.39,127.3 v2(193.2,127.49)
  BOTTOM w0.203: v1(192.92,124.87) 192.67,124.87 192.44,125.1 PU600.25
N111120800: length 2.8
  TOP w0.102: v1(190.18,127.31) 190.18,127.69 v2(190.4,127.91)
  TOP w0.254: PC602.2 190.28,127.21 v1(190.18,127.31)
  BOTTOM w0.203: PU600.21 190.47,127.02 v1(190.18,127.31)
N111178724:
  vias: v1(28.82,88.18) v1(29.4,88.18) v1(30.01,88.18) v1(30.65,88.18) v1(31.26,88.18) v1(31.89,88.18) v2(29.6,91.57) v3(28.54,90.05) v3(28.54,89.34) v3(28.54,88.68) v3(28.94,89.34) v3(28.94,88.68) v3(28.99,90.05) v3(29.42,90.05) v3(29.42,89.34) v3(29.48,88.7) v3(29.98,90.05) v3(29.98,89.34) v3(29.98,88.7) v3(30.49,90.05) v3(30.54,89.31) v3(30.54,88.7) v3(30.64,90.67) v3(31.1,89.31) v3(31.1,88.7) v3(31.61,89.31) v3(31.58,88.68) v3(31.89,88.97) v4(28.74,89.01) v4(28.76,90.38) v4(28.77,89.7) v4(29.22,90.36) v4(29.25,89.7) v4(29.22,89.01) v4(29.73,90.36) v4(29.73,89.01) v4(29.75,89.7) v4(30.24,90.36) v4(30.26,89.7) v4(30.26,89.01) v4(30.77,89.7) v4(30.82,89.01) v4(31.35,89.72) v4(31.35,89.01) v7(32.13,89.48) v7(32.13,89.1) v7(32.13,88.72) v7(32.57,90.58) v7(32.57,90.2) v7(32.57,89.85) v7(32.57,89.47) v7(32.57,89.09) v7(32.57,88.7) v7(32.95,90.58) v7(32.95,90.2) v7(32.95,89.85) v7(32.95,89.47) v7(32.95,89.09) v7(32.95,88.7) v7(33.34,90.58) v7(33.34,90.2) v7(33.34,89.85) v7(33.34,89.47) v7(33.34,89.09) v7(33.34,88.7)
N111701081: length 4.9
  BOTTOM w0.102: QZ24.4 172.53,22.95 172.77,23.19 174.32,23.19 RE84.1 175.6,23.48 175.91,23.48 v2(176.19,23.76)
N111798152: length 3.1
  TOP w0.102: v1(36.57,46.24) 36.82,45.99 v2(36.82,45.78) 36.82,45.43 36.55,45.16 CZ15.1
  BOTTOM w0.102: UZ4.12 36.66,45.43 36.71,45.49 36.71,46.1 v1(36.57,46.24)
N111798158: length 3.2
  TOP w0.102: CZ38.1 35.31,45.63 v2(35.49,45.81) v1(35.9,46.22)
  BOTTOM w0.102: UZ4.10 35.86,45.4 35.75,45.51 35.75,46.07 v1(35.9,46.22)
N112063266: length 1.9
  TOP w0.102: v1(24.38,75.93) 24.59,76.14 C2020.1
  BOTTOM w0.102: U11.2 24.51,76.06 v1(24.38,75.93)
N112063456: length 3.1
  TOP w0.102: R2515.2 26.2,78.69 v1(26.26,78.75)
  BOTTOM w0.102: v1(26.26,78.75) 26.07,78.56 U11.7 v2(23.9,78.56)
N112071134: length 2.5
  TOP w0.102: RI320.1 28.76,56.55 27.94,57.37 UI5.30
N112104092: length 2.5
  TOP w0.102: RA75.1 17.92,20.77 v2(17.92,21.29) 18.17,21.55 U12.41
N112104127: length 1.3
  TOP w0.102: RA76.2 18.53,33.54 CA91.1
N112104904: length 1
  TOP w0.102: CA94.1 28.21,25.79 RA89.2
N112208327: length 2.3
  BOTTOM w0.102: DV9.1 16.81,98.72 v2(17.97,99.88)
N112581938: length 11
  TOP w0.102: v2(6.62,31.28) 6.62,31.5 v1(5.95,32.16)
  TOP w0.508: v1(5.95,32.16) 6.36,32.57 RA4.1
  IN4 w0.508: JHP2.5 11.1,35.92 8.65,35.92 5.95,33.23 v1(5.95,32.16)
N112582115: length 0.9
  TOP w0.254: RA18.2 16.04,44.69 LA5.1
N112582117: length 0.9
  TOP w0.254: RA17.2 LA6.1
N112583802: length 5.4
  TOP w0.203: v1(21.11,37.63) 21.51,38.03 22.9,38.03 23.15,38.29 U15.38
  BOTTOM w0.254: v1(21.11,37.63) 20.84,37.63 v2(20.56,37.9) 20.08,38.38 CA26.1
N112583814: length 2.8
  TOP w0.203: U15.36 21.46,39.59 21.18,39.32 v2(20.83,39.32) 20.21,39.32 20.14,39.4 CA14.1
N112583837: length 3.1
  TOP w0.102: v2(25.33,46.42) 24.74,45.83 v1(24.74,45.73)
  TOP w0.203: U15.20 24.35,45.35 v1(24.74,45.73)
  BOTTOM w0.102: v1(24.74,45.73) 25.32,46.32 CA20.2
