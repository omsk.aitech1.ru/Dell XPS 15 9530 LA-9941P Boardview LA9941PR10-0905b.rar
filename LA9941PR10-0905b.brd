# Allegro board LA9941PR10-0905b.brd (continued)
## Nets (continued)
+1.35V_CPU_VDDQ: CU168.1 CU169.1 CU170.1 CU171.1 CU172.1 CU173.1 CU174.1 CU175.1 CU176.1 CU177.2 CU178.2 CU192.1 CU193.1 CU194.1 CU195.1 CU196.1 CU197.1 CU198.1 CU199.1 CU200.1 CU201.1 JP3.2 JP4.2 RU60.1 RU83.1 U6.AR29 U6.AR31 U6.AR33 U6.AT13 U6.AT19 U6.AT23 U6.AT27 U6.AT32 U6.AT36 U6.AV37 U6.AW22 U6.AW25 U6.AW29 U6.AW33 U6.AY18 U6.BB21 U6.BB22 U6.BB26 U6.BB27 U6.BB30 U6.BB31 U6.BB34 U6.BB36 U6.BD22 U6.BD26 U6.BD30 U6.BD33 U6.BE18 U6.BE22 U6.BE26 U6.BE30 U6.BE33
+1.35V_MEN_P: PC408.1 PC412.2 PJP401.1 PJP403.1 PJP404.1 PL400.1 PR405.2 PU400.5
+1.35V_PWROK: PU400.10 RU53.1
+2.5V_5505LDO_S: CA67.1 CA77.1 CA79.1 RA62.2 U12.43
+3.3V_RUN_VDD33: CV617.1 CV619.1 CV621.1 CV622.1 CV623.1 RV337.1 UV1.J8 UV1.K8 UV1.L8 UV1.M8
+3V_MSATA: CM11.1 CM12.1 CM13.1 CM14.1 JP12.1 JSSD.2 JSSD.24 JSSD.39 JSSD.41 JSSD.52
+3V_NFC: C1135.1 JNFC1.2 JNFC1.3 JNFC1.15 RN5.2 RN8.1
+3V_PCH: CH11.1 CH61.1 CH64.1 CH93.1 JP6.2 JP14.1 JP17.1 RH18.1 RH19.1 RH20.1 RH23.1 RH32.1 RH33.1 RH38.1 RH40.1 RH53.2 RH63.2 RH64.2 RH65.2 RH84.2 RH158.1 RH448.2 RH456.2 RH724.2 RH725.2 RN5.1 RPH4.1 RPH4.3 RPH7.1 RPH7.2 RPH7.4 RPH14.7 RPH14.8 RPH24.1 RPH24.2 RPH24.3 RPH24.4 RPH25.3 RPH25.4 RPH29.5 RPH29.6 RPH29.7 RPH29.8 RPH30.5 RPH30.6 RPH30.7 RPH30.8 U7.A26 U7.AJ30 U7.AJ32 U7.R20 U7.R22 UH2.8
+3V_PCH_APL: CZ45.1 JP14.2 UZ14.1
+3V_PS8723: CI27.1 CI50.1 RI74.2 RI460.2 RI461.2 RI462.2 RI463.2 RI464.2 RI465.2 RI466.2 RI467.2 RI468.2 UI5.9 UI5.25
+3V_THERMAL: CT22.2 RT1.2 RT2.2 RT3.2 RT4.2 RT5.2 RT6.2 U4.5
+3V_VCCPSPI: CH54.1 JP17.2 U7.AD12
+3VALW: C17.1 CH55.1 CH71.1 CZ28.1 CZ32.1 JTB1.52 JTB1.54 JTB1.56 JTB1.58 PJP302.2 PR102.1 PR110.1 PR282.1 PR292.1 R28.1 R29.1 RE33.2 RE52.1 RE60.1 RE61.2 RE64.1 RH121.1 RH173.1 RI17.1 RI32.1 RI74.1 RPH4.2 RPH4.4 RPH7.3 RU76.1 RU118.2 RZ3.1 RZ12.1 U5.2 U7.A16 U7.K8 UU3.5 UZ4.6 UZ4.7 UZ14.4 UZ14.5
+3VALW_EC: CE4.1 CE5.1 CE6.1 CE7.1 CE8.1 CE9.1 CE15.1 CE22.1 LE1.1 PR114.2 RE9.1 RE11.1 RE20.1 RE28.1 RE29.1 RE55.1 RE56.2 RE60.2 RE66.1 RE69.1 RE71.1 RE72.1 RE74.2 RE76.1 RPE2.3 RPE2.4 RPH19.3 RPH19.4 UE1.J4 UE1.J7 UE1.K7 UE1.K12 UE1.M12 UE36.24
+3VALWP: PC301.1 PC312.1 PJP302.1 PL301.1 PR300.1
+3VLP: PR335.1 RE32.2 RE47.1 RE48.1 RE49.1 RE50.1 RE56.1 RE59.1 RTCD1.3 UE1.J6
+3VS: C1.1 C2.1 C3.1 C4.1 C5.1 C6.1 CA7.1 CA8.2 CA9.1 CA12.1 CA13.1 CA29.2 CA85.1 CA86.1 CA87.1 CA88.1 CA89.1 CA90.2 CA92.1 CD21.1 CD22.1 CD43.1 CD44.1 CE19.1 CH33.1 CH73.1 CH98.1 CH100.1 CM30.1 CM31.1 CM32.1 CN1.1 CN2.1 CN3.1 CN14.1 CN15.1 CV26.1 CV743.1 CV745.1 CV771.1 CZ20.1 CZ600.1 DV9.2 JDIMM1.199 JDIMM2.199 JHDD.8 JHDD.9 JHDD.10 JP12.2 JP13.1 JP803.1 JTB1.85 JTB1.87 JTB1.89 JTP.6 JTS.1 LA1.1 PR711.1 QH2.2 QH2.5 QH3.2 QH3.5 QZ1.1 QZ1.2 QZ1.5 QZ1.6 R1.2 R8.1 R54.2 R72.1 RA4.2 RA42.2 RA44.1 RA54.1 RA91.1 RD15.1 RE34.2 RE51.1 RH12.2 RH14.2 RH17.1 RH29.2 RH75.1 RH98.2 RH136.1 RH159.2 RH163.1 RH164.1 RH167.1 RH168.1 RH171.1 RH174.1 RH175.2 RH176.1 RH177.1 RH178.1 RH180.1 RH213.1 RH247.2 RN26.1 RN33.1 RPE2.1 RPE2.2 RPH1.5 RPH1.6 RPH1.7 RPH1.8 RPH2.5 RPH2.6 RPH2.7 RPH2.8 RPH8.1 RPH8.2 RPH8.3 RPH8.4 RPH9.3 RPH9.4 RPH14.5 RPH14.6 RPH16.5 RPH16.6 RPH16.7 RPH16.8 RPH19.1 RPH19.2 RPH25.1 RPH25.2 RU35.2 RU36.1 RU42.1 RV5.1 RV429.1 RV431.1 RV444.1 RV448.1 RV450.1 RV452.1 RV460.1 RV491.2 RZ484.2 RZ602.1 U1.5 U1.10 U1.19 U1.24 U7.AE14 U7.AF12 U7.AG14 U7.AK30 U7.AK32 U7.L24 U7.R30 U7.R32 U12.9 U12.14 U12.16 U12.42 U15.7 U15.11 U15.23 U22.11 U22.37 UA2.B2 UE2.5 UH3.5 UH5.5 UN2.1 UN2.7 UN2.8 UN2.14 UU2.5 UV12.4 UV12.5 UZ600.2
+3VS_DELAY: CV614.1 CV615.1 CV616.1 CV3509.1 PR803.1 QV21.2 QV21.5 QV40.2 QV42.2 QV42.5 QZ1.4 RPH15.5 RPH15.6 RPH15.7 RPH15.8 RPH32.5 RPH32.6 RPH33.6 RPH33.7 RPH33.8 RV301.2 RV302.2 RV303.2 RV304.2 RV305.2 RV306.2 RV307.2 RV308.2 RV319.2 RV320.1 RV325.1 RV326.1 RV331.2 RV337.2 RV506.1 RZ6.1 U23.3 U23.7 U23.8 UH4.5 UV1.AG12 UV1.AH12
+3VS_DP: CV769.1 CV770.1 CV787.1 CV788.1 DPF1.2 JMDP.20
+3VS_MDPR: C37.1 C38.1 C43.1 C48.1 R8.2 R2530.2 R2532.2 R2534.2 R2536.2 U11.1 U11.6 U11.12 U11.25 U11.32 U11.36
+3VS_RD: CN28.1 CN29.1 JP13.2 RN3.2 RN4.2 RN10.1 RN11.1 RN12.1 RN16.2 RN17.2 RN18.2 RN19.2
+3VS_TPS: JP803.2 UZ4.8 UZ4.9
+5V_CHGUSB_1: CI1.1 CI2.1 CI19.1 JUSB1.1 US1.12
+5V_CHGUSB_3: CI9.1 CI15.1 CI23.1 JUSB3.1 US2.12
+5V_HDMI_DDC: DV11.1 RV445.1 RV447.1
+5VALW: CI24.1 CI26.1 CN34.1 CZ29.1 JTB1.74 JTB1.76 JTB1.78 JTB1.80 JTB1.82 JTB1.84 JTB1.86 JTB1.88 JTB1.90 LED3.1 LED6.2 LED7.2 LED8.2 LED9.2 PC407.2 PC604.2 PD100.3 PJP301.2 PJP303.2 PR105.2 PR402.1 PR510.2 PU400.12 PU600.18 R11.1 R12.1 R17.1 R18.1 R20.1 R21.1 R25.1 R26.1 R27.1 R32.1 R33.1 R34.1 R66.2 R67.2 RE62.1 RE63.1 RE65.1 RE68.1 RI19.1 RI30.1 UN3.4 UN3.5 US1.1 US2.1 UZ4.1 UZ4.2 UZ4.4
+5VALWP: PC302.2 PC313.1 PJP301.1 PJP303.1 PL300.2 PR301.2 PU300.14
+5VS: C11.1 CA3.1 CA4.1 CE57.1 CM33.1 CT44.1 CZ11.1 DV8.2 DV11.2 F1.2 JFAN1.2 JP802.1 JTB1.64 JTB1.66 PR712.1 PR730.2 PR821.2 PR853.1 PU801.8 QZ24.3 RA33.2 RE53.1 RN23.1 RZ38.1 U4.1 U4.3
+5VS_HDD: CN4.1 CN5.1 CN6.1 CN7.1 JHDD.14 JHDD.15 JHDD.16 JP15.1
+5VS_HDDAPL: JP15.2 UN3.1
+5VS_KBL: C12.1 F1.1 JKBL.4
+5VS_TPS: JP802.2 UZ4.13 UZ4.14
+V1.05S_VCCP_PWRGOOD: PU500.1 RE27.1 RU50.1
+V1.05V_B+: PC500.1 PC501.1 PC502.1 PC503.1 PC511.1 PJP500.2 PQ500.5
+V18R: CE17.1 UE1.L1
+VCC_CORE: PC900.1 PC901.1 PC902.1 PC903.1 PC904.1 PC905.1 PC906.1 PC907.1 PC908.1 PC909.1 PC921.1 PC922.1 PC923.1 PC924.1 PC926.1 PC927.1 PC928.1 PC929.1 PC930.1 PC931.1 PC932.1 PC933.1 PC934.1 PC935.1 PC953.1 PC954.1 PC955.1 PC956.1 PC965.1 PC966.1 PC967.1 PC968.1 PC969.1 PC970.1 PC971.1 PC972.1 PC973.1 PC974.1 PC975.1 PC976.1 PC977.1 PC978.1 PC979.1 PC980.1 PC981.1 PC982.1 PC983.1 PC984.1 PC991.1 PC992.1 PC993.1 PC994.1 PC995.1 PC996.1 PC997.1 PC998.1 PL701.4 PL702.4 RU96.1 U6.A27 U6.A28 U6.A31 U6.A32 U6.A34 U6.A36 U6.A38 U6.A39 U6.A42 U6.A43 U6.A45 U6.A46 U6.A48 U6.AA8 U6.AA9 U6.AA46 U6.AA47 U6.AB8 U6.AB45 U6.AB46 U6.AC8 U6.AC9 U6.AC46 U6.AC47 U6.AD8 U6.AD46 U6.AE8 U6.AE46 U6.AE47 U6.AF8 U6.AG8 U6.AG46 U6.AH8 U6.AH46 U6.AH47 U6.AJ45 U6.AJ46 U6.AK8 U6.AK46 U6.AK47 U6.AL8 U6.AL9 U6.AL45 U6.AL46 U6.AM8 U6.AM9 U6.AM46 U6.AM47 U6.AN8 U6.AN9 U6.AN10 U6.AN12 U6.AN13 U6.AN14 U6.AN15 U6.AN16 U6.AN17 U6.AN19 U6.AN20 U6.AN21 U6.AN23 U6.AN24 U6.AN25 U6.AN26 U6.AN27 U6.AN29 U6.AN30 U6.AN32 U6.AN34 U6.AN36 U6.AN38 U6.AN39 U6.AN40 U6.AN41 U6.AN42 U6.AN43 U6.AN44 U6.AN45 U6.AN46 U6.AP8 U6.AP9 U6.AP10 U6.AP12 U6.AP13 U6.AP14 U6.AP15 U6.AP16 U6.AP17 U6.AP18 U6.AP19 U6.AP20 U6.AP21 U6.AP22 U6.AP23 U6.AP24 U6.AP25 U6.AP26 U6.AP27 U6.AP29 U6.AP30 U6.AP31 U6.AP32 U6.AP33 U6.AP34 U6.AP35 U6.AP36 U6.AP37 U6.AP38 U6.AP39 U6.AP40 U6.AP41 U6.AP42 U6.AP43 U6.AP44 U6.AP46 U6.AP47 U6.AR35 U6.AR37 U6.AR39 U6.AR41 U6.AR43 U6.AR45 U6.AR46 U6.B27 U6.B28 U6.B31 U6.B32 U6.B34 U6.B36 U6.B38 U6.B39 U6.B42 U6.B43 U6.B45 U6.B46 U6.B48 U6.C27 U6.C28 U6.C31 U6.C32 U6.C34 U6.C36 U6.C38 U6.C39 U6.C42 U6.C43 U6.C45 U6.C46 U6.C48 U6.D27 U6.D28 U6.D31 U6.D32 U6.D34 U6.D36 U6.D38 U6.D39 U6.D42 U6.D43 U6.D45 U6.D46 U6.D48 U6.E27 U6.E28 U6.E31 U6.E32 U6.E34 U6.E36 U6.E38 U6.E39 U6.E42 U6.E43 U6.E45 U6.E46 U6.E48 U6.F22 U6.F27 U6.F28 U6.F31 U6.F32 U6.F34 U6.F36 U6.F38 U6.F39 U6.F42 U6.F43 U6.F45 U6.F46 U6.F48 U6.G27 U6.G29 U6.G31 U6.G32 U6.G34 U6.G36 U6.G38 U6.G39 U6.G42 U6.G43 U6.G45 U6.G46 U6.G48 U6.H8 U6.H9 U6.H11 U6.H12 U6.H13 U6.H14 U6.H16 U6.H17 U6.H18 U6.H19 U6.H20 U6.H21 U6.H23 U6.H24 U6.H25 U6.H26 U6.H27 U6.H29 U6.H30 U6.H31 U6.H32 U6.H33 U6.H34 U6.H36 U6.H37 U6.H38 U6.H39 U6.H40 U6.H42 U6.H43 U6.H45 U6.H46 U6.H48 U6.J8 U6.J9 U6.J10 U6.J14 U6.J19 U6.J24 U6.J29 U6.J33 U6.J36 U6.J37 U6.J38 U6.J39 U6.J40 U6.J42 U6.J43 U6.J45 U6.J46 U6.J48 U6.K8 U6.K9 U6.K38 U6.K40 U6.K43 U6.K44 U6.K45 U6.K46 U6.K48 U6.L6 U6.L8 U6.L37 U6.L38 U6.L39 U6.L40 U6.L42 U6.L43 U6.L44 U6.L46 U6.L47 U6.M6 U6.M8 U6.M9 U6.M37 U6.M38 U6.M39 U6.M40 U6.M42 U6.M43 U6.M44 U6.M45 U6.M46 U6.N8 U6.N9 U6.N37 U6.N38 U6.N39 U6.N40 U6.N42 U6.N43 U6.N44 U6.N46 U6.N47 U6.P8 U6.P45 U6.P46 U6.R8 U6.R9 U6.R46 U6.R47 U6.T45 U6.T46 U6.U8 U6.U9 U6.U46 U6.U47 U6.V8 U6.V45 U6.V46 U6.W8 U6.W46 U6.W47 U6.Y8 U6.Y45 U6.Y46
+VCC_PWR_SRC1: PC701.1 PC702.1 PC703.1 PC704.1 PC705.1 PC762.1 PJP700.2 PL705.1 PQ700.1 PR725.2
+VCC_PWR_SRC2: PC700.1 PC715.1 PC716.1 PC717.1 PC719.1 PC721.1 PC761.1 PJP701.2 PL700.1 PQ703.1
+VCCAFDI_VRM: CH60.1 CH66.1 CH67.1 CH68.1 CH81.1 R56.1 U7.AF34 U7.AK26 U7.AK28 U7.AN11 U7.BB44 U7.BE22
+VCCIO2PCH: R53.2 R58.2
+VCCIO_OUT: CU36.2 JXDP.43 JXDP.44 PR700.1 PR701.1 PR702.1 RU30.1 RU40.1 RU90.1 RU91.1 RV470.1 U6.D51
+VCCIOA_OUT: RU1.2 RU2.2 U6.AK6
+VCCP: CH46.1 CH82.1 CH84.1 JP2.2 JP5.1 JP7.2 JP18.1 JP19.2 LH100.1 PJP501.2 PJP502.2 PR726.1 R55.2 R58.1 RH201.2 RH202.1 RH219.1 RH220.2 RU13.2 RU45.1 RU66.2 RU94.1 U7.AK18 U7.AK20 U7.AN34 U7.AN35 U7.U35 U7.U36 UZ1.5 UZ1.6 UZ1.7 UZ1.8
+VCCRTCEXT: CH79.1 U7.P14 U7.P16
+VCCSST: CH85.1 U7.AA14
+VDDA: CA10.1 CA11.2 RA33.1 U15.39
AGND: CA5.2 CA6.2 CA10.2 CA11.1 CA12.2 CA13.2 CA14.2 CA16.1 CA18.2 CA19.2 CA20.1 CA22.2 CA26.2 CA28.1 CA29.1 CA31.1 CA33.2 CA34.2 CA37.2 CA38.2 CA71.2 JHP2.7 JP8.1 JP9.1 JP10.1 QA3.1 QA3.4 QA4.1 QA4.4 QA5.3 RA2.2 RA3.2 RA7.1 RA46.1 RA49.2 RA51.1 RA52.2 RA70.2 U15.22 U15.28 U15.42 UA2.A2 UA5.8
GND: BAT100.8 BAT100.9 BAT100.10 BAT100.11 BAT100.12 C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C8.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C37.2 C38.2 C43.2 C48.2 C1135.2 C2020.2 C2021.2 CA3.2 CA4.2 CA7.2 CA8.1 CA9.2 CA21.1 CA23.2 CA27.2 CA32.2 CA39.1 CA41.2 CA42.2 CA43.2 CA45.2 CA46.2 CA54.2 CA55.2 CA56.2 CA57.2 CA63.2 CA64.1 CA65.2 CA67.2 CA75.2 CA76.2 CA78.1 CA79.2 CA80.2 CA83.2 CA84.1 CA86.2 CA89.2 CA90.1 CA91.2 CA93.2 CA94.2 CA95.2 CA96.2 CA97.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CE4.2 CE5.2 CE6.2 CE7.2 CE8.2 CE9.2 CE11.2 CE12.2 CE14.1 CE15.2 CE16.2 CE17.2 CE18.2 CE19.2 CE20.1 CE21.2 CE22.2 CE23.2 CE26.2 CE27.2 CE28.2 CE29.2 CE30.2 CE31.2 CE32.2 CE33.2 CE34.2 CE35.2 CE36.2 CE37.2 CE38.2 CE39.2 CE40.2 CE41.2 CE42.2 CE43.2 CE44.2 CE45.2 CE46.2 CE47.2 CE48.2 CE49.2 CE50.2 CE51.2 CE52.2 CE53.2 CE57.2 CE58.2 CE322.2 CH1.1 CH2.1 CH3.2 CH4.2 CH5.2 CH6.1 CH11.2 CH12.2 CH13.2 CH14.1 CH24.2 CH26.1 CH27.2 CH28.2 CH30.2 CH33.2 CH35.2 CH36.2 CH37.2 CH38.2 CH46.2 CH54.2 CH55.2 CH56.2 CH60.2 CH61.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH69.2 CH70.2 CH71.2 CH72.2 CH73.2 CH75.2 CH76.2 CH77.2 CH78.2 CH79.2 CH81.2 CH82.2 CH84.2 CH85.2 CH86.2 CH87.2 CH88.2 CH89.2 CH90.2 CH91.2 CH92.2 CH93.2 CH94.2 CH95.2 CH98.2 CH99.2 CH100.2 CH101.2 CH102.2 CH103.2 CH104.2 CH105.2 CH106.2 CH107.2 CH108.2 CH109.2 CH110.2 CH111.2 CI1.2 CI2.2 CI9.2 CI15.2 CI19.2 CI23.2 CI24.2 CI26.2 CI27.2 CI50.2 CLRP1.2 CLRP2.1 CM11.2 CM12.2 CM13.2 CM14.2 CM22.2 CM30.2 CM31.2 CM32.2 CM33.2 CN1.2 CN2.2 CN3.2 CN4.2 CN5.2 CN6.2 CN7.2 CN14.2 CN15.2 CN28.2 CN29.2 CN34.2 CT21.2 CT22.1 CT44.2 CU36.1 CU39.2 CU168.2 CU169.2 CU170.2 CU171.2 CU172.2 CU173.2 CU174.2 CU175.2 CU176.2 CU192.2 CU193.2 CU194.2 CU195.2 CU196.2 CU197.2 CU198.2 CU199.2 CU200.2 CU201.2 CV26.2 CV32.1 CV568.2 CV569.2 CV570.2 CV571.2 CV572.2 CV573.2 CV574.2 CV575.2 CV576.2 CV580.2 CV581.2 CV582.2 CV583.2 CV584.2 CV585.2 CV586.2 CV587.2 CV588.2 CV589.2 CV590.2 CV591.2 CV592.2 CV593.2 CV594.2 CV595.2 CV596.2 CV597.2 CV598.2 CV599.2 CV600.2 CV601.2 CV602.2 CV603.2 CV604.2 CV605.2 CV606.2 CV607.2 CV608.2 CV609.2 CV610.2 CV611.2 CV612.2 CV613.2 CV614.2 CV615.2 CV616.2 CV617.2 CV619.2 CV621.2 CV622.2 CV623.2 CV636.2 CV637.2 CV638.2 CV639.1 CV643.2 CV650.2 CV651.2 CV652.2 CV653.2 CV654.2 CV655.2 CV656.2 CV657.2 CV658.2 CV659.2 CV660.2 CV661.2 CV662.2 CV663.2 CV668.2 CV675.2 CV676.2 CV677.2 CV678.2 CV679.2 CV680.2 CV681.2 CV682.2 CV683.2 CV684.2 CV685.2 CV686.2 CV687.2 CV688.2 CV693.2 CV700.2 CV701.2 CV702.2 CV703.2 CV704.2 CV705.2 CV706.2 CV707.2 CV708.2 CV709.2 CV710.2 CV711.2 CV712.2 CV713.2 CV718.2 CV725.2 CV726.2 CV727.2 CV728.2 CV729.2 CV730.2 CV731.2 CV732.2 CV733.2 CV734.2 CV735.2 CV736.2 CV737.2 CV738.2 CV743.2 CV744.2 CV745.2 CV752.2 CV753.2 CV754.2 CV756.2 CV766.2 CV767.2 CV768.1 CV769.2 CV770.2 CV771.2 CV772.2 CV773.2 CV774.2 CV775.2 CV776.2 CV777.2 CV778.2 CV787.2 CV788.2 CV789.2 CV795.1 CV796.1 CV3501.2 CV3508.2 CV3509.2 CV3512.2 CV3513.2 CZ6.2 CZ7.2 CZ8.2 CZ11.2 CZ15.2 CZ20.2 CZ28.2 CZ29.2 CZ32.2 CZ38.2 CZ45.2 CZ600.2 CZ601.2 CZ602.2 D8.1 DA2.1 DA3.1 DA4.1 DA5.1 DE2.1 DE5.1 DE6.1 DI1.3 DI2.1 DI3.1 DI5.1 DI6.3 DN2.1 DV2.3 DV3.3 DV4.3 DV5.3 H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1 H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1 H15.1(TP-1) H16.1(TP-1) H17.1 H18.1(TP-1) H19.1 H20.1 H21.1 H23.1 H24.1 H25.1 H26.1 H27.1 H28.1(TP-1) H29.1(TP-1) HT1.2 HT2.2 HT3.2 HT4.2 HT5.2 HT6.2 HU101.2 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JEDP1.1 JEDP1.2 JEDP1.5 JEDP1.8 JEDP1.11 JEDP1.14 JEDP1.17 JEDP1.24 JEDP1.25 JEDP1.27 JEDP1.30 JEDP1.33 JEDP1.34 JEDP1.35 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JFAN1.4 JFAN1.5 JFAN1.6 JHDD.1 JHDD.4 JHDD.7 JHDD.11 JHDD.13 JHDD.17 JHDD.19 JHDD.21 JHDD.22 JHDD.23 JHDD.24 JHDMI.2 JHDMI.5 JHDMI.8 JHDMI.11 JHDMI.17 JHDMI.20 JHDMI.21 JHDMI.22 JHDMI.23 JKB.28 JKB.29 JKB.30 JKB.31 JKB.32 JKBL.5 JKBL.6 JMDP.1 JMDP.7 JMDP.8 JMDP.13 JMDP.14 JMDP.19 JMDP.21 JMDP.22 JMDP.23 JMDP.24 JNFC1.1 JNFC1.7 JNFC1.14 JNFC1.16 JNFC1.17 JP8.2 JP9.2 JP10.2 JSPK1.5 JSPK1.6 JSSD.4 JSSD.9 JSSD.15 JSSD.18 JSSD.21 JSSD.26 JSSD.27 JSSD.29 JSSD.34 JSSD.35 JSSD.37 JSSD.40 JSSD.43 JSSD.50 JSSD.53 JSSD.54 JTB1.5 JTB1.11 JTB1.17 JTB1.23 JTB1.29 JTB1.35 JTB1.41 JTB1.47 JTB1.53 JTB1.59 JTB1.65 JTB1.68 JTB1.70 JTB1.71 JTB1.72 JTB1.77 JTB1.83 JTP.7 JTP.9 JTP.10 JTS.6 JTS.7 JTS.8 JUSB1.4 JUSB1.7 JUSB1.11 JUSB1.12 JUSB1.13 JUSB1.14 JUSB3.4 JUSB3.7 JUSB3.11 JUSB3.12 JUSB3.13 JUSB3.14 JXDP.1 JXDP.2 JXDP.7 JXDP.8 JXDP.13 JXDP.14 JXDP.19 JXDP.20 JXDP.25 JXDP.26 JXDP.31 JXDP.32 JXDP.37 JXDP.38 JXDP.49 JXDP.50 JXDP.59 JXDP.60 LE2.2 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC109.2 PC110.2 PC111.2 PC120.2 PC121.2 PC130.2 PC202.2 PC203.2 PC204.2 PC205.2 PC206.2 PC207.2 PC209.1 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC217.2 PC218.2 PC219.1 PC220.2 PC221.2 PC222.2 PC223.2 PC224.2 PC225.1 PC227.2 PC230.2 PC231.2 PC232.2 PC233.2 PC250.2 PC252.2 PC260.2 PC270.2 PC271.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.2 PC312.2 PC313.2 PC314.2 PC315.2 PC316.2 PC317.2 PC319.2 PC320.2 PC340.2 PC400.2 PC401.2 PC402.2 PC403.2 PC405.2 PC406.2 PC407.1 PC408.2 PC409.2 PC410.2 PC411.2 PC500.2 PC501.2 PC502.2 PC503.2 PC506.2 PC507.2 PC509.2 PC511.2 PC600.2 PC601.2 PC602.1 PC603.2 PC604.1 PC605.1 PC607.1 PC610.2 PC611.1 PC612.1 PC613.1 PC620.2 PC621.2 PC700.2 PC701.2 PC702.2 PC703.2 PC704.2 PC705.2 PC707.2 PC708.1 PC709.1 PC710.2 PC711.2 PC714.2 PC715.2 PC716.2 PC717.2 PC719.2 PC721.2 PC724.2 PC725.2 PC726.2 PC728.2 PC734.1 PC737.1 PC738.2 PC761.2 PC762.2 PC801.2 PC802.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC809.2 PC810.2 PC811.2 PC812.2 PC814.2 PC815.2 PC816.2 PC817.2 PC818.2 PC819.2 PC820.2 PC822.2 PC823.2 PC825.1 PC829.2 PC830.2 PC831.2 PC832.2 PC833.2 PC834.2 PC835.2 PC836.2 PC837.2 PC838.2 PC850.2 PC851.2 PC852.2 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC910.2 PC911.2 PC912.2 PC913.2 PC914.2 PC915.2 PC916.2 PC917.2 PC918.2 PC919.2 PC921.2 PC922.2 PC923.2 PC924.2 PC926.2 PC927.2 PC928.2 PC929.2 PC930.2 PC931.2 PC932.2 PC933.2 PC934.2 PC935.2 PC936.2 PC937.2 PC938.2 PC939.2 PC940.2 PC941.2 PC942.2 PC943.2 PC944.2 PC953.2 PC954.2 PC955.2 PC956.2 PC958.2 PC959.2 PC961.2 PC962.2 PC963.2 PC964.2 PC965.2 PC966.2 PC967.2 PC968.2 PC969.2 PC970.2 PC971.2 PC972.2 PC973.2 PC974.2 PC975.2 PC976.2 PC977.2 PC978.2 PC979.2 PC980.2 PC981.2 PC982.2 PC983.2 PC984.2 PC990.2 PC991.2 PC992.2 PC993.2 PC994.2 PC995.2 PC996.2 PC997.2 PC998.2 PC999.2 PC1000.2 PC1001.2 PC1002.2 PD100.2 PD102.1 PD103.1 PD104.1 PH700.1 PL103.2 PL108.2 PQ101.3 PQ103.3 PQ202.3 PQ203.1 PQ203.4 PQ204.8 PQ207.3 PQ230.3 PQ231.1 PQ231.4 PQ302.1 PQ302.2 PQ302.3 PQ303.1 PQ303.2 PQ303.3 PQ401.1 PQ401.2 PQ401.3 PQ501.1 PQ501.2 PQ501.3 PQ700.8 PQ703.8 PQ800.8 PQ801.8 PQ802.8 PR106.2 PR118.2 PR211.2 PR216.2 PR223.2 PR225.2 PR280.1 PR293.2 PR294.2 PR302.1 PR304.2 PR305.1 PR306.2 PR350.2 PR408.2 PR502.1 PR505.2 PR508.2 PR602.1 PR704.1 PR707.1 PR709.1 PR718.1 PR727.1 PR728.1 PR812.2 PR819.1 PR827.1 PR837.1 PU200.14 PU200.21 PU202.2 PU300.21 PU400.1 PU400.3 PU400.14 PU400.21 PU500.11 PU600.10 PU600.11 PU600.12 PU600.13 PU600.14 PU600.19 PU600.23 PU600.24 PU600.29 PU700.33 PU800.25 PU801.6 PU801.9 Q11.3 Q15.1 Q15.4 Q16.1 Q16.4 Q17.1 Q17.4 Q18.1 Q18.4 Q19.1 Q19.4 Q20.1 Q20.4 QA2.3 QE1.3 QH6.3 QN2.1 QN2.4 QV22.3 QV23.3 QV24.3 QV25.3 QV30.3 QV37.3 QV38.3 QZ2.1 QZ2.4 QZ5.1 QZ5.4 QZ17.1 QZ17.4 QZ18.3 QZ19.3 QZ20.3 QZ24.1 R31.2 R47.2 R48.2 R51.2 R52.2 R59.2 R2515.1 R2531.2 R2533.2 R2535.2 RA5.1 RA59.1 RA60.2 RA75.2 RA90.2 RD8.1 RD9.1 RD16.1 RE12.2 RE36.2 RE40.2 RE42.2 RE43.1 RE44.2 RE57.1 RE58.2 RH8.1 RH16.1 RH24.2 RH25.2 RH26.2 RH27.2 RH30.2 RH31.2 RH35.2 RH62.2 RH66.2 RH67.2 RH68.2 RH69.2 RH120.1 RH122.1 RH127.1 RH130.1 RH132.1 RH138.1 RH143.2 RH154.2 RH155.2 RH165.1 RH169.1 RH170.1 RH172.2 RH188.1 RH191.1 RH193.1 RH194.1 RH243.1 RH244.1 RH245.1 RH322.2 RI6.2 RI320.2 RM12.1 RN1.1 RN6.2 RN7.2 RN9.2 RN13.1 RN14.1 RN15.1 RN20.2 RN21.2 RN30.2 RN40.2 RPH9.1 RPH9.2 RPH12.5 RPH12.6 RPH12.7 RPH12.8 RPH13.5 RPH13.6 RPH13.7 RPH13.8 RPH27.5 RPH27.6 RPH27.7 RPH27.8 RPH32.7 RPH32.8 RPH33.5 RU11.1 RU33.1 RU44.1 RU58.2 RU59.2 RU61.2 RU62.1 RU67.2 RU68.2 RU74.2 RU77.2 RU84.2 RU85.2 RU86.2 RU87.2 RU99.2 RU115.2 RV290.2 RV299.2 RV300.2 RV309.1 RV310.1 RV311.1 RV312.1 RV313.1 RV314.1 RV315.1 RV316.1 RV318.2 RV323.2 RV324.2 RV328.2 RV329.2 RV330.2 RV340.2 RV341.2 RV343.2 RV352.1 RV353.1 RV354.1 RV355.2 RV356.2 RV363.1 RV365.1 RV366.1 RV368.2 RV369.2 RV378.1 RV379.1 RV380.1 RV381.2 RV382.2 RV389.1 RV391.1 RV392.1 RV394.2 RV395.2 RV403.2 RV405.2 RV408.2 RV414.2 RV418.2 RV430.2 RV449.2 RV451.2 RV453.2 RV456.2 RV458.1 RV459.2 RV469.2 RV479.2 RV490.2 RV501.1 RZ30.2 RZ472.1 RZ485.2 RZ601.2 SW1.2 SW2.1 SW2.2 U1.1 U1.2 U1.3 U1.4 U1.8 U1.9 U1.11 U1.18 U1.25 U4.2 U5.1 U6.A8 U6.A11 U6.A15 U6.A19 U6.A22 U6.A26 U6.A30 U6.A33 U6.A37 U6.A40 U6.A44 U6.A49 U6.A50 U6.AA1 U6.AA2 U6.AA3 U6.AA4 U6.AA5 U6.AA7 U6.AA48 U6.AB5 U6.AB7 U6.AB9 U6.AB48 U6.AB50 U6.AB51 U6.AB52 U6.AB53 U6.AB54 U6.AC5 U6.AC7 U6.AC48 U6.AC50 U6.AD7 U6.AD9 U6.AD48 U6.AD50 U6.AD51 U6.AD54 U6.AE1 U6.AE2 U6.AE3 U6.AE4 U6.AE5 U6.AE7 U6.AE48 U6.AE50 U6.AF5 U6.AF6 U6.AF7 U6.AG5 U6.AG7 U6.AG9 U6.AG48 U6.AG50 U6.AG51 U6.AG52 U6.AG53 U6.AG54 U6.AH1 U6.AH2 U6.AH3 U6.AH4 U6.AH5 U6.AH7 U6.AH48 U6.AH50 U6.AJ48 U6.AJ49 U6.AJ50 U6.AJ51 U6.AJ54 U6.AK5 U6.AK7 U6.AK9 U6.AK48 U6.AK49 U6.AK50 U6.AL1 U6.AL4 U6.AL5 U6.AL7 U6.AL48 U6.AM5 U6.AM7 U6.AM50 U6.AM51 U6.AM52 U6.AM53 U6.AM54 U6.AN1 U6.AN2 U6.AN3 U6.AN4 U6.AN5 U6.AN7 U6.AN48 U6.AN49 U6.AN50 U6.AP7 U6.AP49 U6.AP50 U6.AP51 U6.AP54 U6.AR5 U6.AR7 U6.AR8 U6.AR9 U6.AR12 U6.AR14 U6.AR16 U6.AR18 U6.AR20 U6.AR22 U6.AR24 U6.AR26 U6.AR48 U6.AR50 U6.AT1 U6.AT4 U6.AT5 U6.AT6 U6.AT8 U6.AT9 U6.AT10 U6.AT12 U6.AT15 U6.AT16 U6.AT18 U6.AT20 U6.AT22 U6.AT25 U6.AT26 U6.AT29 U6.AT33 U6.AT35 U6.AT37 U6.AT39 U6.AT40 U6.AT42 U6.AT43 U6.AT45 U6.AT46 U6.AT47 U6.AT49 U6.AT50 U6.AT51 U6.AT52 U6.AT53 U6.AT54 U6.AU5 U6.AU9 U6.AU13 U6.AU18 U6.AU22 U6.AU25 U6.AU29 U6.AU30 U6.AU33 U6.AU37 U6.AU42 U6.AV1 U6.AV2 U6.AV3 U6.AV4 U6.AV5 U6.AV9 U6.AV13 U6.AV18 U6.AV22 U6.AV25 U6.AV29 U6.AV33 U6.AV42 U6.AV50 U6.AW5 U6.AW9 U6.AW13 U6.AW18 U6.AW37 U6.AW42 U6.AW43 U6.AW45 U6.AW46 U6.AW47 U6.AW49 U6.AW50 U6.AW51 U6.AW54 U6.AY9 U6.AY13 U6.AY22 U6.AY25 U6.AY29 U6.AY33 U6.AY37 U6.AY42 U6.AY50 U6.B4 U6.B8 U6.B11 U6.B15 U6.B19 U6.B22 U6.B26 U6.B30 U6.B33 U6.B37 U6.B40 U6.B44 U6.B49 U6.B51 U6.BA1 U6.BA4 U6.BA5 U6.BA9 U6.BA13 U6.BA18 U6.BA22 U6.BA25 U6.BA29 U6.BA33 U6.BA37 U6.BA42 U6.BA50 U6.BA51 U6.BA52 U6.BA53 U6.BA54 U6.BB1 U6.BB5 U6.BB6 U6.BB7 U6.BB9 U6.BB10 U6.BB11 U6.BB12 U6.BB14 U6.BB15 U6.BB16 U6.BB17 U6.BB18 U6.BB20 U6.BB23 U6.BB25 U6.BB28 U6.BB32 U6.BB33 U6.BB37 U6.BB38 U6.BB39 U6.BB41 U6.BB42 U6.BB43 U6.BB44 U6.BB46 U6.BB47 U6.BB48 U6.BB49 U6.BB54 U6.BC3 U6.BC5 U6.BC7 U6.BC10 U6.BC12 U6.BC15 U6.BC18 U6.BC21 U6.BC22 U6.BC26 U6.BC30 U6.BC33 U6.BC36 U6.BC38 U6.BC41 U6.BC43 U6.BC46 U6.BC48 U6.BC50 U6.BC52 U6.BD2 U6.BD5 U6.BD10 U6.BD15 U6.BD18 U6.BD36 U6.BD41 U6.BD46 U6.BD51 U6.BD53 U6.BE10 U6.BE15 U6.BE36 U6.BE41 U6.BE46 U6.BF5 U6.BF6 U6.BF7 U6.BF10 U6.BF12 U6.BF15 U6.BF18 U6.BF22 U6.BF26 U6.BF30 U6.BF33 U6.BF36 U6.BF38 U6.BF41 U6.BF43 U6.BF46 U6.BF48 U6.BF49 U6.BF50 U6.C4 U6.C8 U6.C11 U6.C15 U6.C19 U6.C22 U6.C26 U6.C30 U6.C33 U6.C37 U6.C40 U6.C44 U6.C49 U6.C52 U6.C53 U6.D2 U6.D8 U6.D11 U6.D15 U6.D19 U6.D22 U6.D26 U6.D30 U6.D33 U6.D37 U6.D40 U6.D44 U6.D49 U6.E8 U6.E11 U6.E15 U6.E16 U6.E17 U6.E19 U6.E20 U6.E21 U6.E22 U6.E24 U6.E25 U6.E26 U6.E30 U6.E33 U6.E37 U6.E40 U6.E44 U6.E49 U6.E51 U6.E52 U6.E53 U6.E54 U6.F2 U6.F3 U6.F4 U6.F5 U6.F26 U6.F30 U6.F33 U6.F37 U6.F40 U6.F44 U6.F49 U6.F51 U6.F52 U6.F54 U6.G1 U6.G7 U6.G8 U6.G9 U6.G11 U6.G13 U6.G16 U6.G18 U6.G19 U6.G20 U6.G23 U6.G25 U6.G26 U6.G30 U6.G33 U6.G37 U6.G40 U6.G44 U6.G49 U6.G52 U6.G54 U6.H7 U6.H44 U6.H49 U6.H51 U6.H52 U6.H53 U6.H54 U6.J7 U6.J44 U6.J49 U6.J51 U6.J54 U6.K1 U6.K2 U6.K3 U6.K4 U6.K5 U6.K6 U6.K7 U6.L7 U6.L9 U6.L48 U6.M7 U6.M48 U6.M50 U6.M52 U6.M54 U6.N7 U6.N48 U6.P1 U6.P2 U6.P3 U6.P4 U6.P5 U6.P6 U6.P7 U6.P9 U6.P48 U6.P50 U6.P52 U6.P54 U6.R7 U6.R48 U6.T48 U6.U1 U6.U2 U6.U3 U6.U4 U6.U5 U6.U6 U6.U7 U6.U48 U6.U50 U6.U52 U6.U54 U6.V7 U6.V9 U6.V48 U6.V50 U6.W7 U6.W48 U6.W50 U6.W52 U6.W54 U6.Y7 U6.Y9 U6.Y48 U7.A2 U7.A4 U7.A5 U7.A41 U7.A43 U7.A44 U7.AA4 U7.AA16 U7.AA20 U7.AA22 U7.AA28 U7.AB8 U7.AB12 U7.AB34 U7.AB38 U7.AC2 U7.AC44 U7.AD6 U7.AD8 U7.AD14 U7.AD16 U7.AD18 U7.AD30 U7.AD32 U7.AD40 U7.AE16 U7.AE28 U7.AF8 U7.AF38 U7.AG2 U7.AG16 U7.AG26 U7.AG28 U7.AG44 U7.AJ6 U7.AJ8 U7.AJ16 U7.AJ18 U7.AJ20 U7.AJ22 U7.AJ24 U7.AJ34 U7.AJ38 U7.AK14 U7.AK16 U7.AK24 U7.AK43 U7.AK45 U7.AL2 U7.AL8 U7.AL12 U7.AL34 U7.AL38 U7.AM14 U7.AM16 U7.AM24 U7.AM26 U7.AM28 U7.AM30 U7.AM32 U7.AN8 U7.AN36 U7.AN40 U7.AN42 U7.AP13 U7.AP24 U7.AP31 U7.AP43 U7.AR2 U7.AT10 U7.AT15 U7.AT17 U7.AT20 U7.AT26 U7.AT29 U7.AT36 U7.AT38 U7.AT43 U7.AV6 U7.AV7 U7.AV13 U7.AV22 U7.AV24 U7.AV31 U7.AV33 U7.AV40 U7.AW2 U7.AY7 U7.AY10 U7.AY15 U7.AY20 U7.AY26 U7.AY29 U7.AY36 U7.B1 U7.B2 U7.B7 U7.B11 U7.B15 U7.B19 U7.B23 U7.B27 U7.B31 U7.B35 U7.B39 U7.B44 U7.B45 U7.BA1 U7.BA40 U7.BB25 U7.BB42 U7.BC1 U7.BC16 U7.BC22 U7.BC28 U7.BD1 U7.BD2 U7.BD7 U7.BD11 U7.BD15 U7.BD19 U7.BD31 U7.BD35 U7.BD39 U7.BD44 U7.BD45 U7.BE2 U7.BE3 U7.BE5 U7.BE41 U7.C45 U7.D1 U7.D4 U7.D25 U7.D42 U7.E1 U7.E45 U7.F15 U7.F20 U7.F29 U7.F33 U7.F43 U7.G2 U7.G8 U7.G38 U7.G44 U7.H7 U7.H10 U7.H13 U7.H17 U7.H22 U7.H24 U7.H26 U7.H31 U7.H36 U7.H40 U7.K10 U7.K15 U7.K20 U7.K29 U7.K33 U7.K39 U7.L2 U7.L44 U7.M17 U7.M22 U7.M24 U7.M31 U7.N6 U7.N10 U7.N12 U7.N35 U7.N39 U7.P22 U7.P24 U7.P26 U7.P28 U7.P30 U7.P32 U7.P43 U7.P45 U7.R2 U7.R8 U7.R12 U7.R14 U7.R16 U7.R34 U7.R38 U7.R44 U7.T43 U7.U6 U7.U10 U7.U16 U7.U28 U7.U34 U7.U38 U7.U39 U7.U40 U7.U42 U7.V14 U7.V16 U7.V26 U7.V43 U7.W2 U7.W44 U7.Y8 U7.Y14 U7.Y16 U7.Y24 U7.Y28 U7.Y34 U7.Y36 U7.Y40 U11.3 U11.18 U11.24 U11.31 U11.49 U12.44 U12.49 U15.49 U22.8 U22.15 U22.35 U22.41 U23.4 UA5.5 UA5.6 UA5.14 UA5.19 UA5.24 UA5.29 UE1.G2 UE1.J8 UE1.J9 UE1.J10 UE1.N13 UE2.3 UE36.12 UE36.25 UH2.4 UH3.3 UH4.3 UH5.3 UI5.3 UI5.19 UI5.33 UN1.3 UN1.13 UN1.21 UN2.5 UN2.10 UN2.12 UN2.13 UN2.15 UN2.16 UN3.2 US1.14 US1.17 US2.14 US2.17 UU2.3 UU3.3 UV1.A2 UV1.A33 UV1.AA13 UV1.AA15 UV1.AA17 UV1.AA18 UV1.AA20 UV1.AA22 UV1.AB2 UV1.AB5 UV1.AB7 UV1.AB12 UV1.AB14 UV1.AB16 UV1.AB19 UV1.AB21 UV1.AB23 UV1.AB28 UV1.AB30 UV1.AB32 UV1.AC13 UV1.AC15 UV1.AC17 UV1.AC18 UV1.AC20 UV1.AC22 UV1.AE2 UV1.AE5 UV1.AE7 UV1.AE28 UV1.AE30 UV1.AE32 UV1.AE33 UV1.AG11 UV1.AH2 UV1.AH5 UV1.AH7 UV1.AH10 UV1.AH11 UV1.AH13 UV1.AH16 UV1.AH19 UV1.AH22 UV1.AH24 UV1.AH28 UV1.AH29 UV1.AH30 UV1.AH32 UV1.AH33 UV1.AJ7 UV1.AK7 UV1.AK10 UV1.AL2 UV1.AL5 UV1.AL12 UV1.AL14 UV1.AL15 UV1.AL17 UV1.AL18 UV1.AL20 UV1.AL21 UV1.AL23 UV1.AL24 UV1.AL26 UV1.AL28 UV1.AL30 UV1.AL32 UV1.AL33 UV1.AM13 UV1.AM16 UV1.AM19 UV1.AM22 UV1.AM25 UV1.AN1 UV1.AN4 UV1.AN7 UV1.AN10 UV1.AN13 UV1.AN16 UV1.AN19 UV1.AN22 UV1.AN25 UV1.AN30 UV1.AN34 UV1.AP2 UV1.AP33 UV1.B1 UV1.B4 UV1.B7 UV1.B10 UV1.B22 UV1.B25 UV1.B28 UV1.B31 UV1.B34 UV1.C7 UV1.C10 UV1.C13 UV1.C16 UV1.C19 UV1.C22 UV1.C25 UV1.C28 UV1.D2 UV1.D31 UV1.D33 UV1.E5 UV1.E7 UV1.E10 UV1.E22 UV1.E25 UV1.F7 UV1.F28 UV1.G2 UV1.G3 UV1.G5 UV1.G7 UV1.G10 UV1.G13 UV1.G16 UV1.G19 UV1.G22 UV1.G25 UV1.G28 UV1.G30 UV1.G32 UV1.G33 UV1.K2 UV1.K5 UV1.K7 UV1.K28 UV1.K30 UV1.K32 UV1.K33 UV1.M13 UV1.M15 UV1.M17 UV1.M18 UV1.M20 UV1.M22 UV1.N2 UV1.N5 UV1.N7 UV1.N12 UV1.N14 UV1.N16 UV1.N19 UV1.N21 UV1.N23 UV1.N28 UV1.N30 UV1.N32 UV1.N33 UV1.P13 UV1.P15 UV1.P17 UV1.P18 UV1.P20 UV1.P22 UV1.R12 UV1.R14 UV1.R16 UV1.R19 UV1.R21 UV1.R23 UV1.T2 UV1.T5 UV1.T7 UV1.T13 UV1.T15 UV1.T17 UV1.T18 UV1.T20 UV1.T22 UV1.T28 UV1.T32 UV1.U12 UV1.U14 UV1.U16 UV1.U19 UV1.U21 UV1.U23 UV1.V12 UV1.V14 UV1.V16 UV1.V19 UV1.V21 UV1.V23 UV1.W13 UV1.W15 UV1.W17 UV1.W18 UV1.W20 UV1.W22 UV1.W28 UV1.W32 UV1.Y12 UV1.Y14 UV1.Y16 UV1.Y19 UV1.Y21 UV1.Y23 UV5.A1 UV5.A3 UV5.A12 UV5.A14 UV5.B5 UV5.B10 UV5.C1 UV5.C3 UV5.C4 UV5.C11 UV5.C12 UV5.C14 UV5.D10 UV5.E1 UV5.E3 UV5.E12 UV5.E14 UV5.F5 UV5.F10 UV5.G5 UV5.G10 UV5.H1 UV5.H2 UV5.H13 UV5.H14 UV5.K1 UV5.K2 UV5.K13 UV5.K14 UV5.L5 UV5.L10 UV5.M5 UV5.M10 UV5.N1 UV5.N3 UV5.N12 UV5.N14 UV5.P10 UV5.R1 UV5.R3 UV5.R4 UV5.R11 UV5.R12 UV5.R14 UV5.T5 UV5.T10 UV5.U1 UV5.U3 UV5.U12 UV5.U14 UV6.A1 UV6.A3 UV6.A12 UV6.A14 UV6.B5 UV6.B10 UV6.C1 UV6.C3 UV6.C4 UV6.C11 UV6.C12 UV6.C14 UV6.D10 UV6.E1 UV6.E3 UV6.E12 UV6.E14 UV6.F5 UV6.F10 UV6.G5 UV6.G10 UV6.H1 UV6.H2 UV6.H13 UV6.H14 UV6.K1 UV6.K2 UV6.K13 UV6.K14 UV6.L5 UV6.L10 UV6.M5 UV6.M10 UV6.N1 UV6.N3 UV6.N12 UV6.N14 UV6.P10 UV6.R1 UV6.R3 UV6.R4 UV6.R11 UV6.R12 UV6.R14 UV6.T5 UV6.T10 UV6.U1 UV6.U3 UV6.U12 UV6.U14 UV9.A1 UV9.A3 UV9.A12 UV9.A14 UV9.B5 UV9.B10 UV9.C1 UV9.C3 UV9.C4 UV9.C11 UV9.C12 UV9.C14 UV9.D10 UV9.E1 UV9.E3 UV9.E12 UV9.E14 UV9.F5 UV9.F10 UV9.G5 UV9.G10 UV9.H1 UV9.H2 UV9.H13 UV9.H14 UV9.K1 UV9.K2 UV9.K13 UV9.K14 UV9.L5 UV9.L10 UV9.M5 UV9.M10 UV9.N1 UV9.N3 UV9.N12 UV9.N14 UV9.P10 UV9.R1 UV9.R3 UV9.R4 UV9.R11 UV9.R12 UV9.R14 UV9.T5 UV9.T10 UV9.U1 UV9.U3 UV9.U12 UV9.U14 UV10.A1 UV10.A3 UV10.A12 UV10.A14 UV10.B5 UV10.B10 UV10.C1 UV10.C3 UV10.C4 UV10.C11 UV10.C12 UV10.C14 UV10.D10 UV10.E1 UV10.E3 UV10.E12 UV10.E14 UV10.F5 UV10.F10 UV10.G5 UV10.G10 UV10.H1 UV10.H2 UV10.H13 UV10.H14 UV10.K1 UV10.K2 UV10.K13 UV10.K14 UV10.L5 UV10.L10 UV10.M5 UV10.M10 UV10.N1 UV10.N3 UV10.N12 UV10.N14 UV10.P10 UV10.R1 UV10.R3 UV10.R4 UV10.R11 UV10.R12 UV10.R14 UV10.T5 UV10.T10 UV10.U1 UV10.U3 UV10.U12 UV10.U14 UV12.2 UZ4.11 UZ4.15 UZ14.2 UZ600.5 UZ600.6 UZ600.7 UZ600.8 YA2.2 YA2.4 YH2.2 YH2.4 YV1.2 YV1.4
GND_DSP: CA66.2 CA81.2 CA82.1 CA85.2 CA87.2 CA88.2 CA92.2 RA90.1 U12.12
V1N: PL702.3 PR721.1 PR745.1
V2N: PL701.3 PR717.1 PR744.1
VCC: PC214.1 PR213.2 PU200.20
VCC_PGOOD: PR719.2 PU700.3
VCCSENSE: PC718.2 PC734.2 PC736.1 PR733.2 RU96.2 U6.C50
VDD_1.35V: PC410.1 PR401.1 PR402.2 PU400.11
VIN: PC102.1 PC103.1 PC130.1 PC208.1 PD200.2 PL100.2 PL106.2 PQ200.5 PQ200.6 PQ200.7 PQ200.8 PR202.1 PR203.1 PR204.1 PR214.1 PR291.1
VSSSENSE: PC736.2 PC737.2 PU700.13 RU99.1 U6.D50
+CLK_PLLVDD: CV568.1 CV569.1 CV570.1 CV571.1 CV572.1 CV573.1 LV2.1 UV1.AD7 UV1.AE8
+EC_VCCA: CE10.1 LE1.2 UE1.B11
+EDPVDD: CV3501.1 CV3508.1 JEDP1.19 JEDP1.20 JEDP1.21 JEDP1.22 RV333.1 RV334.1 RV416.2 UV12.1
+FB_VREF: CV638.1 RV342.2 RV343.1 UV1.H26
+FBA_DLL_AVDD: CV637.1 CV639.2 CV3513.1 LV21.2 RV510.2 UV1.K27
+FBA_PLL_AVDD: CV636.1 RV510.1 UV1.H17 UV1.U27
+FBA_VREFC_H: CV676.1 RV369.1 RV372.1 RV373.2 UV6.J14
+FBA_VREFC_L: CV651.1 RV356.1 RV359.1 RV360.2 UV5.J14
+FBA_VREFD_H: CV675.1 CV777.1 RV368.1 RV370.1 RV371.2 UV6.A10 UV6.U10
+FBA_VREFD_L: CV650.1 CV776.1 RV355.1 RV357.1 RV358.2 UV5.A10 UV5.U10
+FBB_VREFC_H: CV726.1 RV395.1 RV398.1 RV399.2 UV10.J14
+FBB_VREFC_L: CV701.1 RV382.1 RV385.1 RV386.2 UV9.J14
+FBB_VREFD_H: CV725.1 CV789.1 RV394.1 RV396.1 RV397.2 UV10.A10 UV10.U10
+FBB_VREFD_L: CV700.1 CV778.1 RV381.1 RV383.1 RV384.2 UV9.A10 UV9.U10
+GPU_CORE: PC829.1 PC830.1 PC831.1 PC910.1 PC911.1 PC912.1 PC913.1 PC914.1 PC915.1 PC916.1 PC917.1 PC918.1 PC919.1 PC936.1 PC937.1 PC938.1 PC939.1 PC940.1 PC941.1 PC942.1 PC943.1 PC944.1 PC958.1 PC959.1 PC961.1 PC962.1 PC963.1 PC964.1 PC990.1 PC999.1 PC1000.1 PC1001.1 PC1002.1 PL801.2 PL802.2 PL803.2 PR825.1 RZ15.1 UV1.AA12 UV1.AA14 UV1.AA16 UV1.AA19 UV1.AA21 UV1.AA23 UV1.AB13 UV1.AB15 UV1.AB17 UV1.AB18 UV1.AB20 UV1.AB22 UV1.AC12 UV1.AC14 UV1.AC16 UV1.AC19 UV1.AC21 UV1.AC23 UV1.M12 UV1.M14 UV1.M16 UV1.M19 UV1.M21 UV1.M23 UV1.N13 UV1.N15 UV1.N17 UV1.N18 UV1.N20 UV1.N22 UV1.P12 UV1.P14 UV1.P16 UV1.P19 UV1.P21 UV1.P23 UV1.R13 UV1.R15 UV1.R17 UV1.R18 UV1.R20 UV1.R22 UV1.T12 UV1.T14 UV1.T16 UV1.T19 UV1.T21 UV1.T23 UV1.U13 UV1.U15 UV1.U17 UV1.U18 UV1.U20 UV1.U22 UV1.V13 UV1.V15 UV1.V17 UV1.V18 UV1.V20 UV1.V22 UV1.W12 UV1.W14 UV1.W16 UV1.W19 UV1.W21 UV1.W23 UV1.Y13 UV1.Y15 UV1.Y17 UV1.Y18 UV1.Y20 UV1.Y22
+INV_PWR_SRC: CV752.1 JEDP1.37 JEDP1.38 JEDP1.39 JEDP1.40 QV29.1 QV29.2 QV29.5 QV29.6
+LCDVDD_R: DV18.1 DV19.1 QV30.2 RV405.1 RV415.2 UV12.3
+MIC1_VREFO: RA19.1 RA20.1 U15.29
+PCH_USB_DCPSUS3: CH62.1 CH63.1 RH201.1 U7.AJ26 U7.AJ28
+PCH_VCC: CH101.1 CH102.1 LH100.2 U7.AP45
+PCH_VCCASW: JP18.2 U7.L17 U7.R18
+PCH_VCCCFUSE: CH77.1 R54.1 R55.1 U7.P18 U7.P20
+PCH_VCCCLK: CH30.1 CH103.1 CH105.1 CH106.1 CH110.1 CH111.1 RH202.2 U7.AA30 U7.AA32 U7.AD34 U7.AD35 U7.AD36 U7.AE30 U7.AE32 U7.AG30 U7.AG32 U7.Y32
+PCH_VCCCLK3_3: CH24.1 CH104.1 CH107.1 CH108.1 CH109.1 RH213.2 U7.L26 U7.L29 U7.M26 U7.M29 U7.U32 U7.V32
+PCH_VCCDSW: RH37.2 U7.U14
+PCH_VCCDSW_R: CH56.1 RH37.1
+PCH_VPROC: CH87.1 CH88.1 CH89.1 R53.1 U7.AJ12 U7.AJ14
+PEX_PLLVDD: CV610.1 CV611.1 CV612.1 LV3.2 UV1.AG26
+PLLVDD: CV574.1 CV773.1 LV14.1 UV1.AD8
+RTCBATT: JTB1.60 RTCR1.2
+RTCVCC: CH12.1 CH90.1 CH91.1 CH92.1 RA43.1 RH2.1 RH3.1 RH4.1 RH13.1 RH119.1 RTCD1.1 U7.A6
+V_DDR_REF: CD2.1 CD16.1 CD24.1 CD38.1 JDIMM1.1 JDIMM1.126 JDIMM2.1 JDIMM2.126 PC411.1 PU400.4 QD1.1 QD2.1
+V_DDR_REFA_R: QD1.3 U6.AR6
+V_DDR_REFB_R: QD2.3 U6.AN6
+V_SM_VREF: RU83.2 RU84.1 U6.AM6
+VCHGR: PC220.1 PC221.1 PC222.1 PC223.1 PD202.1 PQ208.1 PQ208.2 PQ208.3 PR219.4
+VDISPLAY_VCC: CV766.1 CV767.1 HDMIF1.1 JHDMI.18
+VGA_B+: PC801.1 PC802.1 PC803.1 PC804.1 PC805.1 PC806.1 PC814.1 PC815.1 PC816.1 PC817.1 PC818.1 PC819.1 PC832.1 PC833.1 PC834.1 PC835.1 PC836.1 PC837.1 PC850.1 PC851.1 PC852.1 PJP800.2 PQ800.1 PQ801.1 PQ802.1 PR815.1
+VLDOIN_1.35V: PJP401.2 PU400.19
+VSBP: PC109.1 PQ102.1 PQ102.2 PQ102.5 PQ102.6 RA53.1 RE54.1 RZ8.1
+VSBP_AMP_AVCC: CA71.1 RA47.2 UA5.7
+VSBP_AMP_PVCC: CA41.1 CA42.1 CA43.1 CA45.1 CA46.1 RA47.1 RA53.2 UA5.15 UA5.16 UA5.27 UA5.28
A52_B52: U6.A52 U6.B52
A53_B53: U6.A53 U6.B53
A_DE0: RI462.1 UI5.29
A_DE1: RI463.1 UI5.28
A_EQ0: RI460.1 UI5.32
A_EQ1: RI461.1 UI5.31
AC_IN: CE16.1 PR220.1 RE58.1 UE1.F5
AC_PRESENT: RH121.2 T171.1(TP-1) U7.E6 UE1.E5
ACDET: PC218.1 PR214.2 PR216.1 PU200.6
ACDRV: PR208.2 PU200.4
ACN: PC210.2 PC211.1 PR210.2 PU200.1
ACOFF: PQ202.2 UE1.A9
ACOK: PR212.1 PR217.2 PR220.2 PR223.1 PU200.5
ACP: PC209.2 PC210.1 PR209.2 PU200.2
AD_BID0: CE12.1 RE9.2 RE12.1 UE1.A12
ADP_I: PC219.2 PR116.1 PU200.7 UE1.B12
ADPIN: ADP100.1 ADP100.2 ADP100.3 PC100.1 PC101.1 PC120.1 PL100.1 PL106.1
ALERT#: PR701.2 PR705.2 PU700.32
AUD_MUTE: QA2.2 UE1.N12
AUD_SPK_L+: CA25.2 RA45.1
AUD_SPK_L+_R: CA53.1 RA45.2 RA49.1
AUD_SPK_L-_R: CA58.1 RA46.2
AUD_SPK_R+: CA24.2 RA48.1
AUD_SPK_R+_R: CA59.1 RA48.2 RA52.1
AUD_SPK_R-_R: CA60.1 RA51.2
AUD_SPK_RC_L+_C: CA25.1 U15.43
AUD_SPK_RC_R+_C: CA24.1 U15.44
B3_A3: U6.A3 U6.B3
B54_C54: U6.B54 U6.C54
B+: CV751.1 PC108.1 PC215.1 PC217.1 PC230.1 PC231.1 PC232.1 PC233.1 PJP300.1 PJP400.1 PJP500.1 PJP600.1 PJP700.1 PJP701.1 PJP800.1 PL203.2 PL700.2 PL705.2 PQ102.4 PR107.1 PR219.1 QV29.4 RV412.1
B++: PC303.1 PC304.1 PC305.1 PC306.1 PC308.1 PC309.1 PC340.1 PJP300.2 PQ300.5 PQ301.5 PR338.2
B_DE0: RI467.1 UI5.15
B_DE1: RI466.1 UI5.16
B_EQ0: RI464.1 UI5.13
B_EQ1: RI465.1 UI5.14
BAT1: LED3.2 R23.2
BAT2: LED7.1 R16.2
BAT3: LED8.1 R19.2
BAT4: LED9.1 R22.2
BAT5: LED6.1 R10.2
BATBTN#: D8.2 DE8.1 RE47.2 SW2.3 SW2.4 UE1.G4
BATDRV#: PR227.1 PU200.11
BATT+: PC104.1 PC105.1 PC270.1 PD202.2 PL102.1 PL105.1 PQ208.5 PQ208.6 PQ208.7 PQ208.8
BATT++: BAT100.1 BAT100.2 BAT100.3 BAT100.4 PC106.1 PC107.1 PL102.2 PL105.2
BATT_LED#_LV1: Q19.2 R32.2 UE1.B10
BATT_LED#_LV2: Q17.2 R17.2 UE1.B9
BATT_LED#_LV3: Q16.2 R20.2 UE1.N2
BATT_LED#_LV4: Q18.2 R26.2 UE1.A2
BATT_LED#_LV5: Q15.2 R11.2 UE1.N8
BATT_LOW: Q20.3 R24.1
BATT_LOW_LED#: Q20.2 R34.2 UE1.A4
BATT_LOW_LED#_D: LED3.3 R24.2
BATT_PRS: BAT100.7 PD104.2 PD104.3 PR113.1
BBS_BIT0: RH29.1 RH245.2 U7.AU2
BBS_BIT1: RH244.2 U7.C10
BE1_BD1: U6.BD1 U6.BE1
BE2_BF2: U6.BE2 U6.BF2
BE3_BF3: U6.BE3 U6.BF3
BE52_BF52: U6.BE52 U6.BF52
BE53_BF53: U6.BE53 U6.BF53
BE54_BD54: U6.BD54 U6.BE54
BEEP#: RA9.2 UE1.M8
BKOFF#: DV13.2 RV12.1 UE1.E1
BMON_OUT: PR281.1 PU202.6
BOOT1: PR740.1 PU700.18
BOOT2: PR713.1 PU700.27
BOOT_1.35V: PR400.2 PU400.18
BST1_3V: PC310.2 PR307.1
BST1_5V: PC311.1 PR308.2
BST_3V: PR307.2 PU300.9
BST_5V: PR308.1 PU300.17
BST_+1.5VRUN: PC614.1 PU600.5
BST_+V1.05V: PR501.1 PU500.10
BT_RADIO_DIS#: JTB1.24 RH174.2 U7.AN6
BTST: PR215.1 PU200.17
BUF_CPU_RST#: RU37.2 RU48.2 U6.L54
BUFO_CPU_RST#: RU11.2 RU13.1 RU42.2 RU48.1 UU2.4
C1_C2: U6.C1 U6.C2
C3_B2: U6.B2 U6.C3
CAB_DET_SINK: CV32.2 JMDP.4 QV37.2 RV453.1 U7.L15 U11.10
CAB_DET_SINK#: QV37.1 RV452.2
CAPS_LED#: QZ24.2 RE52.2 UE1.B3
CCD_INT: RH63.1 U7.N7
CCD_INT#: JTB1.50 RE34.1 UE36.20
CDCLK_REQ#: JTB1.32 RPH25.5 U7.V3
CELL: PQ207.1 PR224.1 PU200.10
CFG0: JXDP.9 U6.AG49
CFG1: JXDP.11 U6.AD49
CFG2: JXDP.15 RU77.1 U6.AC49
CFG3: JXDP.17 U6.AE49
CFG4: JXDP.27 RU115.1 U6.Y50
CFG5: JXDP.29 RU85.1 U6.AB49
CFG6: JXDP.33 RU86.1 U6.V51
CFG7: JXDP.35 RU87.1 U6.W51
CFG8: JXDP.10 U6.Y49
CFG9: JXDP.12 U6.Y54
CFG10: JXDP.16 U6.Y53
CFG11: JXDP.18 U6.W53
CFG12: JXDP.28 U6.U53
CFG13: JXDP.30 U6.V54
CFG14: JXDP.34 U6.R53
CFG15: JXDP.36 U6.R52
CFG16: JXDP.6 U6.Y52
CFG17: JXDP.4 U6.Y51
CFG18: JXDP.24 U6.V53
CFG19: JXDP.22 U6.V52
CFG_RCOMP: RH27.1 U6.R54
CHG_LGATE: PQ204.4 PU200.15
CHG_LX: PC216.1 PQ204.3 PU200.19
CHG_UGATE: PQ204.2 PU200.18
CLK_27M_IN: CV575.1 UV1.H3 YV1.1
CLK_27M_OUT: CV576.1 UV1.H2 YV1.3
CLK_BUF_BCLK: RPH27.3 U7.AT24
CLK_BUF_BCLK#: RPH27.4 U7.AR24
CLK_CPU_DMI: U6.AA6 U7.AF40
CLK_CPU_DMI#: U6.AB6 U7.AF39
CLK_CPU_ITP: JXDP.40 U7.AH45
CLK_CPU_ITP#: JXDP.42 U7.AH43
CLK_CPU_SSC_DPLL: RU40.2 U6.Y6 U7.AJ39
CLK_CPU_SSC_DPLL#: RU44.2 U6.V6 U7.AJ40
CLK_PCH_14M: RH62.1 U7.F45
CLK_PCI0: RH144.2 U7.D44
CLK_PCI1: RH145.2 U7.E44
CLK_PCI2: RH146.2 U7.B42
CLK_PCI_DEBUG: CH26.2 JSSD.19 RH146.1
CLK_PCI_LPBACK: RH144.1 U7.D17
CLK_PCI_LPC: CH14.2 RE13.1 RH145.1 UE1.N5
CLK_PCI_TPM: CH13.1 R2.1 RH97.2 U1.21
CLK_PCI_TPM_R: RH97.1 U7.C40
CLK_PCIE_CD: JTB1.31 U7.AF45
CLK_PCIE_CD#: JTB1.33 U7.AF43
CLK_PCIE_MINI3: JTB1.25 U7.AD45
CLK_PCIE_MINI3#: JTB1.27 U7.AD43
CLK_PEG_VGA: U7.AB36 UV1.AL13
CLK_PEG_VGA#: U7.AB35 UV1.AK13
CLK_REQ#: QV39.3 RPH32.4 UV1.AK12
CLK_SMB: BAT100.5 PD103.2 PR109.1
CLKA0: RV348.2 UV1.R30 UV5.J12
CLKA0#: RV349.2 UV1.R31 UV5.J11
CLKA1: RV361.2 UV1.AB31 UV6.J12
CLKA1#: RV362.2 UV1.AC31 UV6.J11
CLKB0: RV374.2 UV1.D12 UV9.J12
CLKB0#: RV375.2 UV1.E12 UV9.J11
CLKB1: RV387.2 UV1.E20 UV10.J12
CLKB1#: RV388.2 UV1.F20 UV10.J11
CLKIN_DMI: RPH27.1 U7.AW24
CLKIN_DMI#: RPH27.2 U7.AY24
CLKIN_DOT96: RH67.1 U7.G33
CLKIN_DOT96#: RH66.1 U7.H33
CLKIN_SATA: RH69.1 U7.BC6
CLKIN_SATA#: RH68.1 U7.BE6
CMSRC: PR200.2 PU200.3
COLOR_CLK: JEDP1.32 QV7.6 RV333.2
COLOR_DAT: JEDP1.31 QV7.3 RV334.2
COMP: PC724.1 PR736.1 PU700.7
CPU1.5V_S3_GATE_R: QU7.2 R29.2 RU50.2 RU53.2 RU54.2 UU3.1
CPU_FC_PWR: T172.1(TP-1) U6.D5
CPU_FC_PWROK: T173.1(TP-1) U6.D3
CPU_PLTRST#: RU37.1 U7.AU4
CPU_PWR_DEBUG: JXDP.45 RU94.2 U6.F19
CPU_TESTLOW0: RH31.1 U6.F20
CPU_TESTLOW1: RH30.1 U6.F21
CS_1.35V: PR401.2 PU400.13
CSON_B: PC226.2 PC227.1 PR219.3 PR221.2 PR283.2
CSOP_B: PC225.2 PC226.1 PR218.2 PR219.2 PR284.2
CSSN_1: PR201.3 PR210.1
CSSP_1: PR201.2 PR209.1
CTL2/3_1: RE62.2 US1.7 US1.8
CTL2/3_3: RE68.2 US2.7 US2.8
DAT_SMB: BAT100.6 PD103.3 PR111.1
DDC_CLK_HDMI: JHDMI.15 RV445.2 U22.32
DDC_DAT_HDMI: JHDMI.16 RV447.2 U22.33
DDR3_DRAMRST#: JDIMM1.30 JDIMM2.30 RU73.2
DDR3_DRAMRST#_R: QU3.1 RU72.2 RU73.1
DDR_A_BS0: JDIMM1.109 U6.BC20
DDR_A_BS1: JDIMM1.108 U6.BD21
DDR_A_BS2: JDIMM1.79 U6.BD32
DDR_A_CAS#: JDIMM1.115 U6.BE21
DDR_A_D0: JDIMM1.7 U6.AH54
DDR_A_D1: JDIMM1.4 U6.AH52
DDR_A_D2: JDIMM1.16 U6.AK51
DDR_A_D3: JDIMM1.15 U6.AK54
DDR_A_D4: JDIMM1.5 U6.AH53
DDR_A_D5: JDIMM1.6 U6.AH51
DDR_A_D6: JDIMM1.18 U6.AK52
DDR_A_D7: JDIMM1.17 U6.AK53
DDR_A_D8: JDIMM1.23 U6.AN54
DDR_A_D9: JDIMM1.21 U6.AN52
DDR_A_D10: JDIMM1.36 U6.AR51
DDR_A_D11: JDIMM1.35 U6.AR53
DDR_A_D12: JDIMM1.22 U6.AN53
DDR_A_D13: JDIMM1.24 U6.AN51
DDR_A_D14: JDIMM1.34 U6.AR52
DDR_A_D15: JDIMM1.33 U6.AR54
DDR_A_D16: JDIMM1.39 U6.AV52
DDR_A_D17: JDIMM1.41 U6.AV53
DDR_A_D18: JDIMM1.51 U6.AY52
DDR_A_D19: JDIMM1.53 U6.AY51
DDR_A_D20: JDIMM1.42 U6.AV51
DDR_A_D21: JDIMM1.40 U6.AV54
DDR_A_D22: JDIMM1.50 U6.AY54
DDR_A_D23: JDIMM1.52 U6.AY53
DDR_A_D24: JDIMM1.59 U6.AY47
DDR_A_D25: JDIMM1.56 U6.AY49
DDR_A_D26: JDIMM1.57 U6.BA47
DDR_A_D27: JDIMM1.69 U6.BA45
DDR_A_D28: JDIMM1.67 U6.AY45
DDR_A_D29: JDIMM1.68 U6.AY43
DDR_A_D30: JDIMM1.58 U6.BA49
DDR_A_D31: JDIMM1.70 U6.BA43
DDR_A_D32: JDIMM1.129 U6.BF14
DDR_A_D33: JDIMM1.131 U6.BC14
DDR_A_D34: JDIMM1.141 U6.BC11
DDR_A_D35: JDIMM1.143 U6.BF11
DDR_A_D36: JDIMM1.130 U6.BE14
DDR_A_D37: JDIMM1.132 U6.BD14
DDR_A_D38: JDIMM1.140 U6.BD11
DDR_A_D39: JDIMM1.142 U6.BE11
DDR_A_D40: JDIMM1.147 U6.BC9
DDR_A_D41: JDIMM1.149 U6.BE9
DDR_A_D42: JDIMM1.157 U6.BE6
DDR_A_D43: JDIMM1.159 U6.BC6
DDR_A_D44: JDIMM1.146 U6.BD9
DDR_A_D45: JDIMM1.148 U6.BF9
DDR_A_D46: JDIMM1.158 U6.BE5
DDR_A_D47: JDIMM1.160 U6.BD6
DDR_A_D48: JDIMM1.163 U6.BB4
DDR_A_D49: JDIMM1.165 U6.BC2
DDR_A_D50: JDIMM1.175 U6.AW3
DDR_A_D51: JDIMM1.177 U6.AW2
DDR_A_D52: JDIMM1.164 U6.BB3
DDR_A_D53: JDIMM1.166 U6.BB2
DDR_A_D54: JDIMM1.174 U6.AW4
DDR_A_D55: JDIMM1.176 U6.AW1
DDR_A_D56: JDIMM1.181 U6.AU3
DDR_A_D57: JDIMM1.183 U6.AU1
DDR_A_D58: JDIMM1.191 U6.AR1
DDR_A_D59: JDIMM1.193 U6.AR4
DDR_A_D60: JDIMM1.180 U6.AU2
DDR_A_D61: JDIMM1.182 U6.AU4
DDR_A_D62: JDIMM1.192 U6.AR2
DDR_A_D63: JDIMM1.194 U6.AR3
DDR_A_DQS0: JDIMM1.12 U6.AJ53
DDR_A_DQS1: JDIMM1.29 U6.AP52
DDR_A_DQS2: JDIMM1.47 U6.AW53
DDR_A_DQS3: JDIMM1.64 U6.BA46
DDR_A_DQS4: JDIMM1.137 U6.BE12
DDR_A_DQS5: JDIMM1.154 U6.BD7
DDR_A_DQS6: JDIMM1.171 U6.BA2
DDR_A_DQS7: JDIMM1.188 U6.AT3
DDR_A_DQS#0: JDIMM1.10 U6.AJ52
DDR_A_DQS#1: JDIMM1.27 U6.AP53
DDR_A_DQS#2: JDIMM1.45 U6.AW52
DDR_A_DQS#3: JDIMM1.62 U6.AY46
DDR_A_DQS#4: JDIMM1.135 U6.BD12
DDR_A_DQS#5: JDIMM1.152 U6.BE7
DDR_A_DQS#6: JDIMM1.169 U6.BA3
DDR_A_DQS#7: JDIMM1.186 U6.AT2
DDR_A_MA0: JDIMM1.98 U6.BD28
DDR_A_MA1: JDIMM1.97 U6.BD27
DDR_A_MA2: JDIMM1.96 U6.BF28
DDR_A_MA3: JDIMM1.95 U6.BE28
DDR_A_MA4: JDIMM1.92 U6.BF32
DDR_A_MA5: JDIMM1.91 U6.BC27
DDR_A_MA6: JDIMM1.90 U6.BF27
DDR_A_MA7: JDIMM1.86 U6.BC28
DDR_A_MA8: JDIMM1.89 U6.BE27
DDR_A_MA9: JDIMM1.85 U6.BC32
DDR_A_MA10: JDIMM1.107 U6.BD20
DDR_A_MA11: JDIMM1.84 U6.BF31
DDR_A_MA12: JDIMM1.83 U6.BC31
DDR_A_MA13: JDIMM1.119 U6.BE20
DDR_A_MA14: JDIMM1.80 U6.BE32
DDR_A_MA15: JDIMM1.78 U6.BE31
DDR_A_RAS#: JDIMM1.110 U6.BF20
DDR_A_WE#: JDIMM1.113 U6.BF21
DDR_B_BS0: JDIMM2.109 U6.AY23
DDR_B_BS1: JDIMM2.108 U6.BA23
DDR_B_BS2: JDIMM2.79 U6.BA36
DDR_B_CAS#: JDIMM2.115 U6.AV20
DDR_B_D0: JDIMM2.5 U6.AC54
DDR_B_D1: JDIMM2.7 U6.AC52
DDR_B_D2: JDIMM2.15 U6.AE51
DDR_B_D3: JDIMM2.17 U6.AE54
DDR_B_D4: JDIMM2.4 U6.AC53
DDR_B_D5: JDIMM2.6 U6.AC51
DDR_B_D6: JDIMM2.16 U6.AE52
DDR_B_D7: JDIMM2.18 U6.AE53
DDR_B_D8: JDIMM2.23 U6.AU47
DDR_B_D9: JDIMM2.24 U6.AU49
DDR_B_D10: JDIMM2.36 U6.AV43
DDR_B_D11: JDIMM2.35 U6.AV45
DDR_B_D12: JDIMM2.34 U6.AU43
DDR_B_D13: JDIMM2.33 U6.AU45
DDR_B_D14: JDIMM2.22 U6.AV47
DDR_B_D15: JDIMM2.21 U6.AV49
DDR_B_D16: JDIMM2.39 U6.BC49
DDR_B_D17: JDIMM2.41 U6.BE49
DDR_B_D18: JDIMM2.51 U6.BD47
DDR_B_D19: JDIMM2.53 U6.BC47
DDR_B_D20: JDIMM2.40 U6.BD49
DDR_B_D21: JDIMM2.42 U6.BD50
DDR_B_D22: JDIMM2.50 U6.BE47
DDR_B_D23: JDIMM2.52 U6.BF47
DDR_B_D24: JDIMM2.57 U6.BE44
DDR_B_D25: JDIMM2.59 U6.BD44
DDR_B_D26: JDIMM2.67 U6.BC42
DDR_B_D27: JDIMM2.69 U6.BF42
DDR_B_D28: JDIMM2.56 U6.BF44
DDR_B_D29: JDIMM2.58 U6.BC44
DDR_B_D30: JDIMM2.68 U6.BD42
DDR_B_D31: JDIMM2.70 U6.BE42
DDR_B_D32: JDIMM2.129 U6.BA16
DDR_B_D33: JDIMM2.131 U6.AU16
DDR_B_D34: JDIMM2.141 U6.BA15
DDR_B_D35: JDIMM2.143 U6.AV15
DDR_B_D36: JDIMM2.130 U6.AY16
DDR_B_D37: JDIMM2.132 U6.AV16
DDR_B_D38: JDIMM2.140 U6.AY15
DDR_B_D39: JDIMM2.142 U6.AU15
DDR_B_D40: JDIMM2.149 U6.AU12
DDR_B_D41: JDIMM2.148 U6.AY12
DDR_B_D42: JDIMM2.157 U6.BA10
DDR_B_D43: JDIMM2.160 U6.AU10
DDR_B_D44: JDIMM2.147 U6.AV12
DDR_B_D45: JDIMM2.146 U6.BA12
DDR_B_D46: JDIMM2.159 U6.AY10
DDR_B_D47: JDIMM2.158 U6.AV10
DDR_B_D48: JDIMM2.163 U6.AU8
DDR_B_D49: JDIMM2.166 U6.BA8
DDR_B_D50: JDIMM2.176 U6.AV6
DDR_B_D51: JDIMM2.177 U6.BA6
DDR_B_D52: JDIMM2.165 U6.AV8
DDR_B_D53: JDIMM2.164 U6.AY8
DDR_B_D54: JDIMM2.174 U6.AU6
DDR_B_D55: JDIMM2.175 U6.AY6
DDR_B_D56: JDIMM2.181 U6.AM2
DDR_B_D57: JDIMM2.183 U6.AM3
DDR_B_D58: JDIMM2.192 U6.AK1
DDR_B_D59: JDIMM2.193 U6.AK4
DDR_B_D60: JDIMM2.180 U6.AM1
DDR_B_D61: JDIMM2.182 U6.AM4
DDR_B_D62: JDIMM2.191 U6.AK2
DDR_B_D63: JDIMM2.194 U6.AK3
DDR_B_DQS0: JDIMM2.12 U6.AD53
DDR_B_DQS1: JDIMM2.29 U6.AV46
DDR_B_DQS2: JDIMM2.47 U6.BE48
DDR_B_DQS3: JDIMM2.64 U6.BE43
DDR_B_DQS4: JDIMM2.137 U6.AW15
DDR_B_DQS5: JDIMM2.154 U6.AW12
DDR_B_DQS6: JDIMM2.171 U6.AW6
DDR_B_DQS7: JDIMM2.188 U6.AL3
DDR_B_DQS#0: JDIMM2.10 U6.AD52
DDR_B_DQS#1: JDIMM2.27 U6.AU46
DDR_B_DQS#2: JDIMM2.45 U6.BD48
DDR_B_DQS#3: JDIMM2.62 U6.BD43
DDR_B_DQS#4: JDIMM2.135 U6.AW16
DDR_B_DQS#5: JDIMM2.152 U6.AW10
DDR_B_DQS#6: JDIMM2.169 U6.AW8
DDR_B_DQS#7: JDIMM2.186 U6.AL2
DDR_B_MA0: JDIMM2.98 U6.BA30
DDR_B_MA1: JDIMM2.97 U6.AW30
DDR_B_MA2: JDIMM2.96 U6.AY30
DDR_B_MA3: JDIMM2.95 U6.AV30
DDR_B_MA4: JDIMM2.92 U6.AW32
DDR_B_MA5: JDIMM2.91 U6.AY32
DDR_B_MA6: JDIMM2.90 U6.AT30
DDR_B_MA7: JDIMM2.86 U6.AV32
DDR_B_MA8: JDIMM2.89 U6.BA32
DDR_B_MA9: JDIMM2.85 U6.AU32
DDR_B_MA10: JDIMM2.107 U6.AU23
DDR_B_MA11: JDIMM2.84 U6.AY35
DDR_B_MA12: JDIMM2.83 U6.AW35
DDR_B_MA13: JDIMM2.119 U6.AU20
DDR_B_MA14: JDIMM2.80 U6.AW36
DDR_B_MA15: JDIMM2.78 U6.BA35
DDR_B_RAS#: JDIMM2.110 U6.AV23
DDR_B_WE#: JDIMM2.113 U6.AW23
DDR_CKE0_DIMMA: JDIMM1.73 U6.BE34
DDR_CKE1_DIMMA: JDIMM1.74 U6.BF34
DDR_CKE2_DIMMB: JDIMM2.73 U6.AU36
DDR_CKE3_DIMMB: JDIMM2.74 U6.AU35
DDR_CS0_DIMMA#: JDIMM1.114 U6.BE16
DDR_CS1_DIMMA#: JDIMM1.121 U6.BC17
DDR_CS2_DIMMB#: JDIMM2.114 U6.BA20
DDR_CS3_DIMMB#: JDIMM2.121 U6.AY19
DDR_VREF_IN: CA65.1 CA77.2 RA59.2 RA62.1 U12.40
DEW2: RN19.1 RN21.1 UN1.6
DGPU_FB_EN: DZ2.1 PU600.28 QZ19.2 RZ9.2 RZ485.1
DGPU_HOLD_RST#: RPH2.3 U7.A12 UH4.2
DGPU_PWR_EN: CH99.1 PR841.2 QH6.1 QZ2.2 QZ18.2 RH247.1 RH416.1 RV289.2
DGPU_PWR_EN#: QH6.2 RH164.2 RH416.2 U7.C12
DGPU_PWROK: DZ2.2 PR842.2 RPH8.6 RZ9.1 U7.C14
DH_1.35V: PQ400.4 PU400.17
DISP_A0N_R: C47.1 DV2.5 DV2.6 JMDP.5
DISP_A0P_R: C93.1 DV2.4 DV2.7 JMDP.3
DISP_A1N_R: C53.1 DV3.4 DV3.7 JMDP.11
DISP_A1P_R: C42.1 DV3.5 DV3.6 JMDP.9
DISP_A2N_R: C57.1 DV3.1 DV3.9 JMDP.17
DISP_A2P_R: C59.1 DV3.2 DV3.8 JMDP.15
DISP_A3N_R: C56.1 DV2.2 DV2.8 JMDP.12
DISP_A3P_R: C54.1 DV2.1 DV2.9 JMDP.10
DISP_C_A0N: CV780.1 U11.39
DISP_C_A0P: CV779.1 U11.38
DISP_C_A1N: CV782.1 U11.42
DISP_C_A1P: CV781.1 U11.41
DISP_C_A2N: CV784.1 U11.45
DISP_C_A2P: CV783.1 U11.44
DISP_C_A3N: CV786.1 U11.48
DISP_C_A3P: CV785.1 U11.47
DISP_CEC: JMDP.6 RV456.1
DISP_CLK_AUXP_CONN: JMDP.16 RV490.1 U11.28
DISP_DAT_AUXN_CONN: JMDP.18 RV491.1 U11.27
DISPOFF#: DV13.1 JEDP1.28 RV403.1
DL_1.35V: PQ401.4 PU400.15
DMI_CRX_PTX_N0: U6.AB2 U7.BD21
DMI_CRX_PTX_N1: U6.AB3 U7.BE20
DMI_CRX_PTX_N2: U6.AC3 U7.BD17
DMI_CRX_PTX_N3: U6.AC1 U7.BE18
DMI_CRX_PTX_P0: U6.AB1 U7.BB21
DMI_CRX_PTX_P1: U6.AB4 U7.BC20
DMI_CRX_PTX_P2: U6.AC4 U7.BB17
DMI_CRX_PTX_P3: U6.AC2 U7.BC18
DMI_CTX_PRX_N0: U6.AF2 U7.AW22
DMI_CTX_PRX_N1: U6.AF4 U7.AR20
DMI_CTX_PRX_N2: U6.AG4 U7.AP17
DMI_CTX_PRX_N3: U6.AG2 U7.AV20
DMI_CTX_PRX_P0: U6.AF1 U7.AY22
DMI_CTX_PRX_P1: U6.AF3 U7.AP20
DMI_CTX_PRX_P2: U6.AG3 U7.AR17
DMI_CTX_PRX_P3: U6.AG1 U7.AW20
DMI_RCOMP: RH99.2 U7.AY17
DMIC0: CA23.1 RA97.2 RV424.1
DMIC0_R: CV753.1 JTB1.34 RV424.2
DMIC0_RA: RA97.1 U15.13
DMIC_CLK: CA27.1 RA96.2 RV417.1
DMIC_CLK_R: CV754.1 JTB1.36 RV417.2
DMIC_CLK_RA: RA96.1 U15.12
DP_PCH_HPD: RV411.1 U7.C22 U7.K38
DPLL_REF_CLK: U6.AE6 U7.AF36
DPLL_REF_CLK#: U6.AC6 U7.AF35
DRAMRST_CNTRL_PCH: RH53.1 U7.N8
DRAMRST_CNTRL_S3: CU39.1 QD1.2 QD2.2 QU3.2 RU54.1 RU62.2 UE1.M6
DSP_PD#: RA91.2 U12.17 UE36.17
DSWODVREN: RH119.2 RH122.2 U7.C8
EAPD#: RA99.1 RE28.2 U15.14 UE1.D6
EC_BATT_PRS#: CE13.1 PC228.1 PR113.2 PR114.1 UE1.M1
EC_CRY2: CE18.1 RE39.2 RE40.1 UE1.K1
EC_ENVDD: DV19.2 RV415.1 UE1.A10
EC_INV_PWM: DV21.2 UE1.K8
EC_ON: CE23.1 RE340.1 UE1.G1
EC_ON_CTRL#: CE26.1 DE8.2 DE9.2 RE49.2 UE1.G5
EC_PECI: RE38.1 UE1.H2
EC_RST#: CE14.2 RE11.2 UE1.K13
EC_RUNTIME_SCI#: RPH9.5 U7.G15 UE1.N6
EC_RX: JSSD.51 UE1.K9
EC_SMB_CK1: PR109.2 PR231.1 RPH19.6 UE1.A8
EC_SMB_CK1_R: PR231.2 PU200.9
EC_SMB_CK2_PX: QV21.1 RV325.2 UV1.T4
EC_SMB_DA1: PR111.2 PR230.1 RPH19.5 UE1.A7
EC_SMB_DA1_R: PR230.2 PU200.8
EC_SMB_DA2_PX: QV21.4 RV326.2 UV1.T3
EC_SMI#: RPH7.5 U7.Y1 UE1.L13
EC_TX: JSSD.49 RM12.2 T43.1(TP-1) UE1.K10
EC_WLAN_WAKE#: DE12.1 JTB1.20
ECAGND: CE10.2 CE13.2 LE2.1 UE1.A11
EDP_AUXN: CH43.1 U6.F15
EDP_AUXN_C: CH43.2 LV18.1
EDP_AUXN_R: JEDP1.16 LV18.2
EDP_AUXP: CH44.1 U6.F14
EDP_AUXP_C: CH44.2 LV18.4
EDP_AUXP_R: JEDP1.15 LV18.3
EDP_COMP: RU2.1 U6.AG6
EDP_HPD: QV38.1 RV470.2 U6.E14
EDP_HPD_S: JEDP1.26 QV38.2 RV469.1
EDP_LVDDEN: DV18.2 RH132.2 U7.G36
EDP_PWM: DV10.2 U7.N36
EDP_TXN0: CH25.1 U6.C14
EDP_TXN0_C: CH25.2 LV16.4
EDP_TXN0_R: JEDP1.12 LV16.3
EDP_TXN1: CH32.1 U6.A12
EDP_TXN1_C: CH32.2 LV17.4
EDP_TXN1_R: JEDP1.9 LV17.3
EDP_TXN2: CH40.1 U6.C12
EDP_TXN2_C: CH40.2 LV19.4
EDP_TXN2_R: JEDP1.6 LV19.3
EDP_TXN3: CH42.1 U6.A14
EDP_TXN3_C: CH42.2 LV20.1
EDP_TXN3_R: JEDP1.3 LV20.2
EDP_TXP0: CH23.1 U6.D14
EDP_TXP0_C: CH23.2 LV16.1
EDP_TXP0_R: JEDP1.13 LV16.2
EDP_TXP1: CH29.1 U6.B12
EDP_TXP1_C: CH29.2 LV17.1
EDP_TXP1_R: JEDP1.10 LV17.2
EDP_TXP2: CH31.1 U6.D12
EDP_TXP2_C: CH31.2 LV19.1
EDP_TXP2_R: JEDP1.7 LV19.2
EDP_TXP3: CH41.1 U6.B14
EDP_TXP3_C: CH41.2 LV20.4
EDP_TXP3_R: JEDP1.4 LV20.3
EN_+V1.05V: PR503.2 PU500.3
EN_CAM: T8.1(TP-1) U7.A10
EN_WLANPWR#: JTB1.28 UE1.F4
ENBKL: RE469.2 RH138.2 RV11.1 U7.K36
ESB_CLK: RPE2.6 UE1.N7 UE36.1
ESB_DAT: RPE2.5 UE1.M7 UE36.4
FAN_TEMP0: HT5.1 RT4.1 UE1.A13
FAN_TEMP1: HT6.1 RT2.1 UE1.B7
FB: PR732.1 PR733.1 PR738.1 PU700.8
FB2/VSEN: PR728.2 PU700.9
FB_3V: PC301.2 PR300.2 PR302.2 PU300.4
FB_5V: PC302.1 PR301.1 PR304.1 PU300.2
FB_+V1.05V: PC510.1 PR507.1 PR508.1 PU500.4
FB_CLAMP: DZ2.3 QZ25.3 RV8.1 RV505.2 UE36.5
FB_CLAMP_MON: QZ25.1 RV503.2 RZ472.2
FB_CLAMP_MON_R: RV503.1 RV505.1 UV1.P6
FB_CLAMP_REQ#: QV42.3 RE33.1 UE36.10
FB_CLAMP_REQ#_Q: QV42.4 RPH32.3 UV1.M7
FBA_CMD0: UV1.U30 UV5.G12
FBA_CMD1: UV1.T31 UV5.H10
FBA_CMD2: UV1.U29 UV5.H11
FBA_CMD3: UV1.R34 UV5.K11
FBA_CMD4: UV1.R33 UV5.K10
FBA_CMD5: UV1.U32 UV5.L12
FBA_CMD6: UV1.U33 UV5.K4
FBA_CMD7: UV1.U28 UV5.K5
FBA_CMD8: UV1.V28 UV5.J4
FBA_CMD9: UV1.V29 UV5.J5
FBA_CMD10: UV1.V30 UV5.H4
FBA_CMD11: UV1.U34 UV5.H5
FBA_CMD12: UV1.U31 UV5.G3
FBA_CMD13: RV341.1 UV1.V34 UV5.J2
FBA_CMD14: RV339.1 UV1.V33 UV5.J3
FBA_CMD15: UV1.Y32 UV5.L3
FBA_CMD16: UV1.AA31 UV6.G12
FBA_CMD17: UV1.AA29 UV6.H10
FBA_CMD18: UV1.AA28 UV6.H11
FBA_CMD19: UV1.AC34 UV6.K11
FBA_CMD20: UV1.AC33 UV6.K10
FBA_CMD21: UV1.AA32 UV6.L12
FBA_CMD22: UV1.AA33 UV6.K4
FBA_CMD23: UV1.Y28 UV6.K5
FBA_CMD24: UV1.Y29 UV6.J4
FBA_CMD25: UV1.W31 UV6.J5
FBA_CMD26: UV1.Y30 UV6.H4
FBA_CMD27: UV1.AA34 UV6.H5
FBA_CMD28: UV1.Y31 UV6.G3
FBA_CMD29: RV340.1 UV1.Y34 UV6.J2
FBA_CMD30: RV338.1 UV1.Y33 UV6.J3
FBA_CMD31: UV1.V31 UV6.L3
FBA_D0: UV1.L28 UV5.A4
FBA_D1: UV1.M29 UV5.A2
FBA_D2: UV1.L29 UV5.B4
FBA_D3: UV1.M28 UV5.B2
FBA_D4: UV1.N31 UV5.E4
FBA_D5: UV1.P29 UV5.E2
FBA_D6: UV1.R29 UV5.F4
FBA_D7: UV1.P28 UV5.F2
FBA_D8: UV1.J28 UV5.A11
FBA_D9: UV1.H29 UV5.A13
FBA_D10: UV1.J29 UV5.B11
FBA_D11: UV1.H28 UV5.B13
FBA_D12: UV1.G29 UV5.E11
FBA_D13: UV1.E31 UV5.E13
FBA_D14: UV1.E32 UV5.F11
FBA_D15: UV1.F30 UV5.F13
FBA_D16: UV1.C34 UV5.U11
FBA_D17: UV1.D32 UV5.U13
FBA_D18: UV1.B33 UV5.T11
FBA_D19: UV1.C33 UV5.T13
FBA_D20: UV1.F33 UV5.N11
FBA_D21: UV1.F32 UV5.N13
FBA_D22: UV1.H33 UV5.M11
FBA_D23: UV1.H32 UV5.M13
FBA_D24: UV1.P34 UV5.U4
FBA_D25: UV1.P32 UV5.U2
FBA_D26: UV1.P31 UV5.T4
FBA_D27: UV1.P33 UV5.T2
FBA_D28: UV1.L31 UV5.N4
FBA_D29: UV1.L34 UV5.N2
FBA_D30: UV1.L32 UV5.M4
FBA_D31: UV1.L33 UV5.M2
FBA_D32: UV1.AG28 UV6.A4
FBA_D33: UV1.AF29 UV6.A2
FBA_D34: UV1.AG29 UV6.B4
FBA_D35: UV1.AF28 UV6.B2
FBA_D36: UV1.AD30 UV6.E4
FBA_D37: UV1.AD29 UV6.E2
FBA_D38: UV1.AC29 UV6.F4
FBA_D39: UV1.AD28 UV6.F2
FBA_D40: UV1.AJ29 UV6.A11
FBA_D41: UV1.AK29 UV6.A13
FBA_D42: UV1.AJ30 UV6.B11
FBA_D43: UV1.AK28 UV6.B13
FBA_D44: UV1.AM29 UV6.E11
FBA_D45: UV1.AM31 UV6.E13
FBA_D46: UV1.AN29 UV6.F11
FBA_D47: UV1.AM30 UV6.F13
FBA_D48: UV1.AN31 UV6.U11
FBA_D49: UV1.AN32 UV6.U13
FBA_D50: UV1.AP30 UV6.T11
FBA_D51: UV1.AP32 UV6.T13
