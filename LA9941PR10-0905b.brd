# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_SMB_DA1_R: length 2
  BOTTOM w0.254: PR230.2 82.9,28.72 81.97,28.72 81.85,28.84 PU200.8
EC_SMB_DA2_PX: length 11.9
  TOP w0.089: v1(216.31,77.7) 215.84,78.18 RV326.2
  BOTTOM w0.089: UV1.T3 217.13,79.38 216.53,79.38 216.31,79.16 v1(216.31,77.7) 212.12,77.7 211.74,77.32
  BOTTOM w0.102: 211.74,77.32 211.06,76.64 v2(211.06,76.21) QV21.4
EC_SMI#: length 140.6
  TOP w0.089: 166.95,21.72 166.95,21.55 166.89,21.48 166.89,20.77 UE1.L13
  TOP w0.102: v3(272.48,11.09) 271.87,11.09 RPH7.5 271.56,11.77 272.1,12.3 272.1,12.78 271.86,13.02 270.85,13.02 269.14,14.72 269.14,18.48 v3(268.19,19.44) ; 166.95,21.72 166.95,22.19 167.32,22.56 171.41,22.56 171.87,23.02 v2(173.19,23.02) 174.9,23.02 176.19,24.32 183.78,24.32 187.82,20.28 187.82,11.25 v1(188.06,11.01)
  GND1 w0.102: v3(272.48,11.09) 272.99,10.58 272.99,10.55 v4(272.98,10.55) ; v3(268.19,19.44) v4(267.42,19.44)
  IN2 w0.102: v1(188.06,11.01) 188.48,11.42 190.24,11.42 190.47,11.2 210.22,11.2 214.23,15.22 216.75,15.22 221.14,10.83 234.22,10.83 234.82,11.43 236.02,11.43 236.43,11.02 244.69,11.02 246.29,9.42 249.98,9.42 250.15,9.25 272.15,9.25 272.98,10.09 v4(272.98,10.55)
  GND3 w0.102: v4(267.42,19.44) 267.14,19.44 v7(267.03,19.55)
  BOTTOM w0.089: U7.Y1 267.03,19.66
  BOTTOM w0.102: 267.03,19.66 v7(267.03,19.55)
EC_TX: length 126
  TOP w0.076: UE1.K10 166.79,19.16 166.8,19.17
  TOP w0.089: 166.8,19.17 v1(166.81,19.19)
  TOP w0.102: T43.1 280.43,35.77 v1(280.43,36.06) 280.48,36.11 RM12.2
  IN2 w0.076: 168.78,19.32 168.77,19.33 166.96,19.33 v1(166.81,19.19)
  IN2 w0.102: 168.78,19.32 192.4,19.32 193.5,20.42 197.59,20.42 199.05,21.88 203.06,21.88 203.99,22.8 228.09,22.8 v4(228.38,23.1)
  IN4 w0.102: v4(228.38,23.1) 228.89,22.59 229.45,22.59 229.49,22.63 244.77,22.63 249.4,27.26 255.16,27.26 256.48,28.58 256.75,28.58 257.58,29.41 257.58,30.1 258.03,30.55 261.41,30.55 262.54,31.69 264.12,31.69 264.5,32.06 267.06,32.06 267.31,31.81 268.18,31.81 268.81,32.44 268.81,32.88 269.13,33.21 272.05,33.21 274.03,35.19 276.05,35.19 277.14,36.27 280.22,36.27 v1(280.43,36.06)
  BOTTOM w0.102: v1(280.43,36.06) 280.43,36.72 280.7,37 JSSD.49
EC_WLAN_WAKE#: length 149.1
  TOP w0.102: v1(145.92,14.23) 145.92,14.19 145.4,13.67 144.31,13.67 v2(143.93,13.3) 143.04,12.41 DE12.1
  IN3 w0.102: v4(274.33,10.32) 273.62,10.32 272.37,9.07 253.05,9.07 252.02,10.09 251.09,10.09 250.79,10.4 249.57,10.4 248.93,9.76 247.74,9.76 243.37,14.13 234.04,14.13 233.56,14.61 221.46,14.61 220.45,15.62 214.28,15.62 211.77,13.11 211.77,12.76 210.69,11.68 191.3,11.68 190.33,12.64 173.9,12.64 172.91,11.66 158.68,11.66 157.54,12.8 154.93,12.8 152.68,15.04 149.43,15.04 148.62,14.23 v1(145.92,14.23)
  IN4 w0.102: v4(274.33,10.32) 274.03,10.02 272.98,10.02 272.29,9.33 268.59,9.33 v6(268.11,9.81)
  GND3 w0.102: v6(268.11,9.81) 267.88,10.04 v7(267.45,10.04)
  BOTTOM w0.102: v7(267.45,10.04) 267.3,9.89 JTB1.20
ECAGND: length 3.7
  TOP w0.203: CE13.2 158.55,19.92 v2(160.07,19.92) 160.76,19.92 160.86,19.82 161.25,19.82 161.41,19.66 UE1.A11
EDP_AUXN: length 130.2
  IN4 w0.089: v6(170.16,100.95) 170.26,100.85 170.43,100.85 170.48,100.9 170.48,101.05 170.6,101.17 170.6,101.29 170.32,101.57 169.98,101.57 169.34,102.2 169.34,106 167.43,107.91 147.06,107.91 146.18,107.03 143.81,107.03 142.53,105.74 141.34,105.74 140.21,104.62 140.21,104.06 138.43,102.27 137.83,102.27 133.11,97.56 131.38,97.56 128.99,95.17 128.99,66.75 118.53,56.29 114.85,56.29 113.62,55.07 113.62,54.94 113.94,54.62 v1(113.96,54.62)
  GND3 w0.089: v7(170.17,101.52) 170.26,101.44 170.26,101.02 170.19,100.95 v6(170.16,100.95)
  BOTTOM w0.089: v7(170.17,101.52) 170.55,101.14 U6.F15
  BOTTOM w0.102: CH43.1 101.15,35.29 101.63,35.29 105.6,39.26 105.6,46.64 108.03,49.07 110.57,49.07 113.96,52.46 v1(113.96,54.62)
EDP_AUXN_C: length 1
  BOTTOM w0.102: CH43.2 99.82,35.24 LV18.1
EDP_AUXN_R: length 16.7
  BOTTOM w0.102: JEDP1.16 84.55,40.1 84.6,40.05 84.6,38.93 85.87,37.67 89.93,37.67 92.4,35.2 v9(93.51,35.2) 96.29,35.2 96.33,35.16 96.87,35.16 96.91,35.2 97.21,35.2 97.25,35.24 LV18.2
EDP_AUXP: length 130.2
  IN4 w0.089: v1(113.38,54.62) 113.44,54.68 113.44,55.14 114.77,56.48 118.45,56.48 128.8,66.83 128.8,95.25 131.3,97.75 133.04,97.75 137.75,102.46 138.35,102.46 140.03,104.14 140.03,104.69 141.26,105.93 142.45,105.93 143.74,107.21 146.1,107.21 146.98,108.09 167.51,108.09 169.52,106.07 169.52,102.28 170.05,101.75 170.4,101.75 170.78,101.37 v6(170.78,100.93)
  GND3 w0.089: v6(170.78,100.93) 170.78,101.32 v7(170.96,101.49)
  BOTTOM w0.089: U6.F14 171.31,101.14 v7(170.96,101.49)
  BOTTOM w0.102: v1(113.38,54.62) 113.39,54.62 113.75,54.25 113.75,52.55 110.48,49.28 107.94,49.28 105.39,46.72 105.39,39.35 101.54,35.5 101.24,35.5 100.91,35.83 CH44.1
EDP_AUXP_C: length 1
  BOTTOM w0.102: LV18.4 99.84,35.79 CH44.2
EDP_AUXP_R: length 16.6
  BOTTOM w0.102: JEDP1.15 85.05,40.13 84.99,40.07 84.86,40.07 84.81,40.02 84.81,39.02 85.95,37.88 90.02,37.88 92.48,35.41 93.21,35.41 93.23,35.43 93.79,35.43 93.81,35.41 v9(96.61,35.41) 97.09,35.41 97.47,35.79 LV18.3
EDP_COMP: length 2.7
  TOP w0.089: RU2.1 v2(175.5,88.28)
  TOP w0.508: RU2.1 175.55,87.26 v1(176.3,86.52)
  BOTTOM w0.254: v1(176.3,86.52) 176.73,86.95 U6.AG6
EDP_HPD: length 130.9
  IN1 w0.089: v1(101.83,44.43) 106.64,44.43 119.04,56.83 119.04,59.75 127.2,67.92 127.2,98.54 129.71,101.05 130.22,101.05 131.19,102.02 131.19,102.05 132.57,103.42 132.57,108.98 136.35,112.76 145.18,112.76 149.9,108.05 164,108.05 165.02,107.03 169.29,107.03 171.44,104.88 171.44,102.59 v1(171.82,102.2)
  BOTTOM w0.089: U6.E14 171.46,101.84 v1(171.82,102.2)
  BOTTOM w0.102: v1(101.83,44.43) 101.83,45.12 101.6,45.35 QV38.1 100.96,46.92 RV470.2
EDP_HPD_S: length 21.4
  BOTTOM w0.102: JEDP1.26 79.55,41.4 79.74,41.59 87.36,41.59 88.2,42.43 89.52,42.43 v2(89.85,42.76) 90.61,43.52 94.12,43.52 94.77,44.17 97.38,44.17 RV469.1 97.91,44.7 QV38.2
EDP_LVDDEN: length 242
  TOP w0.089: v1(272.22,36.65) 272.22,36.65 RH132.2
  IN4 w0.076: 167.23,15.13 167.39,15.28 168.78,15.28
  IN4 w0.089: v6(70.27,30.44) 70.41,30.29 81.51,30.29 82.15,29.65 83.12,29.65 83.76,30.29 100.16,30.29 110.46,19.99 116.99,19.99 117.35,19.63 122.63,19.63 123.1,20.1 127.9,20.1 128.27,19.73 147.68,19.73 148.1,19.32 148.1,17.96 148.51,17.55 148.95,17.55 149.45,18.04 156.09,18.04 159.6,14.53 162.8,14.53 163.4,15.13 167.23,15.13 ; 168.78,15.28 174.3,15.28 174.68,15.66 179.09,15.66 179.32,15.43 194.21,15.43 194.88,16.09 196.63,16.09 197.56,17.02 199.83,17.02 200.67,17.85 201.75,17.85 206.09,22.19 209,22.19 210.85,24.04 232.35,24.04 233.08,24.78 234.83,24.78 235.56,24.04 244.45,24.04 250.1,29.69 250.1,37.54 252.28,39.72 257.39,39.72 258.13,40.46 259.08,40.46 259.91,39.63 264.42,39.63 266.56,37.48 267.84,37.48 268.42,36.9 270.17,36.9 270.33,37.07 271.8,37.07 v1(272.22,36.65)
  GND3 w0.102: v7(69.63,31.33) 70.27,30.69 v6(70.27,30.44)
  BOTTOM w0.089: U7.G36 272.59,36.28 v1(272.22,36.65)
  BOTTOM w0.102: v7(69.63,31.33) 68.82,31.33 67.18,32.96 67.18,33.71 66.5,34.38 66.5,37.21 66.66,37.36 DV18.2 66.66,39.06 66.97,39.37 67.65,39.37 v2(67.85,39.57)
EDP_PWM: length 211
  IN4 w0.089: v6(270.44,36.75) 270.38,36.69 268.37,36.69 267.76,37.29 266.48,37.29 264.34,39.44 259.65,39.44 258.89,40.2 258.25,40.2 257.3,39.25 252.47,39.25 250.57,37.34 250.57,29.5 244.64,23.57 235.37,23.57 234.86,24.08 234.1,24.08 233.59,23.57 211.51,23.57 208.51,20.57 205.13,20.57 201.95,17.39 200.86,17.39 200.03,16.55 197.75,16.55 196.83,15.62 195.07,15.62 194.4,14.95 180.15,14.95 179.68,14.48 178.69,14.48 178.12,15.05 174.74,15.05 173.76,14.08 170.51,14.08 169.81,14.78 167.93,14.78 167.41,14.26 164.83,14.26 164.66,14.44 164.12,14.44 163.73,14.05 159.42,14.05 157.54,15.93 155.86,15.93 154.22,17.56 149.63,17.56 149.14,17.08 147.82,17.08 147.38,17.51 145.79,17.51 144.65,18.65 142.58,18.65 142.01,19.22 126.99,19.22 126.59,19.62 123.84,19.62 123.39,19.16 117.1,19.16 116.75,19.52 110.27,19.52 99.97,29.82 87.75,29.82 v1(87.2,29.27)
  GND3 w0.089: v7(270.02,36.56) 270.25,36.56 v6(270.44,36.75)
  BOTTOM w0.102: v1(87.2,29.27) DV10.2
EDP_TXN0: length 134
  IN4 w0.089: v6(171.35,102.79) 170.84,102.79 170.75,102.89 170.75,105.24 170.41,105.57 170.41,106.21 167.87,108.74 146.71,108.74 145.83,107.86 143.45,107.86 142.3,106.71 141.11,106.71 139.17,104.77 139.17,104.21 138.14,103.19 137.46,103.19 136.01,101.73 135.89,101.73 135.26,102.36 134.93,102.36 134.69,102.12 134.69,101.79 135.31,101.16 135.31,101.04 135.12,100.85 135,100.85 134.4,101.45 134.12,101.45 133.83,101.15 133.83,100.87 134.42,100.27 134.42,100.15 134.24,99.96 134.11,99.96 133.51,100.56 133.24,100.56 132.94,100.26 132.94,99.98 133.54,99.39 133.54,99.26 132.83,98.55 131.16,98.55 128.15,95.54 128.15,67.1 118.18,57.13 114.4,57.13 112.63,55.36 112.63,53.86 111.62,52.85 111.62,52.5 v1(111.48,52.36)
  GND3 w0.089: v6(171.35,102.79) 171.06,102.79 v7(170.96,102.89)
  BOTTOM w0.089: U6.C14 171.31,103.24 v7(170.96,102.89)
  BOTTOM w0.102: CH25.1 101.36,37.47 101.79,37.47 104.69,40.38 104.69,47 107.83,50.14 110.09,50.14 111.86,51.91 111.86,51.99 111.49,52.36 v1(111.48,52.36)
EDP_TXN0_C: length 1.1
  BOTTOM w0.102: LV16.4 99.78,37.7 CH25.2
EDP_TXN0_R: length 14.9
  BOTTOM w0.102: JEDP1.12 86.55,40.35 86.4,40.2 86.4,39.33 87.17,38.57 90.45,38.57 92.88,36.13 v9(95.34,36.13) 95.81,36.13 97.04,37.36 97.18,37.36 97.52,37.7 LV16.3
EDP_TXN1: length 132.2
  IN4 w0.089: v1(110.02,51.92) 110.27,51.92 110.36,51.83 110.36,51.6 110.28,51.52 109.85,51.52 109.64,51.3 109.56,51.3 109.4,51.46 109.4,55.33 112.97,58.91 115.05,58.91 126.37,70.23 126.37,99.3 134.27,107.2 136.71,107.2 136.97,106.94 138.49,106.94 139.21,107.66 139.21,108.59 140.88,110.27 144.97,110.27 145.22,110.52 168.7,110.52 172.74,106.48 172.74,104.8 172.6,104.65 172.5,104.65 172.25,104.9 v6(172.25,104.91)
  GND3 w0.089: v7(171.86,105.01) 172.15,105.01 v6(172.25,104.91)
  BOTTOM w0.089: U6.A12 v7(171.86,105.01)
  BOTTOM w0.102: v1(110.02,51.92) 109.72,51.63 108.34,51.63 103.99,47.28 103.99,41.81 101.61,39.43 101.24,39.43 CH32.1
EDP_TXN1_C: length 1.1
  BOTTOM w0.102: LV17.4 99.82,39.6 CH32.2
EDP_TXN1_R: length 13.9
  BOTTOM w0.102: LV17.3 97.52,39.6 97.26,39.34 97,39.34 v9(96.75,39.09) 96.46,38.8 96.46,37.97 96.15,37.65 96.11,37.65 95.7,37.25 95.7,37.21 95.4,36.9 93.09,36.9 90.73,39.26 88.11,39.26 87.9,39.46 87.9,40.2 88.05,40.35 JEDP1.9
EDP_TXN2: length 129.1
  IN4 w0.089: v6(172.22,103.47) 172.09,103.35 171.98,103.35 171.89,103.44 171.89,103.83 171.94,103.87 171.94,106.62 168.51,110.05 145.42,110.05 145.17,109.8 141.24,109.8 139.81,108.37 139.81,107.38 138.74,106.31 134.04,106.31 126.84,99.11 126.84,67.64 117.64,58.44 113.23,58.44 110.27,55.47 110.27,54.06 110.5,53.83 110.5,53.59 110.43,53.52 110.25,53.52 v1(110.04,53.72)
  GND3 w0.089: v6(172.22,103.47) 171.93,103.47 v7(171.83,103.58)
  BOTTOM w0.089: v7(171.83,103.58) 171.83,103.58 171.96,103.58 172.23,103.3 U6.C12
  BOTTOM w0.102: CH40.1 101.24,41.33 101.92,41.33 103.3,42.7 103.3,47.56 109.27,53.54 109.86,53.54 v1(110.04,53.72)
EDP_TXN2_C: length 1.1
  BOTTOM w0.102: CH40.2 99.75,41.43 LV19.4
EDP_TXN2_R: length 9.9
  BOTTOM w0.102: JEDP1.6 89.55,40.34 89.4,40.2 89.4,40.09 89.54,39.95 92.2,39.95 93.48,41.23 v9(96.35,41.23) 96.89,41.23 97.03,41.09 97.2,41.09 97.54,41.43 LV19.3
EDP_TXN3: length 128.9
  IN4 w0.089: v6(171.46,104.94) 171.26,104.94 171.13,105.06 171.13,106.5 168.24,109.4 145.88,109.4 145.63,109.15 143.76,109.15 142.35,107.73 141.19,107.73 138.54,105.09 137.06,105.09 135.64,103.67 134.93,103.67 134.07,104.52 133.74,104.52 133.5,104.28 133.5,103.95 134.29,103.15 134.29,102.97 134.16,102.84 133.98,102.84 133.16,103.65 132.83,103.65 132.59,103.41 132.59,103.08 133.3,102.37 133.3,102.25 132.61,101.57 131.63,100.58 130.61,99.56 130.61,98.96 127.5,95.85 127.5,67.37 117.91,57.78 113.57,57.78 110.97,55.18 110.97,54.3 111.14,54.13 111.6,54.13 v1(111.63,54.09)
  GND3 w0.089: v7(171.07,105.04) 171.17,104.94 v6(171.46,104.94)
  BOTTOM w0.089: v7(171.07,105.04) 171.42,104.68 U6.A14
  BOTTOM w0.102: v1(111.63,54.09) 111.33,54.39 110.79,54.39 110.21,54.97 109.29,54.97 108.88,54.56 108.88,53.83 102.8,47.75 102.8,44.14 101.7,43.03 101.24,43.03 CH42.1
EDP_TXN3_C: length 1
  BOTTOM w0.102: LV20.1 99.89,42.79 CH42.2
EDP_TXN3_R: length 8.8
  BOTTOM w0.102: LV20.2 97.52,42.79 97.18,43.13 96.32,43.13 96.16,43.3 v9(95.74,43.3) 94.91,43.3 93.91,42.3 92.72,42.3 92.7,42.27 92.14,42.27 92.11,42.3 91.41,42.3 90.9,41.79 90.9,41.69 91.05,41.54 JEDP1.3
EDP_TXP0: length 134
  IN4 w0.089: v1(112.07,52.36) 112.05,52.36 111.8,52.6 111.8,52.77 112.82,53.78 112.82,55.28 114.48,56.95 118.26,56.95 128.33,67.02 128.33,95.46 131.24,98.37 132.9,98.37 133.72,99.19 133.72,99.46 133.12,100.06 133.12,100.19 133.31,100.37 133.44,100.37 134.03,99.78 134.31,99.78 134.61,100.07 134.61,100.35 134.01,100.95 134.01,101.07 134.2,101.26 134.32,101.26 134.92,100.66 135.2,100.66 135.5,100.96 135.5,101.24 134.87,101.86 134.87,102.04 135.01,102.18 135.19,102.18 135.81,101.55 136.09,101.55 137.54,103 138.22,103 139.35,104.14 139.35,104.69 141.18,106.53 142.38,106.53 143.53,107.68 145.91,107.68 146.79,108.56 167.79,108.56 170.22,106.13 170.22,105.5 170.56,105.16 170.56,102.81 170.77,102.61 171.11,102.61 171.35,102.37 v6(171.35,102.36)
  GND3 w0.089: v6(171.35,102.36) 171.13,102.36 v7(170.96,102.19)
  BOTTOM w0.089: v7(170.96,102.19) 171.31,102.54 U6.D14
  BOTTOM w0.102: v1(112.07,52.36) 112.07,51.82 110.18,49.94 107.92,49.94 104.9,46.92 104.9,40.29 101.87,37.26 101.15,37.26 CH23.1
EDP_TXP0_C: length 1
  BOTTOM w0.102: CH23.2 99.88,37.15 LV16.1
EDP_TXP0_R: length 15.1
  BOTTOM w0.102: LV16.2 97.12,37.15 95.9,35.93 95.64,35.93 95.62,35.9 95.03,35.9 95,35.93 92.79,35.93 90.36,38.36 87.08,38.36 86.19,39.25 86.19,40.2 86.05,40.35 JEDP1.13
EDP_TXP1: length 132.3
  IN4 w0.089: v1(110.02,51.12) 109.48,51.12 109.22,51.38 109.22,55.41 112.89,59.09 114.97,59.09 126.19,70.31 126.19,99.38 134.19,107.38 136.79,107.38 137.04,107.12 138.42,107.12 139.03,107.73 139.03,108.67 140.81,110.45 144.9,110.45 145.15,110.7 168.78,110.7 172.92,106.56 172.92,104.72 172.67,104.47 172.26,104.47 v6(172.25,104.48)
  GND3 w0.089: v6(172.25,104.48) 172.07,104.48 v7(171.86,104.27)
  BOTTOM w0.089: v7(171.86,104.27) 171.9,104.27 U6.B12
  BOTTOM w0.102: v1(110.02,51.12) 109.72,51.42 108.42,51.42 104.2,47.2 104.2,41.73 101.69,39.22 101.24,39.22 CH29.1
EDP_TXP1_C: length 1.1
  BOTTOM w0.102: LV17.1 99.81,39.05 CH29.2
EDP_TXP1_R: length 14.2
  BOTTOM w0.102: LV17.2 97.49,39.05 97.41,39.14 97.13,39.14 96.67,38.68 96.67,37.88 v9(96.08,37.29) 95.48,36.69 93,36.69 90.65,39.05 88.02,39.05 87.69,39.38 87.69,40.2 87.55,40.35 JEDP1.10
EDP_TXP2: length 129.1
  IN4 w0.089: v6(172.22,103.04) 172.09,103.17 171.91,103.17 171.71,103.36 171.71,103.91 171.75,103.95 171.75,106.54 168.43,109.87 145.49,109.87 145.24,109.61 141.32,109.61 139.99,108.29 139.99,107.3 138.82,106.12 134.12,106.12 127.03,99.03 127.03,67.56 117.72,58.25 113.31,58.25 110.45,55.4 110.45,54.14 110.68,53.91 110.68,53.52 110.5,53.33 110.24,53.33 v1(110.04,53.14)
  GND3 w0.089: v6(172.22,103.04) 171.93,103.04 v7(171.83,102.94)
  BOTTOM w0.089: U6.D12 172.23,102.54 v7(171.83,102.94)
  BOTTOM w0.102: v1(110.04,53.14) 109.86,53.33 109.36,53.33 103.5,47.48 103.5,42.62 102.01,41.12 101.24,41.12 CH31.1
EDP_TXP2_C: length 1
  BOTTOM w0.102: CH31.2 99.89,40.88 LV19.1
EDP_TXP2_R: length 10.2
  BOTTOM w0.102: JEDP1.7 89.05,40.35 89.19,40.2 89.19,40 89.45,39.74 92.29,39.74 93.57,41.02 96.05,41.02 96.07,41 96.63,41 96.65,41.02 96.81,41.02 96.95,40.88 LV19.2
EDP_TXP3: length 129
  IN4 w0.089: v6(171.46,104.5) 171.46,104.51 171.22,104.75 171.18,104.75 170.95,104.99 170.95,106.43 168.16,109.21 145.96,109.21 145.71,108.96 143.84,108.96 142.43,107.55 141.27,107.55 138.62,104.9 137.14,104.9 135.72,103.48 134.85,103.48 134,104.34 133.82,104.34 133.68,104.2 133.68,104.02 134.48,103.23 134.48,102.9 134.23,102.66 133.9,102.66 133.09,103.47 132.91,103.47 132.77,103.34 132.77,103.16 133.48,102.45 133.48,102.17 130.79,99.48 130.79,98.88 127.68,95.77 127.68,67.29 117.99,57.6 113.65,57.6 111.15,55.1 111.15,54.37 111.21,54.31 111.28,54.31 111.47,54.5 111.61,54.5 111.67,54.56 111.67,54.79 v1(111.62,54.84)
  GND3 w0.089: v7(171,104.27) 171.23,104.5 v6(171.46,104.5)
  BOTTOM w0.089: v7(171,104.27) 171.34,103.94 U6.B14
  BOTTOM w0.102: CH41.1 101.24,43.24 101.61,43.24 102.6,44.23 102.6,47.84 108.67,53.92 108.67,54.65 109.21,55.18 110.3,55.18 110.88,54.6 111.38,54.6 v1(111.62,54.84)
EDP_TXP3_C: length 1.1
  BOTTOM w0.102: CH41.2 99.74,43.34 LV20.4
EDP_TXP3_R: length 9
  BOTTOM w0.102: JEDP1.4 90.55,41.54 90.69,41.69 90.69,41.94 91.26,42.51 v9(92.42,42.51) 93.83,42.51 94.83,43.51 95.41,43.51 95.43,43.53 96.04,43.53 96.06,43.51 96.24,43.51 96.41,43.34 LV20.3
EN_+V1.05V: length 4.5
  BOTTOM w0.102: PR503.2 228.41,67.85 228.03,68.23 226.76,68.23 226.22,67.7 226.22,67.42 v2(226.33,67.32)
  BOTTOM w0.254: PR503.2 228.53,67.89 PU500.3
EN_CAM: length 1.6
  BOTTOM w0.089: T8.1 276.72,25.68 U7.A10
EN_WLANPWR#: length 128.8
  TOP w0.089: UE1.F4 164.2,16.08 164.2,15.6 164.53,15.26 164.53,14.5 164.69,14.34 164.69,13.95 v3(164.53,13.79)
  GND1 w0.076: v3(164.53,13.79) 164.76,13.79 v4(164.95,13.6)
  IN2 w0.102: v4(164.95,13.6) 165.04,13.5 165.68,13.5 165.86,13.32 166.37,13.32 167.12,12.56 171.4,12.56 172.31,13.48 183.73,13.48 185.48,15.24 187.58,15.24 187.85,15.5 198.47,15.5 199.23,14.74 204.54,14.74 205.67,15.86 207.71,15.86 208.13,15.45 211.01,15.45 213.22,17.66 220.61,17.66 224.19,14.08 224.8,14.08 225.59,13.28 226.82,13.28 227.59,14.05 228.66,14.05 229.25,13.46 233.07,13.46 234.6,14.99 241.38,14.99 241.91,14.46 243.52,14.46 243.69,14.3 254.1,14.3 255.03,13.37 258.7,13.37 258.88,13.55 263.98,13.55 264.9,12.63 266.79,12.63 267.17,13 269.87,13 270.72,12.15 271.36,12.15 v4(271.74,12.53)
  IN4 w0.102: v4(271.74,12.53) 271.23,13.04 269.2,13.04 268.54,12.38 v6(265.29,12.38)
  GND3 w0.102: v6(265.29,12.38) 264.83,11.92 v7(264.83,11.87)
  BOTTOM w0.102: v7(264.83,11.87) 264.83,11.63 265.7,10.76 JTB1.28
ENBKL: length 196.2
  TOP w0.089: RH138.2 271.14,38.1 271.14,37.17 v2(271.26,37.05) v1(271.66,36.66)
  IN2 w0.089: 268.89,42.2 268.89,42.12 268.9,42.11 268.9,42.04 268.92,42.03 268.92,41.7 269.3,41.31 269.3,39.65 269.63,39.33 269.63,37.8 270.78,36.66 v1(271.66,36.66)
  IN2 w0.102: v1(253.89,43.13) 254.36,43.6 261.09,43.6 261.48,43.21 264.19,43.21 265.11,44.13 267.91,44.13 268.89,43.15 268.89,42.2
  BOTTOM w0.089: U7.K36 271.39,36.4 v1(271.66,36.66)
  BOTTOM w0.102: RV11.1 92.62,32.6 RE469.2 93.97,33.94 104.15,33.94 108.82,38.62 114.41,38.62 121.23,45.44 161.12,45.44 162.03,46.34 234.59,46.34 235.94,44.99 252.02,44.99 v1(253.89,43.13)
ESB_CLK: length 33.6
  TOP w0.089: UE1.N7 168.02,17.66 168.07,17.71 168.34,17.71
  TOP w0.102: RPE2.6 174.55,16.83 v1(173.91,16.19) ; 168.34,17.71 168.36,17.69 169.32,17.69 169.62,17.98 v3(169.62,18) ; v3(149.44,17.74) 149.26,17.55 UE36.1
  GND1 w0.102: v4(148.71,18.02) 148.78,17.95 149.24,17.95 v3(149.44,17.74) ; v3(169.62,18) v4(170.03,18)
  IN3 w0.102: v1(173.91,16.19) 173.25,16.85 171.4,16.85 170.25,18 v4(170.03,18)
  IN4 w0.102: v4(148.71,18.02) 149.23,18.55 156.26,18.55 158.7,16.1 160.46,16.1 160.59,15.98 162.97,15.98 163.45,16.45 167.19,16.45 167.74,17 168.57,17 169.57,18 v4(170.03,18)
ESB_DAT: length 43.6
  TOP w0.089: 168.56,17.48 168.06,17.48 167.99,17.41 167.53,17.41 UE1.M7
  TOP w0.102: 168.56,17.48 169.56,17.48 169.73,17.66 170.34,17.66 170.85,18.17 171.59,18.17 172.43,17.33 174.06,17.33 174.07,17.33 RPE2.5 175.37,17.33 175.51,17.47 175.51,20.07 v3(175.13,20.45) ; UE36.4 150.36,19.05 150.94,19.63 150.94,20.27 v2(151.92,21.26) 152.85,22.18 153.96,22.18 156.46,24.68 v1(156.46,24.73)
  GND1 w0.102: v4(174.88,20.77) 175.13,20.52 v3(175.13,20.45)
  IN2 w0.102: v1(156.46,24.73) 157.63,23.57 167.76,23.57 169.25,22.08 174.26,22.08 174.88,21.46 v4(174.88,20.77)
FAN_TEMP0: length 323.8
  TOP w0.102: v2(136.94,87.5) 137.46,86.98 v1(137.74,86.98) ; v1(161.29,24.73) 161.19,24.63 161.19,21.25 UE1.A13
  IN1 w0.102: v1(161.29,24.73) 160.31,24.73 158.41,26.64 158.41,30.49 157.46,31.44 153.63,31.44 149.5,35.57 149.5,50.85 138.52,61.83 138.52,65.14 138.15,65.51 138.15,86.57 v1(137.74,86.98)
  IN2 w0.102: v4(265.67,49.16) 263.14,51.68 263.14,53.11 260.59,55.66 260.59,56.76 255.97,61.39 255.97,76.03 255.28,76.72 255.28,77.88 255.98,78.58 255.98,98.75 255.32,99.41 255.32,103.87 254.48,104.71 254.48,113.04 252.44,115.08 250.75,115.08 248.51,117.32 248.51,122.26 v1(250.04,123.79) ; v1(161.29,24.73) 161.84,24.18 168.01,24.18 169.46,22.73 177.21,22.73 177.38,22.91 177.87,22.91 178.73,22.05 181.74,22.05 183.32,20.47 187.16,20.47 189.53,22.84 197.26,22.84 198.43,24.01 227.86,24.01 227.96,24.11 229.55,24.11 230.03,23.63 233.23,23.63 233.85,24.25 234.97,24.25 237.9,21.32 242.29,21.32 242.56,21.58 253.04,21.58 254.23,20.4 254.56,20.4 254.57,20.39 261.19,20.39 261.76,20.97 261.76,21.93 262.53,22.7 262.53,26.42 262.03,26.91 255.73,26.91 254.65,28 254.65,30.97 254.01,31.61 254.01,33.49 252.56,34.93 v4(252.56,46.62)
  IN4 w0.102: v4(252.56,46.62) 254.36,46.62 255.59,47.85 258.77,47.85 260.06,49.14 265.66,49.14 v4(265.67,49.16)
  BOTTOM w0.102: v1(250.04,123.79) RT4.1 251.21,122.61 254.16,122.61 HT5.1
FAN_TEMP1: length 147.6
  TOP w0.089: v3(161.34,17.27) 161.48,17.41 162.03,17.41 UE1.B7
  GND1 w0.076: v5(161.09,17.62) 161.34,17.37 v3(161.34,17.27)
  IN1 w0.102: v5(161.09,17.62) 160.97,17.74 160.97,19.59 160.27,20.29 155.93,20.29 155.01,19.38 149.83,19.38 149.13,20.08 149.13,21.98 147.91,23.2 147.91,25.7 146.06,27.55 146.06,44.15 135.62,54.59 135.62,76.87 136.22,77.47 136.22,85.08 135.61,85.69 135.61,88.93 v1(135.19,89.35)
  IN2 w0.102: v1(127.39,124.68) 128.38,124.68 133.09,119.96 133.09,114.05 133.89,113.25 133.89,100.26 135.19,98.96 v1(135.19,89.35)
  BOTTOM w0.102: HT6.1 112.51,122.56 115.4,122.56 RT2.1 117.52,124.68 v2(119.8,124.68) v1(127.39,124.68)
FB: length 6.5
  BOTTOM w0.203: PU700.8 126,118.77 126.67,119.44 127.66,119.44 127.95,119.73 ; 127.95,119.73 v2(127.95,119.72) ; 127.95,119.73 128.15,119.93 128.15,120.37 PR732.1
  BOTTOM w0.254: PR733.1 PR732.1 PR738.1
FB2/VSEN: length 4
  TOP w0.102: v1(126.96,118.71) 126.96,119.13 127.1,119.27 127.57,119.27 v2(127.87,119.58)
  TOP w0.254: PR728.2 126.96,118.71 v1(126.96,118.71)
  BOTTOM w0.203: v1(126.96,118.71) 127.27,118.41 127.27,117.79 127.1,117.62 PU700.9
FB_3V: length 4.5
  TOP w0.102: v2(46.21,36.09) 46.38,36.26 PR300.2
  TOP w0.203: PU300.4 48.37,35.07
  TOP w0.254: PR300.2 PC301.2 48.12,36.21 PR302.2 48.37,35.07
FB_5V: length 6.5
  TOP w0.102: PR301.1 52.84,36.74 v2(53.47,36.74)
  TOP w0.203: 50.09,35.43 49.17,34.51 PU300.2
  TOP w0.254: 50.09,35.43 51.42,35.43 PR304.1 51.52,36.21 PC302.1 PR301.1
FB_+V1.05V: length 4.6
  BOTTOM w0.102: v2(225.51,68.38) 225.83,68.7 PR508.1
  BOTTOM w0.254: PR508.1 PC510.1 PR507.1 228.78,68.39 PU500.4
FB_CLAMP: length 154.4
  TOP w0.102: QZ25.3 245.29,53.74 244.86,54.17 DZ2.3 244.52,55.43 v1(244.16,55.06) ; v1(152.56,22.66) 150.42,20.52 149.96,20.52 v2(149.96,20.1) 149.96,19.74 149.77,19.55 UE36.5
  IN2 w0.102: v1(230.57,73.22) 229.96,73.83 224.17,73.83 223.95,73.62 222.58,73.62 222.37,73.83 214.22,73.83 v1(213.49,73.1)
  IN3 w0.102: v1(230.57,73.22) 230.57,64.52 237.49,57.6 241.62,57.6 v1(244.16,55.06)
  IN4 w0.102: v1(152.56,22.66) 154.23,24.33 177.04,24.33 179.49,26.78 179.49,30.21 180.78,31.5 182.08,31.5 182.59,32.01 182.59,38.9 186.88,43.2 201.74,43.2 205.99,47.45 205.99,62.43 209.68,66.11 209.68,70.03 212.74,73.1 v1(213.49,73.1)
  BOTTOM w0.102: RV8.1 v1(230.57,73.22) ; RV505.2 v1(213.49,73.1)
FB_CLAMP_MON: length 53.9
  TOP w0.102: v1(242.76,60.59) v2(242.76,58.38) RZ472.2 242.3,56.33 242.3,53.64 243.17,52.78 QZ25.1
  BOTTOM w0.102: RV503.2 214.67,73.55 214.67,72.43 214.17,71.94 214.17,68.16 215.04,67.29 215.04,62.59 216.9,60.73 220.99,60.73 222.06,61.79 223.9,61.79 226.67,64.56 230.67,64.56 234.5,60.73 241.53,60.73 241.9,60.36 242.54,60.36 v1(242.76,60.59)
FB_CLAMP_MON_R: length 11.8
  BOTTOM w0.089: UV1.P6 219.2,82.13 218.81,81.74 218.81,81.3 218.55,81.04 218.32,81.04 218.08,80.8 218.08,78.65 217.84,78.41 217.84,77.32
  BOTTOM w0.102: 217.84,77.32 217.84,76.72 217.41,76.29 v2(215.89,76.29) 215.28,76.29 214.37,75.38 RV503.1 RV505.1
FB_CLAMP_REQ#: length 98.9
  TOP w0.102: v1(214.34,52.45) 214.73,52.84 v2(218.48,52.84) 220.03,52.84 220.68,53.49 QV42.3 ; UE36.10 146.43,21.6 146.75,21.92 146.75,22.82 RE33.1 146.56,23.53 153.61,23.53 155.91,25.83 158.96,25.83 159.83,26.7 170.29,26.7 172.22,24.76 175.09,24.76 176.57,26.23 181.14,26.23 v1(181.51,26.6)
  IN4 w0.102: v1(214.34,52.45) 204.68,42.79 187.78,42.79 184.31,39.33 184.31,35.57 182.99,34.25 182.99,28.09 v1(181.51,26.6)
FB_CLAMP_REQ#_Q: length 28.9
  TOP w0.102: v1(222.25,62.24) 221.8,61.79 221.8,60.14 v2(221.45,59.79) 220.68,59.01 QV42.4
  IN4 w0.089: 221.78,77.32 221.61,77.48 221.61,80.97 221.74,81.1 221.74,82.65 v4(221.7,82.68)
  IN4 w0.102: v1(222.25,62.24) 222.57,62.56 222.57,67.37 221.78,68.16 221.78,77.32
  GND3 w0.089: v7(221.3,82.68) v4(221.7,82.68)
  BOTTOM w0.089: UV1.M7 220.9,83.08 v7(221.3,82.68)
  BOTTOM w0.102: v1(222.25,62.24) 221.91,62.57 RPH32.3
FBA_CMD0: length 37.1
  BOTTOM w0.127: UV1.U30 216.34,102.76 216.34,103.39 216.6,103.64 216.85,103.64 217.13,103.92 217.13,105.13 217.44,105.44 217.44,105.82 217.66,106.05 217.66,107.3 217.81,107.44 217.81,107.63 218.93,108.76 218.93,111.51 217.97,112.48 v2(216.27,112.48) 213.32,112.48 212.01,113.79 212.01,120.07 213.42,121.48 218.79,121.48 219.04,121.72 219.82,121.72 220.66,122.56 220.66,123.81 220.95,124.1 221.53,124.1 UV5.G12
FBA_CMD1: length 33.6
  BOTTOM w0.127: UV1.T31 217.55,103.26 217.99,103.7 217.99,104.09 218.17,104.27 218.17,104.53 217.97,104.73 217.97,105.03 217.77,105.24 217.77,105.85 218.05,106.13 218.05,106.97 218.3,107.23 218.3,107.59 219.39,108.68 v2(219.39,109.53) 219.39,111.67 218.17,112.89 213.46,112.89 212.39,113.95 212.39,119.91 213.68,121.19 219.01,121.19 219.21,121.39 219.9,121.39 221.1,122.6 UV5.H10
FBA_CMD2: length 33.3
  TOP w0.127: v1(220.09,120.09) 219.95,120.23 218.81,120.23 218.57,120.47 213.3,120.47 212.66,119.83 212.66,113.23 217.7,108.19 217.7,107.5 216.31,106.11 v2(216.31,102.9) v1(216.31,101.93)
  IN1 w0.089: v1(220.09,120.09) 220.09,121.86 v1(221.49,123.26)
  BOTTOM w0.089: v1(221.49,123.26) 221.1,123.65 UV5.H11
  BOTTOM w0.102: UV1.U29 216.69,101.55 v1(216.31,101.93)
FBA_CMD3: length 33.1
  TOP w0.089: v1(221.27,121.5) 221.22,121.5 220.6,122.12 v1(219.45,122.12)
  BOTTOM w0.089: v1(219.45,122.12) 219.07,122.5 219.07,123.24 UV5.K11
  BOTTOM w0.127: UV1.R34 218.85,106.05 218.85,106.67 219.2,107.02 219.2,107.39 220.16,108.36 v2(220.16,111.29) 220.16,112.19 218.46,113.89 213.96,113.89 213.16,114.7 213.16,119.58 214.03,120.45 219.49,120.45 219.8,120.76 220.31,120.76 221.04,121.5 v1(221.27,121.5)
FBA_CMD4: length 32.8
  TOP w0.089: v1(219.89,122.5) v2(220.43,122.5) 220.9,122.5 221.17,122.23 v1(221.17,122.08)
  BOTTOM w0.089: UV5.K10 219.52,122.87 v1(219.89,122.5)
  BOTTOM w0.127: UV1.R33 218.4,104.98 218.05,105.34 218.05,105.8 218.43,106.18 218.43,106.81 218.81,107.2 218.81,107.55 219.78,108.52 219.78,111.91 218.29,113.4 213.78,113.4 212.78,114.41 212.78,119.74 213.87,120.84 219.47,120.84 219.7,121.06 220.15,121.06 v1(221.17,122.08)
FBA_CMD5: length 34.4
  BOTTOM w0.089: 218.06,122 218.31,122.25 218.31,124.08 UV5.L12
  BOTTOM w0.127: 218.06,122 213.39,122 211.63,120.24 211.63,113.63 213.27,112 v2(214.18,112) 217.91,112 218.55,111.35 218.55,109.66 218.25,109.35 216.18,109.35 215.83,109.01 215.83,107.7 216.3,107.23 216.3,105.93 216.29,105.92 216.29,104.41 UV1.U32
FBA_CMD6: length 31.3
  TOP w0.089: 220.91,120.06 220.91,119.41 220.39,118.89 219.46,118.89 219.15,118.59 v1(219.15,118.47)
  TOP w0.127: 220.91,120.06 220.91,120.4 220.41,120.91 219.21,120.91 218.9,121.23 212.79,121.23 211.9,120.34 v2(211.9,116.44) 211.9,112.86 v1(216.9,107.86)
  BOTTOM w0.089: v1(219.15,118.47) 219.5,118.13 UV5.K4 ; 216.9,105.26 216.7,105.06 UV1.U33 ; 217.1,105.46 217.1,106.53
  BOTTOM w0.102: 216.9,105.26 217.1,105.46
  BOTTOM w0.127: 217.1,106.53 217.1,107.37 217.1,107.37 217.1,107.65 v1(216.9,107.86)
FBA_CMD7: length 33.7
  TOP w0.127: v1(219.2,119.55) 218.6,119.55 218.34,119.82 214.86,119.82 213.8,118.75 213.8,114.78 213.93,114.65 215.27,114.65 215.37,114.55 215.37,114.17 215.27,114.07 213.9,114.07 213.8,113.97 213.8,113.66 213.9,113.56 215.27,113.56 215.37,113.46 215.37,113.15 215.27,113.05 214.42,113.05 214.32,112.95 214.32,112.65 214.42,112.55 215.27,112.55 215.37,112.44 215.37,111.59 217.61,109.35 218.17,109.35 218.48,109.05 v2(218.48,108.19) 218.48,107.69 216.69,105.9 216.69,101.57 v1(216.29,101.17)
  BOTTOM w0.089: UV5.K5 219.5,118.96 219.2,119.26 v1(219.2,119.55)
  BOTTOM w0.102: v1(216.29,101.17) 216.7,100.75 UV1.U28
FBA_CMD8: length 33
  TOP w0.127: v1(220.7,117.66) 221.25,117.12 221.25,115.78 220.62,115.16 220.62,114.59 220.75,114.46 221.91,114.46 222.03,114.33 222.03,114.08 221.91,113.95 220.75,113.95 220.62,113.83 220.62,113.57 220.75,113.44 221.87,113.44 222,113.32 222,113.06 221.87,112.94 220.75,112.94 220.62,112.81 220.62,112.56 220.75,112.43 221.98,112.43 222.11,112.3 222.11,112.05 221.98,111.92 220.75,111.92 220.62,111.79 220.62,111.54 220.75,111.41 222.02,111.41 222.15,111.29 222.15,111.03 222.02,110.9 220.75,110.9 220.62,110.78 220.62,110.52 220.75,110.4 221.19,110.4 221.32,110.27 221.32,110.02 221.19,109.89 220.75,109.89 220.62,109.76 220.62,109.08 v2(217.19,105.64) 216.9,105.36 216.9,101.48 216.72,101.3 216.72,100.97 216.54,100.79 215.96,100.79 v1(215.46,100.29)
  BOTTOM w0.102: v1(215.46,100.29) 215.47,100.29 215.88,100.7 UV1.V28
  BOTTOM w0.132: UV5.J4 220.3,118.06 v1(220.7,117.66)
FBA_CMD9: length 38.6
  TOP w0.089: v1(219.89,118.44) 220.27,118.05 221.11,118.05 221.52,118.47 221.52,120.34
  TOP w0.127: v1(215.45,101.12) 215.04,101.54 215.04,102.19 214.86,102.37 v2(214.86,107.15) 214.86,108.82 211.14,112.54 211.14,120.68 212.71,122.25 213.92,122.25 214.31,121.86 219.05,121.86 219.34,121.57 220.63,121.57 221.52,120.68 221.52,120.34
  BOTTOM w0.089: UV5.J5 220.3,118.85 v1(219.89,118.44)
  BOTTOM w0.102: UV1.V29 215.58,101.55 215.45,101.43 v1(215.45,101.12)
FBA_CMD10: length 34.7
  TOP w0.089: v1(220.72,118.5) 221.23,119 221.23,120.24
  TOP w0.127: v1(215.45,101.96) 215.45,102.28 215.07,102.67 215.07,103.8 215.33,104.06 v2(215.33,104.4) 215.33,108.89 211.52,112.7 211.52,120.51 212.85,121.85 213.92,121.85 214.22,121.55 218.97,121.55 219.28,121.24 220.53,121.24 221.23,120.55 221.23,120.24
  BOTTOM w0.089: UV5.H4 221.1,118.12 v1(220.72,118.5)
  BOTTOM w0.102: v1(215.45,101.96) 215.89,102.4 UV1.V30
FBA_CMD11: length 26.2
  TOP w0.127: v1(218.06,108.88) 217.55,108.88 213.42,113.01 v2(213.42,114.41) 213.42,118.93 214.67,120.18 218.41,120.18 218.64,119.95 219.53,119.95 219.8,119.68 v1(219.8,119.51)
  BOTTOM w0.089: UV5.H5 221.1,119.2 220.92,119.38 219.93,119.38 v1(219.8,119.51) ; UV1.U34 216.7,106.53
  BOTTOM w0.127: 216.7,106.53 216.68,106.55 216.68,107.39 216.32,107.75 216.32,108.45 216.75,108.88 v1(218.06,108.88)
FBA_CMD12: length 36
  BOTTOM w0.127: UV5.G3 221.49,117.68 221.49,119.64 220.65,120.48 219.92,120.48 219.48,120.03 214.16,120.03 213.54,119.41 213.54,114.95 214.15,114.35 218.72,114.35 v2(219.06,114) 220.55,112.51 220.55,108.2 219.59,107.23 219.59,106.85 219.24,106.51 219.24,106.13 218.82,105.71 218.82,103.85 218.55,103.59 218.26,103.59 217.93,103.26 217.93,102.94 217.8,102.81 217.09,102.81 UV1.U31
FBA_CMD13: length 32.2
  TOP w0.127: v1(217.97,109.77) 220.12,109.77 220.24,109.9 220.24,110.43 220.12,110.56 218.54,110.56 218.41,110.69 218.41,111.22 218.54,111.35 220.08,111.35 220.24,111.51 220.24,112.14 220.12,112.26 v2(219.19,112.26) 217.59,112.26 217.46,112.39 217.46,112.83 217.59,112.96 220.12,112.96 220.24,113.09 220.24,115.62 v1(220.67,116.06)
  BOTTOM w0.089: v1(220.67,116.06) 220.67,115.25 221.05,114.87 221.05,114.75
  BOTTOM w0.127: RV341.1 222.87,112.54 221.05,114.36 221.05,114.75 ; UV1.V34 215.9,106.23 215.92,106.25 215.92,107.07 215.12,107.87 215.12,110.96 215.23,111.07 215.56,111.07 215.66,110.96 215.66,109.88 215.76,109.77 v1(217.97,109.77)
  BOTTOM w0.132: v1(220.67,116.06) 220.3,116.43 UV5.J2
FBA_CMD14: length 32.4
  TOP w0.089: v1(219.86,116.87) 219.44,117.29 218.68,117.29 RV339.1
  TOP w0.127: v1(217.99,111.2) 216.31,111.2 215.75,111.75 215.75,113.53 215.85,113.63 216.33,113.63 216.43,113.53 v2(216.43,112.68) 216.43,112 216.55,111.87 216.93,111.87 217.05,112 217.05,113.51 217.16,113.61 219.76,113.61 219.86,113.71 v1(219.86,116.87)
  BOTTOM w0.089: v1(219.86,116.87) 220.26,117.27 UV5.J3
  BOTTOM w0.127: UV1.V33 215.9,104.99 215.54,105.36 215.54,106.92 214.74,107.71 214.74,111.25 214.94,111.45 215.94,111.45 216.04,111.34 216.04,110.26 216.14,110.15 216.45,110.15 216.55,110.26 216.55,111.34 216.65,111.45 216.95,111.45 217.06,111.34 217.06,110.26 217.16,110.15 217.46,110.15 217.56,110.26 217.56,111.36 217.66,111.45 217.89,111.45 217.99,111.34 v1(217.99,111.2)
FBA_CMD15: length 35.4
  TOP w0.089: 220.53,120.05 220.53,119.51 220.15,119.13 219.2,119.13 218.76,118.69 218.76,118.05 219.09,117.72 v1(219.09,117.69)
  TOP w0.127: 220.53,120.05 220.53,120.34 220.32,120.56 219.11,120.56 218.88,120.78 213.08,120.78 212.28,119.99 v2(212.28,119.49) 212.28,113.07 217.31,108.03 217.31,107.66 215.77,106.12 215.77,103.3 215.45,102.98 v1(215.45,102.82)
  BOTTOM w0.089: v1(219.09,117.69) 218.7,117.3 UV5.L3
  BOTTOM w0.102: UV1.Y32 214.2,103.82 214.6,103.42 214.6,103.16 214.94,102.82 v1(215.45,102.82)
FBA_CMD16: length 44.5
  TOP w0.127: v1(203.47,124.1) 203.47,121.73 202.18,120.45 198.6,120.45 197.94,121.11 195.07,121.11 194.27,120.32 194.27,114.6 197.12,111.75 200.68,111.75 204.47,107.96 v2(209.05,107.96) 211.21,107.96 211.84,107.34 211.84,105.96 212.12,105.67 212.34,105.67 212.99,105.02 v1(212.99,103.59)
  BOTTOM w0.102: UV1.AA31 213.38,103.2 v1(212.99,103.59)
  BOTTOM w0.132: UV6.G12 203.84,124.47 v1(203.47,124.1)
FBA_CMD17: length 45.8
  TOP w0.127: v1(213.8,101.1) 213.29,101.61 212.85,101.61 212.58,101.87 212.58,103.84 211.45,104.97 211.45,107.17 211.05,107.58 v2(207.15,107.58) 204.31,107.58 200.54,111.34 196.95,111.34 193.85,114.44 193.85,120.44 194.93,121.52 200.23,121.52 200.66,121.09 202.39,121.09 202.72,121.42 202.72,122.09 v1(202.97,122.34)
  BOTTOM w0.089: v1(213.8,101.1) 213.8,101.17 213.4,101.58 UV1.AA29
  BOTTOM w0.132: UV6.H10 203.07,122.44 v1(202.97,122.34)
FBA_CMD18: length 47.4
  TOP w0.127: v1(202.69,124.09) 202.69,122.81 202.37,122.5 202.37,121.56 202.23,121.42 200.89,121.42 200.36,121.95 194.83,121.95 193.47,120.59 193.47,114.25 196.79,110.94 v2(199.25,110.94) 200.41,110.94 204.15,107.2 210.7,107.2 211.07,106.82 211.07,104.85 211.75,104.17 211.75,101.85 211.95,101.64 212.31,101.64 212.72,101.23 v1(212.85,101.23)
  BOTTOM w0.089: v1(212.85,101.23) 213.38,100.7 UV1.AA28
  BOTTOM w0.132: UV6.H11 203.07,123.71 v1(202.69,124.09)
FBA_CMD19: length 39.3
  BOTTOM w0.127: UV1.AC34 211.7,106.51 210.22,107.99 207.8,107.99 205.83,109.96 v2(203.97,109.96) 200.48,109.96 196.42,114.01 194.72,114.01 194.59,114.15 194.59,120.95 194.9,121.25 202.16,121.25 202.55,121.65 202.55,122.66 202.7,122.82 202.7,123.15 202.58,123.27 201.87,123.27
  BOTTOM w0.132: UV6.K11 201.87,123.27
FBA_CMD20: length 37.5
  BOTTOM w0.127: UV6.K10 201.47,122.6 201.11,122.24 201.11,121.9 200.85,121.64 194.74,121.64 194.18,121.09 194.18,113.99 194.54,113.63 196.27,113.63 v2(196.92,112.97) 200.32,109.58 205.66,109.58 207.64,107.61 210.03,107.61 211.31,106.33 211.31,105.44 211.7,105.05 UV1.AC33
FBA_CMD21: length 41.6
  BOTTOM w0.127: UV1.AA32 213.11,104 212.74,104.37 212.48,104.37 212.31,104.55 212,104.55 211.85,104.4 211.62,104.4 211.26,104.75 211.26,104.96 211.04,105.19 210.76,105.19 210.55,105.39 210.55,105.72 209.05,107.22 207.48,107.22 205.5,109.19 200.16,109.19 v2(198.04,111.32) 196.11,113.25 194.37,113.25 193.78,113.85 193.78,121.64 194.16,122.03 200.46,122.03 201.07,122.64 201.07,124.07 UV6.L12
FBA_CMD22: length 26.5
  BOTTOM w0.127: UV1.AA33 213.35,104.8 212.67,105.48 212.67,106.55 212.28,106.94 211.83,106.94 210.4,108.38 207.96,108.38 205.99,110.34 200.86,110.34 200.73,110.47 v2(200.73,111.89) 200.73,114.09 200.86,114.22 201.17,114.22 201.29,114.09 201.29,113.24 201.42,113.11 201.75,113.11 201.88,113.24 201.88,117.66 UV6.K4
FBA_CMD23: length 33.1
  TOP w0.127: v1(213.8,100.32) 213.8,100.49 214.24,100.92 214.24,102.21 214.48,102.45 214.48,108.66 210.75,112.38 210.75,120.12 210.03,120.84 v2(203.69,120.84) 203.3,120.84 201.84,119.39 v1(201.32,119.39)
  BOTTOM w0.089: UV1.Y28 214.18,100.7 v1(213.8,100.32)
  BOTTOM w0.132: UV6.K5 201.47,119.24 v1(201.32,119.39)
FBA_CMD24: length 33.4
  TOP w0.127: v1(202.67,118.45) 202.09,118.45 201.94,118.59 201.94,118.96 203.45,120.46 v2(206.39,120.46) 209.87,120.46 210.37,119.96 210.37,112.22 210.7,111.9 210.7,111.72 210.58,111.61 210.58,111.43 210.76,111.25 210.94,111.25 211.06,111.36 211.24,111.36 211.42,111.18 211.42,111 211.3,110.89 211.3,110.71 211.48,110.53 211.66,110.53 211.78,110.64 211.96,110.64 212.13,110.46 212.13,110.28 212.02,110.17 212.02,109.99 212.2,109.81 212.38,109.81 212.49,109.92 212.67,109.92 212.85,109.74 212.85,109.56 212.74,109.45 212.74,109.27 212.92,109.09 213.1,109.09 213.21,109.2 213.39,109.2 214,108.6 214,104.26 214.2,104.06 214.2,102.59 213.8,102.19 v1(213.8,101.93)
  BOTTOM w0.102: UV1.Y29 214.19,101.55 v1(213.8,101.93)
  BOTTOM w0.127: v1(202.67,118.45) 202.67,118.43 202.3,118.07 UV6.J4
FBA_CMD25: length 29
  BOTTOM w0.127: UV6.J5 202.27,119.73 203.59,121.05 209.19,121.05 210.87,119.37 210.87,113.32 v2(211.27,112.92) 213.87,110.32 213.87,107.51 214.72,106.66 214.72,106.15 214.87,106 214.87,105.31 214.64,105.08 214.64,104.75 214.37,104.49 214.37,104.31 214.57,104.12 214.57,103.99 215.05,103.51 UV1.W31
FBA_CMD26: length 32.7
  TOP w0.127: v1(213.82,102.8) 213.55,103.07 213.55,105.75 213.42,105.87 212.76,105.87 212.64,106 212.64,106.25 212.76,106.38 213.42,106.38 213.55,106.51 213.55,106.76 213.42,106.89 212.76,106.89 212.64,107.02 212.64,107.27 212.76,107.4 213.42,107.4 213.55,107.52 213.55,107.92 209.99,111.48 209.99,119.37 v2(209.46,119.9) 209.26,120.1 203.64,120.1 203.42,119.88 203.42,119.74 203.89,119.27 203.89,119.13 203.72,118.96 203.58,118.96 203.12,119.42 202.96,119.42 202.81,119.27 202.81,119.1 v1(203.47,118.44)
  BOTTOM w0.102: v1(213.82,102.8) 214.2,102.42 UV1.Y30
  BOTTOM w0.127: UV6.H4 203.1,118.07 v1(203.47,118.44)
FBA_CMD27: length 32.6
  BOTTOM w0.127: UV1.AA34 213.69,105.6 214.08,105.21 214.44,105.21 214.62,105.39 214.62,105.77 214.31,106.07 214.31,106.53 213.49,107.35 213.49,110.16 v2(212.92,110.73) 212.22,111.42 207.73,111.42 207.61,111.55 207.61,112 207.73,112.12 210.36,112.12 210.49,112.25 210.49,119.21 209.06,120.64 204.29,120.64 203.4,119.75 203.4,119.2 UV6.H5
FBA_CMD28: length 40.1
  TOP w0.127: v1(212.22,106.12) 212.22,107.84 211.56,108.5 v2(211.29,108.5) 206.25,108.5 206.12,108.63 206.12,109.01 206.25,109.14 210.95,109.14 211.11,109.3 211.11,109.82 210.38,110.55 208.62,110.55 208.49,110.68 208.49,111.01 208.62,111.13 209.42,111.13 209.55,111.26 209.55,111.55 209.42,111.68 208.6,111.68 208.47,111.81 208.47,112.1 208.6,112.22 209.42,112.22 209.55,112.35 209.55,118.94 208.67,119.82 205.03,119.82 204.27,119.06 v1(204.27,118.47)
  BOTTOM w0.102: v1(204.27,118.47) 204.27,117.67 UV6.G3 ; UV1.Y31 214.2,103.21 213.8,103.61 213.8,104.25 213.65,104.4 213.19,104.4 212.91,104.68 212.91,104.93 212.22,105.63
  BOTTOM w0.132: 212.22,105.63 v1(212.22,106.12)
FBA_CMD29: length 29.8
  TOP w0.089: RV340.1 202.65,115.41 v1(202.65,116.06)
  BOTTOM w0.127: UV1.Y34 214.07,105.6 213.68,105.99 213.68,106.62 210.96,109.34 210.96,110.42 210.42,110.95 209.87,110.95 209.75,110.83 209.75,109 209.62,108.87 209.36,108.87 209.24,109 209.24,110.83 209.11,110.95 208.86,110.95 208.73,110.83 208.73,108.9 208.6,108.77 208.35,108.77 208.22,108.9 208.22,110.83 208.09,110.95 207.84,110.95 207.71,110.83 207.71,110.07 207.59,109.94 207.33,109.94 207.21,110.07 207.21,110.83 207.08,110.95 v2(205.83,110.95) 204.33,110.95 204.2,111.08 204.2,113.96 202.65,115.51 v1(202.65,116.06) 202.62,116.06 202.27,116.41 UV6.J2
FBA_CMD30: length 32
  TOP w0.089: v1(202.65,116.86) 202.26,116.47 202.26,114.78
  TOP w0.127: 202.26,114.78 202.26,114.75 RV338.1 202.91,114.1 202.91,112.77 v2(204.47,111.2) 205.81,109.86 206.31,109.86 206.44,109.99 206.44,112.71 206.56,112.83 206.82,112.83 206.94,112.71 206.94,109.99 207.07,109.86 207.33,109.86 207.45,109.99 207.45,112.71 207.58,112.83 207.83,112.83 207.96,112.71 207.96,109.99 208.09,109.86 v1(210.48,109.86)
  BOTTOM w0.127: v1(210.48,109.86) 210.48,109.28 213.05,106.7 213.05,105.46 213.33,105.19 213.5,105.19 213.89,104.8 UV1.Y33 ; v1(202.65,116.86) 202.65,116.86 202.62,116.89 202.62,116.89 202.27,117.24 UV6.J3
FBA_CMD31: length 33.2
  BOTTOM w0.127: UV1.V31 215.56,103.54 215.56,104.14 215.66,104.25 215.66,104.53 215.56,104.63 215.56,104.86 215.2,105.21 215.2,106.2 215.15,106.25 215.15,106.77 214.25,107.67 v2(214.25,109.15) 214.25,110.48 211.25,113.47 211.25,119.53 209.28,121.5 203.29,121.5 202.09,120.3 201.37,120.3 200.25,119.18 200.25,117.68 UV6.L3
FBA_D0: length 19.8
  IN4 w0.089: 222.03,102.27 222.03,101.9 221.31,101.18 v1(221.31,101.08)
  IN4 w0.094: v1(226.3,117.67) 225.89,117.26 225.89,114.67 224.63,113.41 224.63,106.64 222.72,104.73 222.72,102.95 222.03,102.27
  BOTTOM w0.089: v1(221.31,101.08) 221.69,100.7 UV1.L28
  BOTTOM w0.102: v1(226.3,117.67) UV5.A4
FBA_D1: length 20
  IN4 w0.089: 222.3,102.08 222.3,101.83 221.74,101.26 221.74,101 221.46,100.72 220.85,100.72 v1(220.47,101.1)
  IN4 w0.094: 222.3,102.08 223.05,102.83 223.05,104.57 224.98,106.5 224.98,108.86 225.61,109.49 225.61,113.89 226.69,114.97 226.69,115.68 v1(226.3,116.07)
  BOTTOM w0.089: v1(220.47,101.1) 220.9,101.53 UV1.M29
  BOTTOM w0.102: v1(226.3,116.07) UV5.A2
FBA_D2: length 21.6
  IN4 w0.089: 224.6,105.63 224.37,105.63 223.38,104.64 223.38,102.8 222.54,101.96 222.54,101.53 v1(222.13,101.13)
  IN4 w0.094: v1(225.5,117.67) 225.89,118.05 226.46,118.05 226.73,117.79 226.73,116.31 226.96,116.09 226.96,114.75 225.95,113.74 225.95,109.34 225.33,108.72 225.33,106.36 224.6,105.63
  BOTTOM w0.089: v1(222.13,101.13) 222.13,101.12 UV1.L29
  BOTTOM w0.102: UV5.B4 v1(225.5,117.67)
FBA_D3: length 20
  IN4 w0.089: v1(220.43,100.28) 220.09,100.63 220.09,101.23 220.32,101.46 221.34,101.46 221.72,101.84 221.72,102.34 222.44,103.06 222.44,104.94
  IN4 w0.094: v1(225.5,116.07) 225.08,115.65 225.08,114.35 224.29,113.55 224.29,106.79 222.44,104.94
  BOTTOM w0.089: v1(220.43,100.28) 220.85,100.7 UV1.M28
  BOTTOM w0.102: v1(225.5,116.07) UV5.B2
FBA_D4: length 19.8
  IN4 w0.089: v1(220.47,102.81) 220.6,102.81 221.22,103.43 221.22,105.69
  IN4 w0.094: 221.22,105.69 222.89,107.37 222.89,112.15 221.87,113.17 221.87,116.19 222.14,116.46 223.2,116.46 223.46,116.72 223.46,118.14 v1(223.09,118.5)
  BOTTOM w0.089: UV1.N31 220.08,103.2 v1(220.47,102.81)
  BOTTOM w0.102: v1(223.09,118.5) 223.5,118.09 UV5.E4
FBA_D5: length 18.2
  IN4 w0.089: v1(219.64,101.1) 220.03,101.48 220.03,101.99 220.47,102.43 220.7,102.43 221.5,103.23 221.5,105.48
  IN4 w0.094: v1(223.1,116.07) 222.69,115.66 222.69,112.84 223.24,112.29 223.24,107.22 221.5,105.48
  BOTTOM w0.089: v1(219.64,101.1) 219.2,101.54 UV1.P29
  BOTTOM w0.102: v1(223.1,116.07) UV5.E2
FBA_D6: length 21.5
  IN4 w0.089: v1(218.76,101.16) 218.76,101.41 219.21,101.87 219.21,102.98 219.48,103.25 219.82,103.25 220.03,103.46 220.03,105.48 221.08,106.53
  IN4 w0.094: 221.08,106.53 222.2,107.65 222.2,111.86 220.63,113.43 220.63,115.29 221.11,115.77 221.11,116.66 221.74,117.29 222.88,117.29 223.07,117.47 v1(223.07,117.68)
  BOTTOM w0.089: v1(218.76,101.16) 218.76,101.19 UV1.R29
  BOTTOM w0.102: v1(223.07,117.68) 222.7,118.04 UV5.F4
FBA_D7: length 20.9
  IN4 w0.089: 220.86,105.82 220.86,103.45 220.64,103.23 220.38,103.23 220.11,102.96 220.11,102.43 219.56,101.87 219.56,101.65 219.28,101.38 219.28,100.78 v1(218.81,100.31)
  IN4 w0.094: v1(222.27,116.88) 221.89,116.88 221.49,116.48 221.49,115.64 220.98,115.13 220.98,113.57 222.55,112 222.55,107.51 220.86,105.82
  BOTTOM w0.089: v1(218.81,100.31) 218.83,100.31 219.2,100.68 UV1.P28
  BOTTOM w0.102: v1(222.27,116.88) 222.68,116.47 UV5.F2
FBA_D8: length 29.3
  IN1 w0.089: 226.62,106.53 226.62,106.36 225.2,104.95 225.2,104.12 224.8,103.72 224.61,103.72 224,103.1 223.55,103.1 223.28,102.83 223.28,101.36 v1(223,101.07)
  IN1 w0.094: 226.62,106.53 226.62,109.15 225.11,110.66 225.11,111.78 225.01,111.88 224.72,111.88 224.63,111.97 224.63,112.16 224.72,112.25 225.01,112.25 225.11,112.35 225.11,112.53 225.01,112.63 224.72,112.63 224.63,112.72 224.63,112.91 224.72,113 225.01,113 225.11,113.1 225.11,113.29 225.01,113.38 224.72,113.38 224.63,113.47 224.63,113.66 224.72,113.76 225.01,113.76 225.11,113.85 225.11,114.04 225.01,114.13 224.72,114.13 224.63,114.23 224.63,114.41 224.72,114.51 225.01,114.51 225.11,114.6 225.11,121.55 226.26,122.7 v1(226.26,123.27)
  BOTTOM w0.089: v1(223,101.07) 223.03,101.07 UV1.J28 ; UV5.A11 226.69,123.67 226.29,123.27 v1(226.26,123.27)
FBA_D9: length 30.5
  IN1 w0.089: 226.97,106.53 226.97,106.46 225.38,104.87 225.38,104.04 224.87,103.54 224.69,103.54 224.12,102.97 224.12,102.24 224.04,102.16 v1(223.81,101.93)
  IN1 w0.094: v1(226.33,124.87) 226.66,124.54 226.66,122.65 225.89,121.89 225.89,120.35 225.99,120.25 226.19,120.25 226.29,120.16 226.29,119.97 226.19,119.88 225.99,119.88 225.89,119.78 225.89,119.59 225.99,119.5 226.19,119.5 226.29,119.41 226.29,119.22 226.19,119.12 225.99,119.12 225.89,119.03 225.89,115.07 225.55,114.72 225.55,114.45 225.64,114.35 226.25,114.35 226.35,114.26 226.35,114.07 226.25,113.98 225.64,113.98 225.55,113.88 225.55,113.7 225.64,113.6 226.25,113.6 226.35,113.51 226.35,113.32 226.25,113.23 225.64,113.23 225.55,113.13 225.55,110.71 226.97,109.29 226.97,106.53
  BOTTOM w0.089: UV1.H29 223.82,101.93 v1(223.81,101.93) ; UV5.A13 226.7,125.25 v1(226.33,124.87)
FBA_D10: length 30.2
  IN1 w0.089: 226.27,106.53 226.27,106.27 225.02,105.02 225.02,104.19 224.72,103.89 224.54,103.89 223.92,103.28 223.28,103.28 222.92,102.92 v1(222.92,101.82)
  IN1 w0.094: 226.27,106.53 226.27,109 224.28,110.99 224.28,118.32 224.37,118.42 224.68,118.42 224.78,118.51 224.78,118.7 224.68,118.79 224.37,118.79 224.28,118.89 224.28,119.08 224.37,119.17 224.68,119.17 224.78,119.26 224.78,119.45 224.68,119.55 224.37,119.55 224.28,119.64 224.28,119.83 224.37,119.92 224.68,119.92 224.78,120.02 224.78,120.2 224.68,120.3 224.37,120.3 224.28,120.39 224.28,120.58 224.37,120.67 224.68,120.67 224.78,120.77 224.78,120.96 224.68,121.05 224.37,121.05 224.28,121.14 224.28,122.05 225.11,122.88 225.11,123.37 225.37,123.64 225.87,123.64 v1(226.26,124.03)
  BOTTOM w0.089: UV1.J29 223.13,101.82 v1(222.92,101.82) ; UV5.B11 v1(226.26,124.03)
FBA_D11: length 30.1
  IN1 w0.089: v1(224.61,101.16) 224.61,101.21 224.3,101.53 224.3,102.9 224.76,103.36 224.95,103.36 225.56,103.97 225.56,104.77 227.31,106.53
  IN1 w0.094: 227.31,106.53 227.31,110.13 225.9,111.54 225.9,112.71 225.97,112.78 226.62,112.78 226.69,112.86 226.69,122.18 227.52,123.01 227.52,124.34 226.57,125.29 226.21,125.29 225.79,124.87 v1(225.53,124.87)
  BOTTOM w0.089: v1(225.53,124.87) 225.9,125.25 UV5.B13 ; UV1.H28 224.2,100.75 v1(224.61,101.16)
FBA_D12: length 40.9
  IN1 w0.089: 229.4,106.53 229.4,105.9 227.58,104.08 227.58,103.45 226.14,102.01 v1(224.66,102.01)
  IN1 w0.094: v1(223.14,123.32) 222.76,123.71 222.45,123.71 222.45,123.7 222.13,123.7 221.91,123.93 221.91,126 222.97,127.06 223.17,127.06 223.91,127.8 228.01,127.8 229.61,126.19 229.61,120.47 229.4,120.27 229.4,106.53
  BOTTOM w0.089: v1(224.66,102.01) 225.05,101.62 UV1.G29 ; UV5.E11 223.34,123.52 223.33,123.52 v1(223.14,123.32)
FBA_D13: length 31.7
  IN1 w0.089: 228.71,106.53 228.71,105.92 226.42,103.64 v1(226.3,103.64)
  IN1 w0.094: 228.71,106.53 228.71,120.56 228.91,120.76 228.91,125.91 227.75,127.06 224.25,127.06 224.05,126.87 224.05,126.41 223.31,125.67 v1(223.11,125.67)
  BOTTOM w0.089: v1(226.3,103.64) 226.3,103.6 UV1.E31 ; v1(223.11,125.67) 223.5,125.28 UV5.E13
FBA_D14: length 32.2
  IN1 w0.089: 228.36,106.53 228.36,105.82 226.94,104.4 v1(226.31,104.4)
  IN1 w0.094: 228.36,106.53 228.36,120.7 228.56,120.91 228.56,125.76 227.61,126.72 225.51,126.72 224.85,126.06 224.53,126.06 224.32,125.84 224.32,124.67 224.12,124.47 222.68,124.47 v1(222.29,124.08)
  BOTTOM w0.089: v1(222.29,124.08) UV5.F11 ; UV1.E32 226.7,104.01 v1(226.31,104.4)
FBA_D15: length 34.8
  IN1 w0.089: v1(226.3,102.8) 226.66,103.16 226.66,103.62 229.05,106.02 229.05,106.53
  IN1 w0.094: v1(222.3,124.87) 222.69,125.26 222.69,125.81 222.93,126.06 223.22,126.06 223.69,126.52 223.69,127.04 224.06,127.41 227.9,127.41 229.26,126.05 229.26,120.62 229.05,120.41 229.05,106.53
  BOTTOM w0.089: UV5.F13 222.7,125.27 v1(222.3,124.87) ; v1(226.3,102.8) 226.3,102.8 UV1.F30
FBA_D16: length 27.5
  IN1 w0.094: v1(214.3,123.27) 214.69,122.88 214.69,119.45 215.48,118.66 215.48,113.15 217.03,111.6 221.57,111.6 225.14,108.02 v1(225.87,108.02)
  BOTTOM w0.089: UV1.C34 227.93,106.07 227.93,106.53
  BOTTOM w0.102: UV5.U11 v1(214.3,123.27)
  BOTTOM w0.127: 227.93,106.53 227.93,106.56 v2(226.84,107.66) 226.47,108.02 v1(225.87,108.02)
FBA_D17: length 30.6
  IN1 w0.094: v1(225.87,106.75) 225.43,106.75 221.91,110.27 217.37,110.27 213.1,114.54 213.1,124.47 v1(213.49,124.85)
  BOTTOM w0.089: 226.23,106.53 227.02,105.73 227.02,104.53 UV1.D32 ; v1(213.49,124.85) 213.49,124.86 UV5.U13
  BOTTOM w0.127: 226.23,106.53 226.01,106.75 v1(225.87,106.75)
FBA_D18: length 28.1
  IN1 w0.094: v1(215.07,123.26) 215.52,122.82 215.52,120.78 216.41,119.9 216.41,119.37 217.1,118.68 217.1,112.63 217.79,111.95 221.71,111.95 225,108.66 v1(225.87,108.66)
  BOTTOM w0.089: UV1.B33 228.79,105.21 228.79,106.52 228.78,106.53
  BOTTOM w0.102: v1(215.07,123.26) 215.07,123.3 UV5.T11
  BOTTOM w0.127: v1(225.87,108.66) 226.66,108.66 228.78,106.53
FBA_D19: length 30.2
  IN1 w0.094: v1(225.87,107.39) 225.29,107.39 222.05,110.62 217.52,110.62 214.69,113.45 214.69,114.23 213.75,115.17 213.75,118.98 213.87,119.1 213.87,124.44 v1(214.3,124.87)
  BOTTOM w0.089: v1(214.3,124.87) UV5.T13 ; 227.22,106.53 227.52,106.23 227.52,105.99 228,105.51 228,105.2 UV1.C33
  BOTTOM w0.127: v1(225.87,107.39) 226.36,107.39 227.22,106.53
FBA_D20: length 37.8
  IN1 w0.094: v1(224.72,105.27) 221.27,105.27 219.99,106.55 219.33,106.55 212.06,113.81 212.06,125.3 212.82,126.05 216.16,126.05 216.32,125.88 216.32,123.8 216.85,123.27 v1(217.5,123.27)
  BOTTOM w0.089: v1(224.72,105.27) 225.19,105.27 225.66,104.8 UV1.F33
  BOTTOM w0.102: UV5.N11 217.1,123.67 v1(217.5,123.27)
