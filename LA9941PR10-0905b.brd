# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D34: length 99
  IN1 w0.076: v1(171.22,77.88) 170.98,77.64 170.98,64.91 170.74,64.67 170.74,64.56 170.86,64.45 170.97,64.45 171.17,64.65 171.28,64.65 171.39,64.54 171.39,64.43 171.19,64.23 171.19,64.12 171.29,64.01 171.4,64.01 171.6,64.21 171.71,64.21 171.82,64.11 171.82,64 171.62,63.8 171.62,63.69 171.72,63.58 171.83,63.58 172.03,63.78 172.14,63.78 172.25,63.68 172.25,63.57 172.05,63.37 172.05,63.26 172.16,63.15 172.26,63.15 172.47,63.35 172.57,63.35 172.68,63.24 172.68,63.14 172.48,62.93 172.48,62.83 172.59,62.72 172.69,62.72 172.9,62.92 173,62.92 173.11,62.81 173.11,62.71 172.91,62.5 172.91,62.4 173.02,62.29 173.13,62.29 173.33,62.49 173.44,62.49 173.54,62.38 173.54,62.27 173.34,62.07 173.34,61.96 173.45,61.86 173.56,61.86 173.76,62.06 173.87,62.06 173.98,61.95 173.98,61.84 173.77,61.64 173.77,61.53 173.88,61.42 173.99,61.42 174.19,61.63 174.3,61.63 174.41,61.52 174.41,61.41 174.2,61.21 174.2,61.1 174.31,60.99 174.42,60.99 174.62,61.2 174.73,61.2 174.84,61.09 174.84,60.98 174.64,60.78 174.64,60.67 174.74,60.56 174.85,60.56 175.05,60.76 175.16,60.76 175.27,60.66 175.27,60.55 175.07,60.35 175.07,60.24 175.17,60.13 175.28,60.13 175.49,60.33 175.59,60.33 175.7,60.23 175.7,60.12 175.5,59.92 175.5,59.81 175.61,59.7 175.71,59.7 175.92,59.9 176.02,59.9 176.13,59.79 176.13,59.69 175.93,59.48 175.93,59.38 176.04,59.27 176.15,59.27 176.35,59.47 176.46,59.47 176.56,59.36 176.56,59.25 176.36,59.05 176.36,58.94 176.47,58.84 176.58,58.84 176.78,59.04 176.89,59.04 176.99,58.93 176.99,58.82 176.79,58.62 176.79,58.51 176.9,58.41 177.01,58.41 177.21,58.61 177.32,58.61 177.43,58.5 177.43,58.39 177.22,58.19 177.22,58.08 177.33,57.97 177.44,57.97 177.64,58.18 177.75,58.18 178.17,57.76 191.26,57.76 206.52,42.5 224.54,42.5 228.23,38.81 228.23,36.98 228.31,36.9 228.69,36.9 228.77,36.98 v1(228.77,37.28)
  BOTTOM w0.089: v1(171.22,77.88) 170.9,77.56 U6.BA15
  BOTTOM w0.102: JDIMM2.141 227.8,35.53 228.23,35.96 228.23,36.74 v1(228.77,37.28)
DDR_B_D35: length 99
  IN1 w0.076: v1(228.77,35.75) 228.77,35.25 226.96,33.45 226.96,31.69 227.04,31.62 227.24,31.62 227.32,31.69 227.32,33.21 229.16,35.06 229.16,38.2 224.64,42.73 206.62,42.73 191.36,57.99 178.26,57.99 171.21,65.04 171.21,77.1 171.59,77.48 171.59,79.61 v1(171.22,79.98)
  BOTTOM w0.089: v1(171.22,79.98) 170.9,79.66 U6.AV15
  BOTTOM w0.102: v1(228.77,35.75) 228.4,35.38 JDIMM2.143
DDR_B_D36: length 98.6
  IN1 w0.076: v1(170.28,78.58) 170.09,78.39 170.09,77.57 169.02,76.5 169.02,64.38 172.18,61.22 172.18,61.11 171.68,60.62 171.68,60.51 175.78,56.41 190.7,56.41 205.96,41.15 223.62,41.15 225.48,39.29 225.48,36.36 225.55,36.29 225.92,36.29 225.99,36.21 225.99,35.98 225.92,35.91 225.55,35.91 225.48,35.83 225.48,35.6 225.55,35.52 225.92,35.52 225.99,35.45 225.99,35.22 225.92,35.14 225.55,35.14 225.48,35.07 225.48,28.46 v1(224.5,27.48)
  BOTTOM w0.089: U6.AY16 169.96,78.26 v1(170.28,78.58)
  BOTTOM w0.102: JDIMM2.130 v1(224.5,27.48)
DDR_B_D37: length 99.6
  IN1 w0.076: v1(170.28,79.98) 169.91,79.61 169.91,77.65 168.79,76.53 168.79,64.28 171.8,61.28 171.8,61.17 171.3,60.67 171.3,60.57 175.69,56.18 190.61,56.18 205.87,40.92 223.52,40.92 225.25,39.2 225.25,28.71 225.17,28.63 224.58,28.63 224.5,28.71 v1(224.5,29.01)
  BOTTOM w0.089: U6.AV16 169.96,79.66 v1(170.28,79.98)
  BOTTOM w0.102: JDIMM2.132 225.1,28.41 v1(224.5,29.01)
DDR_B_D38: length 99
  IN1 w0.076: v1(171.22,78.58) 171.22,78.4 170.75,77.93 170.75,67.2 170.68,67.12 170.36,67.12 170.28,67.05 170.28,66.89 170.36,66.82 170.68,66.82 170.75,66.74 170.75,66.56 170.68,66.49 170.36,66.49 170.28,66.41 170.28,66.26 170.36,66.18 170.68,66.18 170.75,66.11 170.75,65.95 170.68,65.88 170.36,65.88 170.28,65.8 170.28,65.65 170.36,65.57 170.68,65.57 170.75,65.5 170.75,65 170.51,64.76 170.51,64.47 177.45,57.53 191.17,57.53 206.43,42.27 224.45,42.27 227.98,38.74 227.98,35.92 226.65,34.59 226.65,27.88 v1(227.04,27.48)
  BOTTOM w0.089: v1(171.22,78.58) 170.9,78.26 U6.AY15
  BOTTOM w0.102: v1(227.04,27.48) 227.5,27.02 JDIMM2.140
DDR_B_D39: length 99.2
  IN1 w0.076: v1(171.22,80.68) 171.77,80.14 171.77,77.34 171.44,77.01 171.44,65.14 178.36,58.21 191.45,58.21 206.71,42.95 224.73,42.95 229.39,38.3 229.39,34.96 227.62,33.19 227.62,29.59 v1(227.04,29.01)
  BOTTOM w0.089: v1(171.22,80.68) 170.9,80.36 U6.AU15
  BOTTOM w0.102: v1(227.04,29.01) 228.1,27.95 JDIMM2.142
DDR_B_D40: length 99.8
  IN1 w0.076: v1(231.02,35.75) 231.02,33.76 229.34,32.09 229.22,32.09 228.95,32.36 228.83,32.36 228.66,32.19 228.52,32.19 228.42,32.3 228.42,32.44 228.59,32.62 228.75,32.77 228.75,32.9 228.48,33.18 228.48,33.34 228.59,33.45 228.75,33.45 228.96,33.23 229.07,33.23 229.87,34.04 229.87,38.5 224.93,43.44 206.91,43.44 191.65,58.7 180.5,58.7 171.92,67.28 171.92,72.49 172.32,72.89 172.32,75.85 172.01,76.17 172.01,77.21 172.15,77.35 172.15,78.05 172.55,78.45 172.55,80.13 v1(173.1,80.68)
  BOTTOM w0.089: v1(173.1,80.68) 172.78,80.36 U6.AU12
  BOTTOM w0.102: v1(231.02,35.75) 230.61,35.75 230.2,35.34 JDIMM2.149
DDR_B_D41: length 100.6
  IN1 w0.076: v1(173.1,78.58) 173.1,78.41 172.71,78.01 172.71,77.01 172.36,76.66 172.36,76.35 172.85,75.87 172.85,72.78 173.15,72.48 173.15,70.89 173.14,70.89 173.14,66.7 180.69,59.15 191.84,59.15 207.1,43.89 225.12,43.89 226.86,42.16 226.97,42.16 227.16,42.35 227.26,42.35 227.37,42.24 227.37,42.13 227.18,41.94 227.18,41.83 227.29,41.73 227.4,41.73 227.59,41.92 227.7,41.92 227.8,41.81 227.8,41.7 227.61,41.51 227.61,41.4 227.8,41.22 227.91,41.22 228.1,41.41 228.21,41.41 228.31,41.3 228.31,41.19 228.12,41 228.12,40.89 228.23,40.78 228.34,40.78 228.53,40.97 228.64,40.97 228.75,40.87 228.75,40.76 228.56,40.57 228.56,40.46 228.66,40.35 228.77,40.35 228.96,40.54 229.07,40.54 229.18,40.44 229.18,40.33 228.99,40.14 228.99,40.03 229.09,39.92 229.2,39.92 229.39,40.11 229.5,40.11 229.61,40 229.61,39.9 229.42,39.71 229.42,39.6 230.57,38.45 231.16,38.45 231.56,38.05 231.56,33.89 229.19,31.51 229.19,27.88 v1(229.58,27.48)
  BOTTOM w0.089: U6.AY12 172.78,78.26 v1(173.1,78.58)
  BOTTOM w0.102: JDIMM2.148 229.9,27.16 v1(229.58,27.48)
DDR_B_D42: length 99.4
  IN1 w0.076: v1(233.14,37.28) 233.46,37.28 233.53,37.2 233.53,32.52 232.84,31.82 232.84,31.68 232.94,31.59 233.08,31.59 233.87,32.38 233.87,37.87 226.5,45.24 207.66,45.24 192.4,60.5 181.25,60.5 174.61,67.14 174.61,71.56 174.37,71.8 174.37,75.97 173.92,76.41 173.92,77.3 174.04,77.41 v1(174.04,77.88)
  BOTTOM w0.089: v1(174.04,77.88) 173.72,77.56 U6.BA10
  BOTTOM w0.102: JDIMM2.157 232.6,36.74 v1(233.14,37.28)
DDR_B_D43: length 100.7
  IN1 w0.076: v1(174.04,80.68) 174.59,80.14 174.59,78.36 174.79,78.16 174.79,77.22 175.54,76.47 175.54,71.81 175.31,71.58 175.31,67.41 175.65,67.07 181.53,61.19 186.07,61.19 186.15,61.26 186.15,61.53 186.22,61.6 186.37,61.6 186.45,61.53 186.45,61.26 186.53,61.19 186.68,61.19 186.76,61.26 186.76,61.53 186.83,61.6 186.98,61.6 187.06,61.53 187.06,61.26 187.14,61.19 187.29,61.19 187.37,61.26 187.37,61.53 187.44,61.6 192.26,61.6 207.94,45.93 226.78,45.93 234.55,38.15 234.55,32.1 233.41,30.95 233.41,29.52 v1(232.9,29.01)
  BOTTOM w0.089: v1(174.04,80.68) 173.72,80.36 U6.AU10
  BOTTOM w0.102: JDIMM2.160 233.5,28.41 v1(232.9,29.01)
DDR_B_D44: length 100.6
  IN1 w0.076: v1(173.1,79.98) 172.73,79.61 172.73,78.81 172.73,78.81 172.73,78.29 172.53,78.08 172.53,77.43 172.18,77.08 172.18,76.28 172.58,75.88 172.58,72.87 172.15,72.44 172.15,72.23 172.15,67.37 180.6,58.93 191.75,58.93 207.01,43.66 225.03,43.66 230.1,38.59 230.1,38.09 230.18,38.01 230.55,38.01 230.62,37.94 230.62,37.79 230.55,37.71 230.18,37.71 230.1,37.63 230.1,33.8 229.11,32.81 229.11,32.7 229.31,32.49 229.42,32.49 230.62,33.69 230.62,36.88 v1(231.02,37.28)
  BOTTOM w0.089: v1(173.1,79.98) 172.78,79.66 U6.AV12
  BOTTOM w0.102: v1(231.02,37.28) 230.68,37.28 229.6,36.2 JDIMM2.147
DDR_B_D45: length 100.4
  IN1 w0.076: v1(173.1,77.88) 173.1,72.84 173.37,72.57 173.37,71.48 173.38,71.48 173.38,70.8 173.37,70.79 173.37,66.8 180.79,59.38 191.94,59.38 207.2,44.12 225.81,44.12 230.11,39.82 230.11,39.71 229.92,39.52 229.92,39.42 230.03,39.31 230.14,39.31 230.33,39.5 230.44,39.5 230.55,39.39 230.55,39.28 230.36,39.09 230.36,38.98 230.46,38.88 230.57,38.88 230.76,39.07 230.87,39.07 231.81,38.12 231.81,33.03 231.12,32.34 231.02,32.34 230.73,32.62 230.62,32.62 230.51,32.52 230.51,32.41 230.8,32.12 230.8,32.01 230.69,31.91 230.58,31.91 230.3,32.19 230.19,32.19 230.08,32.09 230.08,31.98 230.37,31.69 230.37,31.58 230.26,31.47 230.15,31.47 229.87,31.76 229.76,31.76 229.65,31.65 229.65,31.55 229.86,31.34 229.86,30.8 229.72,30.66 229.49,30.66 229.41,30.58 229.41,30.43 229.49,30.36 230.03,30.36 230.11,30.28 230.11,29.54 v1(229.58,29.01)
  BOTTOM w0.089: v1(173.1,77.88) 172.78,77.56 U6.BA12
  BOTTOM w0.102: v1(229.58,29.01) 229.15,28.58 229.15,27.21 229.3,27.06 JDIMM2.146
DDR_B_D46: length 100.1
  IN1 w0.076: v1(233.14,35.75) 233.14,32.45 232.54,31.84 232.54,31.66 232.92,31.28 233.1,31.28 234.1,32.29 234.1,37.96 226.59,45.47 207.75,45.47 192.49,60.73 192.1,60.73 192.03,60.8 192.03,61.06 191.94,61.15 191.81,61.15 191.72,61.06 191.72,60.8 191.65,60.73 191.49,60.73 191.42,60.8 191.42,61.06 191.33,61.15 191.2,61.15 191.11,61.06 191.11,60.8 191.04,60.73 190.88,60.73 190.81,60.8 190.81,61.06 190.72,61.15 190.59,61.15 190.5,61.06 190.5,60.8 190.43,60.73 190.21,60.73 190.13,60.8 190.13,61.07 190.06,61.15 189.91,61.15 189.83,61.07 189.83,60.8 189.75,60.73 181.35,60.73 174.85,67.22 174.85,71.69 174.55,71.99 174.55,76 174.85,76.3 174.85,76.63 174.41,77.07 174.41,78.04 174.04,78.4 v1(174.04,78.58)
  BOTTOM w0.089: v1(174.04,78.58) 173.72,78.26 U6.AY10
  BOTTOM w0.102: v1(233.14,35.75) 233.2,35.69 JDIMM2.159
DDR_B_D47: length 100.8
  IN1 w0.076: v1(174.04,79.98) 174.22,79.98 174.41,79.79 174.41,78.29 174.61,78.08 174.61,77.15 175.08,76.68 175.08,76.27 174.8,75.99 174.8,72.09 175.08,71.81 175.08,67.32 181.44,60.96 187.59,60.96 187.67,61.03 187.67,61.3 187.75,61.38 187.92,61.38 188,61.3 188,61.03 188.08,60.96 188.23,60.96 188.31,61.03 188.31,61.3 188.38,61.38 188.53,61.38 188.61,61.3 188.61,61.03 188.69,60.96 188.84,60.96 188.91,61.03 188.91,61.3 188.99,61.38 189.14,61.38 189.22,61.3 189.22,61.03 189.3,60.96 189.45,60.96 189.52,61.03 189.52,61.3 189.6,61.38 192.17,61.38 207.85,45.7 226.68,45.7 234.33,38.06 234.33,32.19 232.41,30.27 232.41,27.98 v1(232.9,27.48)
  BOTTOM w0.089: v1(174.04,79.98) 173.72,79.66 U6.AV10
  BOTTOM w0.102: JDIMM2.158 v1(232.9,27.48)
DDR_B_D48: length 99.6
  IN1 w0.076: v1(235.58,37.28) 235.58,36.98 235.65,36.9 236.06,36.9 236.14,36.98 236.14,38.59 235.93,38.8 235.61,38.8 235.15,38.34 235.04,38.34 234.94,38.45 234.94,38.56 235.66,39.28 235.66,39.39 235.55,39.5 235.45,39.5 234.72,38.77 234.61,38.77 234.51,38.88 234.51,38.99 235.23,39.71 235.23,39.82 235.12,39.93 235.01,39.93 234.29,39.21 234.18,39.21 234.07,39.31 234.07,39.42 234.8,40.15 234.8,40.25 234.69,40.36 234.58,40.36 233.86,39.64 233.75,39.64 233.64,39.75 233.64,39.85 234.37,40.58 234.37,40.68 234.26,40.79 234.15,40.79 233.43,40.07 233.32,40.07 226.98,46.41 208.14,46.41 192.05,62.51 184.59,62.51 175.79,71.31 175.79,71.94 175.71,72.02 175.71,76.55 175.13,77.13 175.13,78.17 175.35,78.39 175.35,80.11 v1(175.92,80.68)
  BOTTOM w0.089: v1(175.92,80.68) 175.6,80.36 U6.AU8
  BOTTOM w0.102: v1(235.58,37.28) 234.4,36.1 JDIMM2.163
DDR_B_D49: length 98.7
  IN1 w0.076: v1(175.92,77.88) 175.92,77.29 176.34,76.87 176.34,74.3 177.03,73.61 177.03,71.04 184.88,63.19 192.33,63.19 208.43,47.09 227.26,47.09 232.88,41.48 234.54,41.48 236.82,39.2 236.82,31.77 236.75,31.69 235.35,31.69 235.27,31.62 235.27,31.47 235.35,31.39 236.75,31.39 236.82,31.31 236.82,31.16 236.75,31.08 235.91,31.08 235.83,31 235.83,30.83 235.91,30.75 236.1,30.75 236.19,30.66 236.19,30.53 236.1,30.45 235.91,30.45 235.83,30.37 235.83,27.56 235.76,27.48 v1(235.44,27.48)
  BOTTOM w0.089: v1(175.92,77.88) 175.6,77.56 U6.BA8
  BOTTOM w0.102: JDIMM2.166 235.3,27.34 v1(235.44,27.48)
DDR_B_D50: length 99.3
  IN1 w0.076: v1(237.22,29.01) 237.53,29.32 237.64,29.32 237.74,29.22 237.84,29.22 237.95,29.33 237.95,29.43 237.85,29.53 237.85,29.64 237.96,29.75 238.07,29.75 238.17,29.65 238.28,29.65 238.38,29.76 238.38,29.87 238.13,30.12 238.13,30.24 238.22,30.33 238.35,30.33 238.6,30.08 238.71,30.08 238.82,30.19 238.82,30.3 238.72,30.4 238.72,30.51 238.92,30.71 238.92,32.32 240.16,33.56 240.16,38.1 229.58,48.67 209.19,48.67 193.01,64.84 187.4,64.84 179.99,72.26 179.99,72.56 178.05,74.49 178.05,76.52 177.41,77.17 177.41,79.44 v1(176.86,79.98)
  BOTTOM w0.089: v1(176.86,79.98) 176.54,79.66 U6.AV6
  BOTTOM w0.102: JDIMM2.176 238.3,27.02 237.83,27.49 237.83,28.39 v1(237.22,29.01)
DDR_B_D51: length 98.5
  IN1 w0.076: v1(239.26,35.75) 239.26,34.87 239.18,34.79 237.41,34.79 237.34,34.87 237.34,35.03 237.41,35.11 238.83,35.11 238.91,35.18 238.91,35.33 238.83,35.41 237.54,35.41 237.47,35.49 237.47,35.66 237.54,35.74 238.66,35.74 238.85,35.93 238.85,38.76 234.49,43.12 234.38,43.12 233.86,42.6 233.75,42.6 233.64,42.7 233.64,42.81 234.16,43.33 234.16,43.44 229.98,47.62 229.87,47.62 229.38,47.13 229.24,47.13 229.14,47.23 229.14,47.37 229.64,47.86 229.64,47.97 229.53,48.08 229.42,48.08 228.7,47.35 228.59,47.35 228.48,47.46 228.48,47.57 228.91,48 228.91,48.1 228.8,48.21 228.7,48.21 228.27,47.78 228.16,47.78 227.73,48.21 209,48.21 192.82,64.38 187.21,64.38 178.31,73.29 178.31,73.63 177.67,74.26 177.67,76.33 176.86,77.15 v1(176.86,77.88)
  BOTTOM w0.089: v1(176.86,77.88) 176.54,77.56 U6.BA6
  BOTTOM w0.102: JDIMM2.177 238.6,35.45 238.91,35.75 v1(239.26,35.75)
DDR_B_D52: length 99.5
  IN1 w0.076: v1(175.92,79.98) 175.53,79.59 175.53,78.32 175.32,78.11 175.32,77.19 175.92,76.59 175.92,74.21 176.63,73.5 176.63,71.7 176.58,71.65 176.58,70.85 177.12,70.3 184.69,62.74 192.14,62.74 208.24,46.64 227.07,46.64 232.69,41.02 234.35,41.02 236.37,39.01 236.37,36.64 236.29,36.57 236.05,36.57 235.97,36.49 235.97,36.34 236.05,36.26 236.29,36.26 236.37,36.19 236.37,36.04 236.29,35.96 236.05,35.96 235.97,35.88 235.97,35.73 236.05,35.65 236.29,35.65 236.37,35.58 236.37,35.43 236.29,35.35 235.75,35.35 235.66,35.26 235.66,35.13 235.75,35.04 236.29,35.04 236.37,34.97 236.37,34.82 236.29,34.74 235.76,34.74 235.67,34.65 235.67,34.52 235.76,34.44 236.29,34.44 236.37,34.36 236.37,34.21 236.29,34.13 235.79,34.13 235.7,34.04 235.7,33.91 235.79,33.83 236.27,33.83 236.37,33.73 236.37,33.6 236.27,33.51 235.11,33.51 235.04,33.59 235.04,35.68 235.11,35.75 v1(235.58,35.75)
  BOTTOM w0.089: U6.AV8 175.6,79.66 v1(175.92,79.98)
  BOTTOM w0.102: v1(235.58,35.75) 235,35.18 JDIMM2.165
DDR_B_D53: length 98.9
  IN1 w0.076: v1(175.92,78.58) 175.92,78.46 175.51,78.05 175.51,77.25 176.1,76.67 176.1,74.29 176.81,73.58 176.81,70.94 184.78,62.96 192.24,62.96 208.33,46.87 227.17,46.87 232.78,41.25 234.45,41.25 236.6,39.1 236.6,32.68 236.52,32.61 235.65,32.61 235.57,32.53 235.57,32.38 235.65,32.3 236.52,32.3 236.6,32.23 236.6,32.08 236.52,32 235.11,32 235.05,31.93 235.05,29.08 235.12,29.01 v1(235.44,29.01)
  BOTTOM w0.089: U6.AY8 175.6,78.26 v1(175.92,78.58)
  BOTTOM w0.102: JDIMM2.164 234.7,28.27 v1(235.44,29.01)
DDR_B_D54: length 99.5
  IN1 w0.076: v1(237.22,27.48) 238.27,28.54 238.27,28.64 238.03,28.88 238.03,28.99 238.14,29.09 238.25,29.09 238.48,28.86 238.59,28.86 238.7,28.97 238.7,29.07 238.46,29.31 238.46,29.42 239.15,30.11 239.15,32.23 240.38,33.46 240.38,38.19 229.68,48.9 209.28,48.9 193.11,65.07 187.5,65.07 180.21,72.35 180.21,72.71 178.99,73.94 178.99,76.16 178.15,77 178.15,79.43 177.94,79.64 177.48,79.64 177.29,79.83 177.29,80.25 v1(176.86,80.68)
  BOTTOM w0.089: v1(176.86,80.68) 176.54,80.36 U6.AU6
  BOTTOM w0.102: v1(237.22,27.48) 237.7,27 JDIMM2.174
DDR_B_D55: length 98.8
  IN1 w0.076: v1(176.86,78.58) 177.23,78.21 177.23,77.1 177.86,76.46 177.86,74.35 179.58,72.64 179.58,72.35 187.31,64.61 192.92,64.61 209.09,48.44 229.49,48.44 239.93,38 239.93,33.65 239.85,33.57 238.67,33.57 238.59,33.65 238.59,33.8 238.67,33.88 239.57,33.88 239.65,33.95 239.65,34.11 239.57,34.18 238.67,34.18 238.59,34.26 238.59,34.41 238.67,34.49 239.57,34.49 239.65,34.56 239.65,37.2 239.57,37.28 v1(239.26,37.28)
  BOTTOM w0.089: v1(176.86,78.58) 176.54,78.26 U6.AY6
  BOTTOM w0.102: v1(239.26,37.28) 239.06,37.28 238.66,36.88 238.66,36.04 238,35.38 JDIMM2.175
DDR_B_D56: length 105.4
  IN1 w0.076: v1(241.76,37.28) 241.76,37.01 241.64,36.89 241.5,36.89 241.37,37.01 241.37,38.33 241.9,38.86 241.9,38.98 241.77,39.11 241.66,39.11 241.28,38.73 241.17,38.73 241.05,38.86 241.05,38.96 241.42,39.34 241.42,39.45 241.32,39.56 241.21,39.56 240.83,39.18 240.72,39.18 240.62,39.29 240.62,39.4 240.99,39.77 240.99,39.88 240.89,39.99 240.78,39.99 240.4,39.61 240.29,39.61 240.18,39.72 240.18,39.83 240.56,40.2 240.56,40.31 240.45,40.42 240.35,40.42 239.97,40.04 239.86,40.04 239.75,40.15 239.75,40.26 240.13,40.64 240.13,40.74 240.02,40.85 239.92,40.85 239.54,40.47 239.43,40.47 239.32,40.58 239.32,40.69 239.7,41.07 239.7,41.17 239.59,41.28 239.48,41.28 239.11,40.9 239,40.9 238.89,41.01 238.89,41.12 239.27,41.5 239.27,41.61 239.16,41.71 239.05,41.71 238.68,41.34 238.57,41.34 238.46,41.44 238.46,41.55 238.84,41.93 238.84,42.04 238.73,42.14 238.62,42.14 238.24,41.77 238.14,41.77 238.03,41.88 238.03,41.98 238.41,42.36 238.41,42.47 238.3,42.58 238.19,42.58 237.81,42.2 237.71,42.2 237.6,42.31 237.6,42.41 237.97,42.79 237.97,42.9 237.87,43.01 237.76,43.01 237.38,42.63 237.27,42.63 230.07,49.84 209.67,49.84 193.5,66.01 187.89,66.01 179.84,74.05 179.84,77.55 179.51,77.88 179.51,78.64 180.35,79.48 180.35,82.14 v1(179.18,83.31)
  BOTTOM w0.089: U6.AM2 179.53,83.66 v1(179.18,83.31)
  BOTTOM w0.102: v1(241.76,37.28) 241.24,37.28 239.8,35.83 JDIMM2.181
DDR_B_D57: length 105.5
  IN1 w0.076: v1(178.48,83.31) 179.51,82.27 179.51,81.48 179.66,81.33 179.66,80.61 179.51,80.46 179.51,79.38 178.74,78.61 178.74,78.3 179.17,77.86 179.17,76.87 179.61,76.42 179.61,73.96 187.79,65.78 193.4,65.78 209.58,49.61 229.97,49.61 241.14,38.44 241.14,31.78 241.22,31.7 241.41,31.7 241.49,31.78 241.49,32.26 241.57,32.33 242.04,32.33 242.12,32.41 242.12,32.56 242.04,32.64 241.57,32.64 241.49,32.71 241.49,33.42 241.57,33.5 242.04,33.5 242.11,33.58 242.11,33.73 242.04,33.81 241.57,33.81 241.49,33.88 241.49,34.03 241.57,34.11 242.04,34.11 242.11,34.19 242.11,34.34 242.04,34.42 241.57,34.42 241.49,34.49 241.49,34.64 241.57,34.72 242.04,34.72 242.11,34.8 242.11,34.95 242.04,35.03 241.57,35.03 241.49,35.1 241.49,35.68 241.57,35.75 v1(241.76,35.75)
  BOTTOM w0.089: U6.AM3 178.83,83.66 v1(178.48,83.31)
  BOTTOM w0.102: JDIMM2.183 240.4,35.34 240.81,35.75 v1(241.76,35.75)
DDR_B_D58: length 104.9
  IN1 w0.076: v1(243.41,27.48) 243.15,27.48 243.02,27.61 243.02,27.79 242.94,27.87 242.4,27.87 242.31,27.96 242.31,28.08 242.4,28.17 242.94,28.17 243.02,28.25 243.02,31.4 243.46,31.85 243.46,33.37 244.59,34.49 244.59,38.84 231.79,51.64 211.31,51.64 195.14,67.81 188.64,67.81 183.11,73.34 183.11,82.68 181.26,84.53 180.46,84.53 180.07,84.92 v1(179.89,84.92)
  BOTTOM w0.089: U6.AK1 180.23,85.25 v1(179.89,84.92)
  BOTTOM w0.102: JDIMM2.192 243.1,27.17 v1(243.41,27.48)
DDR_B_D59: length 105.3
  IN1 w0.076: v1(177.78,84.93) 178.18,84.53 179.32,84.53 179.77,84.08 181.05,84.08 182.65,82.49 182.65,73.15 188.45,67.36 194.95,67.36 211.12,51.18 230.63,51.18 234.62,47.19 234.73,47.19 235.11,47.56 235.21,47.56 235.32,47.46 235.32,47.35 234.95,46.97 234.95,46.86 235.05,46.76 235.16,46.76 235.54,47.13 235.65,47.13 235.75,47.03 235.75,46.92 235.38,46.54 235.38,46.43 235.48,46.33 235.59,46.33 235.97,46.7 236.08,46.7 236.18,46.59 236.18,46.49 235.81,46.11 235.81,46 235.92,45.89 236.02,45.89 236.4,46.27 236.51,46.27 236.62,46.16 236.62,46.06 236.24,45.68 236.24,45.57 236.35,45.46 236.45,45.46 236.82,45.83 236.95,45.83 243.46,39.32 243.46,34.16 243.54,34.08 243.85,34.08 243.93,34.16 243.93,34.9 244.01,34.98 244.29,34.98 244.36,35.05 244.36,35.21 244.29,35.28 244.01,35.28 243.93,35.36 v1(243.93,35.75)
  BOTTOM w0.089: v1(177.78,84.93) 178.13,85.28 U6.AK4
  BOTTOM w0.102: JDIMM2.193 243.4,35.22 v1(243.93,35.75)
DDR_B_D60: length 105.2
  IN1 w0.076: v1(239.76,27.48) 241.25,27.48 241.34,27.58 241.34,27.7 241.25,27.8 240.26,27.8 240.18,27.87 240.18,28.04 240.26,28.12 241.2,28.12 241.3,28.21 241.3,28.35 241.2,28.44 240.68,28.44 240.6,28.52 240.6,30.57 242.34,32.31 242.34,38.85 237.81,43.39 237.7,43.39 237.33,43.01 237.22,43.01 230.16,50.07 209.77,50.07 193.59,66.24 187.98,66.24 180.03,74.19 180.03,77.55 180.33,77.86 180.33,78.75 180.53,78.94 180.53,82.66 v1(179.88,83.31)
  BOTTOM w0.089: U6.AM1 180.23,83.66 v1(179.88,83.31)
  BOTTOM w0.102: v1(239.76,27.48) 239.5,27.23 JDIMM2.180
DDR_B_D61: length 106.6
  IN1 w0.076: v1(177.78,83.31) 178.11,82.98 178.11,79.9 178.37,79.64 178.69,79.64 178.95,79.38 178.95,79.07 178.56,78.68 178.56,78.22 178.99,77.79 178.99,76.78 179.39,76.39 179.39,73.86 187.7,65.55 193.31,65.55 209.48,49.38 229.88,49.38 240.91,38.35 240.91,32.74 240.84,32.67 240.27,32.67 240.2,32.59 240.2,32.44 240.27,32.36 240.84,32.36 240.91,32.29 240.91,32.13 240.84,32.06 240.16,32.06 240.08,31.98 240.08,31.83 240.16,31.75 240.73,31.75 240.81,31.68 240.81,31.47 240.73,31.39 239.71,31.39 239.63,31.32 239.63,31.16 239.71,31.09 240.35,31.09 240.43,31 240.43,30.87 240.35,30.78 239.71,30.78 239.63,30.71 239.63,30.56 239.71,30.48 240.27,30.48 240.35,30.4 240.35,28.84 240.27,28.76 239.83,28.76 239.76,28.84 v1(239.76,29.01)
  BOTTOM w0.089: U6.AM4 178.13,83.66 v1(177.78,83.31)
  BOTTOM w0.102: v1(239.76,29.01) 240.22,28.55 240.22,27.29 240.1,27.17 JDIMM2.182
DDR_B_D62: length 105.1
  IN1 w0.076: v1(243.93,37.28) 244.26,37.28 244.34,37.35 244.34,38.77 235.16,47.94 235.05,47.94 234.68,47.57 234.57,47.57 234.46,47.67 234.46,47.78 234.84,48.16 234.84,48.27 234.73,48.37 234.62,48.37 234.24,48 234.14,48 234.03,48.11 234.03,48.21 234.41,48.59 234.41,48.7 234.3,48.81 234.19,48.81 233.81,48.43 233.7,48.43 233.6,48.54 233.6,48.64 233.97,49.02 233.97,49.13 233.87,49.24 233.76,49.24 233.38,48.86 233.27,48.86 233.17,48.97 233.17,49.08 233.54,49.45 233.54,49.56 233.43,49.67 233.33,49.67 232.95,49.29 232.84,49.29 232.73,49.4 232.73,49.51 233.11,49.88 233.11,49.99 233,50.1 232.9,50.1 232.52,49.72 232.41,49.72 232.3,49.83 232.3,49.94 232.68,50.31 232.68,50.42 232.57,50.53 232.46,50.53 232.09,50.15 231.98,50.15 231.87,50.26 231.87,50.37 232.25,50.75 232.25,50.85 232.14,50.96 232.03,50.96 231.66,50.58 231.55,50.58 231.44,50.69 231.44,50.8 231.82,51.18 231.82,51.29 231.69,51.41 211.21,51.41 195.04,67.58 188.54,67.58 182.88,73.25 182.88,82.58 181.12,84.34 179.89,84.34 179.32,84.91 v1(179.2,84.91)
  BOTTOM w0.089: v1(179.2,84.91) 179.2,85.01 U6.AK2
  BOTTOM w0.102: v1(243.93,37.28) 242.8,36.15 JDIMM2.191
DDR_B_D63: length 106.2
  IN1 w0.076: v1(178.48,84.93) 178.96,85.42 180.69,85.42 182.31,83.8 183.34,82.77 183.34,73.44 188.73,68.04 195.23,68.04 211.4,51.87 231.88,51.87 244.84,38.9 244.84,34.43 243.69,33.27 243.69,32.1 243.81,31.98 243.81,30.62 243.73,30.54 243.48,30.54 243.39,30.46 243.39,30.33 243.48,30.24 243.73,30.24 243.81,30.16 243.81,29.4 v1(243.41,29.01)
  BOTTOM w0.089: U6.AK3 178.83,85.28 v1(178.48,84.93)
  BOTTOM w0.102: v1(243.41,29.01) 243.85,28.58 243.85,27.31 243.7,27.16 JDIMM2.194
DDR_B_DQS0: length 94.7
  IN1 w0.076: v1(185.93,30.21) 185.93,29.93 185.84,29.84 185.72,29.84 185.19,30.37 185.19,30.77 184.06,31.9 184.06,32.28 173.63,42.71 161.89,42.71 140.93,63.67 140.93,86.43 140.51,86.85 140.51,87.45 140.65,87.59 140.74,87.59 v1(140.96,87.37)
  BOTTOM w0.089: U6.AD53 145.22,88.95 145.31,89.03 145.31,89.13 145.18,89.27 143.66,89.27 143.61,89.22 142.95,89.22 141.47,87.74 141.32,87.74 v1(140.96,87.37)
  BOTTOM w0.102: JDIMM2.12 186.7,27.25 186.52,27.44 186.52,28.06 186.74,28.28 186.74,29.71 186.47,29.98 186.16,29.98 v1(185.93,30.21)
DDR_B_DQS1: length 92.5
  IN1 w0.076: v1(149.61,80.11) 149.35,80.36 149.24,80.36 149.19,80.31 149.19,77.75 148.93,77.49 146.26,77.49 144.69,75.93 144.69,64.77 163.26,46.19 183.52,46.19 187.48,42.23 187.59,42.23 188.07,42.71 188.3,42.71 188.55,42.45 188.55,42.22 188.07,41.74 188.07,41.63 188.24,41.47 188.34,41.47 188.82,41.95 189.06,41.95 189.31,41.7 189.31,41.47 188.83,40.99 188.83,40.88 188.99,40.72 189.1,40.72 189.58,41.2 189.81,41.2 190.06,40.94 190.06,40.71 189.59,40.23 189.59,40.12 189.75,39.96 189.85,39.96 190.33,40.44 190.57,40.44 190.82,40.19 190.82,39.96 190.34,39.48 190.34,39.37 190.5,39.21 190.61,39.21 191.09,39.69 191.32,39.69 191.57,39.43 191.57,39.2 191.1,38.72 191.1,38.61 191.26,38.45 191.36,38.45 191.52,38.61 191.75,38.61 192.57,37.79 192.57,37.48 192.35,37.26 192.01,37.26 191.9,37.15 v1(191.9,36.88)
  BOTTOM w0.089: U6.AV46 150.06,79.66 v1(149.61,80.11)
  BOTTOM w0.102: JDIMM2.29 191.8,35.26 191.61,35.45 191.61,35.72 191.28,36.04 191.28,37.09 191.42,37.22 191.78,37.22 191.9,37.1 v1(191.9,36.88)
DDR_B_DQS2: length 85.5
  IN1 w0.076: v1(197.38,36.88) 197.6,37.09 197.74,37.09 198.05,37.41 198.05,37.78 186.67,49.16 164.51,49.16 155.97,57.7 155.97,59.91 155.81,60.08 155.08,60.08 155,60.15 155,60.38 155.08,60.46 155.81,60.46 155.97,60.62 155.97,60.98 155.81,61.14 154.79,61.14 154.71,61.22 154.71,61.45 154.79,61.53 155.81,61.53 155.97,61.69 155.97,62.05 155.81,62.21 155.07,62.21 154.99,62.29 154.99,62.52 155.07,62.59 155.81,62.59 155.97,62.76 155.97,66.43 153.89,68.51 150.44,68.51 149.01,69.95 149.01,71.9 148.82,72.09 148.47,72.09 148.31,72.26 v1(148.31,72.29)
  BOTTOM w0.089: U6.BE48 148.7,74.81 148.7,75.1 148.73,75.13 148.84,75.13 149.07,74.91 149.07,73.59 149.02,73.54 149.02,72.34 148.66,71.98 148.44,71.98 148.31,72.11 v1(148.31,72.29)
  BOTTOM w0.102: JDIMM2.47 197.2,35.32 196.99,35.53 196.91,35.53 196.83,35.61 196.83,37.02 197,37.19 197.24,37.19 197.38,37.05 v1(197.38,36.88)
DDR_B_DQS3: length 86
  IN1 w0.076: v1(202.54,29.45) 202.54,29.68 202.37,29.86 202.12,29.86 201.9,30.07 201.9,34.66 203.24,35.99 203.24,37.88 189.13,51.98 169.66,51.98 159.23,62.41 159.23,68.24 157.98,69.5 157.04,70.43 156.13,70.43 154.97,71.58 152.64,71.58 v1(152.41,71.35)
  BOTTOM w0.089: U6.BE43 152.32,74.44 152.32,73.11 152.02,72.8 152.02,71.75 v1(152.41,71.35)
  BOTTOM w0.102: JDIMM2.64 202.3,27.08 202.02,27.36 202.02,29.65 202.1,29.73 202.47,29.73 202.54,29.65 v1(202.54,29.45)
DDR_B_DQS4: length 98.7
  IN1 w0.076: v1(226.67,36.9) 226.98,37.2 227.22,37.2 227.43,37.41 227.43,37.76 226.92,38.27 226.92,39.11 224.25,41.79 206.23,41.79 190.97,57.05 177.25,57.05 176.59,57.71 176.36,57.71 175.92,57.27 175.82,57.27 175.65,57.44 175.65,57.54 176.09,57.98 176.09,58.21 175.84,58.46 175.6,58.46 175.17,58.03 175.06,58.03 174.9,58.19 174.9,58.3 175.33,58.73 175.33,58.97 175.08,59.22 174.85,59.22 174.41,58.78 174.31,58.78 174.14,58.95 174.14,59.05 174.58,59.49 174.58,59.72 174.33,59.97 174.09,59.97 173.66,59.54 173.55,59.54 173.39,59.7 173.39,59.81 173.82,60.24 173.82,60.48 173.57,60.73 173.34,60.73 172.9,60.29 172.8,60.29 172.63,60.46 172.63,60.56 173.07,61 173.07,61.23 169.8,64.5 169.8,69.75 169.87,69.83 170.1,69.83 170.27,69.99 170.27,70.35 170.1,70.51 169.87,70.51 169.8,70.59 169.8,70.82 169.87,70.9 170.1,70.9 170.27,71.06 170.27,71.42 170.1,71.58 169.87,71.58 169.8,71.66 169.8,73.91 170.04,74.15 170.04,76.16 169.89,76.31 169.89,76.75 170.5,77.36 170.5,77.99 170.83,78.32 170.83,78.89 v1(171.22,79.28)
  BOTTOM w0.089: v1(171.22,79.28) 170.9,78.96 U6.AW15
  BOTTOM w0.102: v1(226.67,36.9) 226.67,37.06 226.57,37.17 226.32,37.17 226.23,37.07 226.23,35.71 226.6,35.34 JDIMM2.137
DDR_B_DQS5: length 100.1
  IN1 w0.076: v1(230.85,29.39) 230.85,29.23 230.99,29.08 231.23,29.08 231.31,29.16 231.31,30.51 231.47,30.68 231.91,30.68 232.04,30.8 232.04,31.01 231.91,31.14 231.29,31.14 231.09,31.34 231.09,31.62 231.29,31.82 231.81,31.82 231.9,31.91 231.9,32.11 232.45,32.65 232.45,38.17 226.01,44.6 207.4,44.6 192.14,59.87 180.99,59.87 173.95,66.9 173.95,72.55 173.98,72.58 173.98,75.89 173.49,76.38 173.49,78.89 v1(173.1,79.28)
  BOTTOM w0.089: v1(173.1,79.28) 172.78,78.96 U6.AW12
  BOTTOM w0.102: JDIMM2.154 231.7,27.12 231.7,27.12 231.55,27.28 231.55,27.82 232.04,28.32 232.04,28.92 231.71,29.24 230.99,29.24 v1(230.85,29.39)
DDR_B_DQS6: length 98.7
  IN1 w0.076: v1(237.73,36.9) 237.73,37.11 237.86,37.24 238.09,37.24 238.31,37.47 238.31,38.61 234.81,42.11 233.14,42.11 232.68,42.58 232.68,42.68 233.34,43.35 233.34,43.58 233.09,43.83 232.86,43.83 232.19,43.17 232.09,43.17 231.92,43.33 231.92,43.44 232.59,44.1 232.59,44.34 232.34,44.59 232.1,44.59 231.44,43.92 231.33,43.92 231.17,44.09 231.17,44.19 231.83,44.86 231.83,45.09 231.58,45.34 231.35,45.34 230.68,44.68 230.58,44.68 230.41,44.84 230.41,44.95 231.08,45.61 231.08,45.85 230.82,46.1 230.59,46.1 229.93,45.44 229.82,45.44 229.66,45.6 229.66,45.71 230.32,46.37 230.32,46.6 230.07,46.85 229.84,46.85 229.17,46.19 229.07,46.19 227.53,47.73 208.69,47.73 192.59,63.83 187.09,63.83 179.43,71.49 177.99,72.93 177.99,73.6 177.42,74.18 177.42,76.32 176.47,77.27 176.47,78.89 v1(176.86,79.28)
  BOTTOM w0.089: v1(176.86,79.28) 176.54,78.96 U6.AW6
  BOTTOM w0.102: v1(237.73,36.9) 237.46,37.17 236.96,37.17 236.61,36.82 236.61,35.64 236.8,35.45 JDIMM2.171
DDR_B_DQS7: length 105.9
  IN1 w0.076: v1(178.48,84.12) 178.92,83.68 180.76,83.68 181.9,82.55 181.9,78.47 181.37,77.93 180.83,77.93 180.25,77.35 180.25,74.65 188.18,66.72 194.36,66.72 195.02,66.06 195.02,65.54 210.02,50.55 230.36,50.55 237.04,43.87 238.01,43.87 242.83,39.05 242.83,32.11 241.39,30.67 241.39,29.26 241.77,28.87 241.9,28.87 v1(242.14,28.63)
  BOTTOM w0.089: U6.AL3 178.83,84.47 v1(178.48,84.12)
  BOTTOM w0.102: JDIMM2.188 241.9,27.25 241.71,27.45 241.71,28.77 241.81,28.88 241.89,28.88 v1(242.14,28.63)
DDR_B_DQS#0: length 94.8
  IN1 w0.076: v1(140.96,87.96) 140.74,87.74 140.59,87.74 140.36,87.51 140.36,86.79 140.78,86.37 140.78,63.61 161.83,42.56 173.56,42.56 183.91,32.21 183.91,31.83 185.04,30.71 185.04,30.31 185.66,29.69 185.69,29.69 v1(185.93,29.45)
  BOTTOM w0.089: U6.AD52 145.62,88.95 145.53,89.03 145.53,89.21 145.31,89.43 142.85,89.43 142.18,88.76 142.18,88.76 141.37,87.96 v1(140.96,87.96)
  BOTTOM w0.102: JDIMM2.10 186.1,27.25 186.28,27.44 186.28,28.15 186.51,28.38 186.51,29.61 186.37,29.75 186.23,29.75 v1(185.93,29.45)
DDR_B_DQS#1: length 92.5
  IN1 w0.076: v1(191.9,37.64) 191.9,37.57 192.06,37.41 192.29,37.41 192.42,37.54 192.42,37.73 191.69,38.45 191.58,38.45 191.43,38.3 191.19,38.3 190.94,38.55 190.94,38.79 191.42,39.26 191.42,39.37 191.26,39.53 191.15,39.53 190.67,39.06 190.44,39.06 190.19,39.31 190.19,39.54 190.67,40.02 190.67,40.13 190.5,40.29 190.4,40.29 189.92,39.81 189.68,39.81 189.43,40.06 189.43,40.3 189.91,40.77 189.91,40.88 189.75,41.04 189.64,41.04 189.16,40.57 188.93,40.57 188.68,40.82 188.68,41.05 189.16,41.53 189.16,41.64 188.99,41.8 188.89,41.8 188.41,41.32 188.17,41.32 187.92,41.57 187.92,41.81 188.4,42.28 188.4,42.39 188.24,42.55 188.13,42.55 187.65,42.08 187.42,42.08 183.45,46.04 163.2,46.04 144.54,64.7 144.54,75.99 146.19,77.65 148.87,77.65 149.03,77.81 149.03,80.37 149.17,80.51 149.31,80.51 v1(149.61,80.81)
  BOTTOM w0.089: v1(149.61,80.81) 149.64,80.81 150.09,80.36 U6.AU46
  BOTTOM w0.102: JDIMM2.27 191.2,35.28 191.38,35.45 191.38,35.62 191.05,35.94 191.05,37.18 191.32,37.45 191.78,37.45 191.9,37.57 v1(191.9,37.64)
DDR_B_DQS#2: length 85.5
  IN1 w0.076: v1(197.38,37.64) 197.38,37.38 197.52,37.25 197.68,37.25 197.9,37.47 197.9,37.72 186.61,49.01 164.45,49.01 155.82,57.64 155.82,59.85 155.75,59.93 155.01,59.93 154.85,60.09 154.85,60.45 155.01,60.61 155.75,60.61 155.82,60.69 155.82,60.92 155.75,60.99 154.72,60.99 154.56,61.16 154.56,61.51 154.72,61.68 155.75,61.68 155.82,61.75 155.82,61.98 155.75,62.06 155,62.06 154.84,62.22 154.84,62.58 155,62.74 155.75,62.74 155.82,62.82 155.82,66.37 153.83,68.36 150.38,68.36 148.86,69.88 148.86,71.84 148.75,71.94 148.41,71.94 148.31,71.84 v1(148.31,71.59)
  BOTTOM w0.089: U6.BD48 149.23,74.97 149.23,72.25 148.75,71.76 148.47,71.76 v1(148.31,71.59)
  BOTTOM w0.102: v1(197.38,37.64) 197.17,37.42 196.9,37.42 196.6,37.12 JDIMM2.45
DDR_B_DQS#3: length 85.9
  IN1 w0.076: v1(202.54,30.21) 202.34,30.01 202.18,30.01 202.06,30.14 202.06,34.6 203.39,35.93 203.39,37.94 189.19,52.14 169.73,52.14 159.38,62.48 159.38,68.3 157.11,70.58 156.19,70.58 155.03,71.74 152.72,71.74 v1(152.41,72.05)
  BOTTOM w0.089: U6.BD43 152.5,74.96 152.5,72.98 152.23,72.71 152.23,72.23 v1(152.41,72.05)
  BOTTOM w0.102: v1(202.54,30.21) 202.54,30.2 202.3,29.96 202,29.96 201.79,29.75 201.79,27.3 201.7,27.21 JDIMM2.62
DDR_B_DQS#4: length 98.6
  IN1 w0.076: v1(170.28,79.28) 170.67,78.89 170.67,78.38 170.34,78.05 170.34,77.43 169.73,76.82 169.73,76.25 169.89,76.09 169.89,74.21 169.65,73.97 169.65,71.59 169.81,71.43 170.04,71.43 170.12,71.35 170.12,71.12 170.04,71.05 169.81,71.05 169.65,70.88 169.65,70.53 169.81,70.36 170.04,70.36 170.12,70.29 170.12,70.06 170.04,69.98 169.81,69.98 169.65,69.82 169.65,64.44 172.91,61.17 172.91,61.06 172.48,60.63 172.48,60.39 172.73,60.14 172.97,60.14 173.4,60.57 173.51,60.57 173.67,60.41 173.67,60.31 173.24,59.87 173.24,59.64 173.49,59.39 173.72,59.39 174.16,59.82 174.26,59.82 174.42,59.66 174.42,59.55 173.99,59.12 173.99,58.88 174.24,58.63 174.48,58.63 174.91,59.06 175.02,59.06 175.18,58.9 175.18,58.8 174.75,58.36 174.75,58.13 175,57.88 175.23,57.88 175.67,58.31 175.77,58.31 175.94,58.15 175.94,58.04 175.5,57.61 175.5,57.37 175.75,57.12 175.99,57.12 176.42,57.55 176.53,57.55 177.19,56.89 190.9,56.89 206.16,41.63 224.19,41.63 226.77,39.05 226.77,38.21 227.28,37.7 227.28,37.47 227.16,37.35 226.98,37.35 v1(226.67,37.66)
  BOTTOM w0.089: U6.AW16 169.96,78.96 v1(170.28,79.28)
  BOTTOM w0.102: v1(226.67,37.66) 226.67,37.53 226.54,37.4 226.23,37.4 226,37.17 226,35.63 JDIMM2.135
DDR_B_DQS#5: length 100.1
  IN1 w0.076: v1(230.85,28.63) 231.15,28.93 231.29,28.93 231.46,29.1 231.46,30.45 231.54,30.52 231.98,30.52 232.19,30.74 232.19,31.07 231.98,31.29 231.35,31.29 231.24,31.4 231.24,31.56 231.35,31.67 231.88,31.67 232.05,31.85 232.05,32.04 232.6,32.59 232.6,38.23 226.08,44.76 207.46,44.76 192.2,60.02 181.05,60.02 174.1,66.97 174.1,72.49 174.13,72.51 174.13,75.96 173.65,76.44 173.65,78.89 v1(174.04,79.28)
  BOTTOM w0.089: v1(174.04,79.28) 173.72,78.96 U6.AW10
  BOTTOM w0.102: JDIMM2.152 231.1,27.1 231.31,27.31 231.31,27.92 231.81,28.41 231.81,28.82 231.62,29.01 231.01,29.01 230.85,28.85 v1(230.85,28.63)
DDR_B_DQS#6: length 98.7
  IN1 w0.076: v1(175.92,79.28) 176.31,78.89 176.31,77.2 177.27,76.25 177.27,74.11 177.84,73.54 177.84,72.86 179.36,71.34 187.02,63.68 192.53,63.68 208.63,47.58 227.46,47.58 229,46.04 229.24,46.04 229.9,46.7 230.01,46.7 230.17,46.54 230.17,46.43 229.51,45.77 229.51,45.53 229.76,45.28 229.99,45.28 230.65,45.94 230.76,45.94 230.92,45.78 230.92,45.67 230.26,45.01 230.26,44.78 230.51,44.53 230.75,44.53 231.41,45.19 231.52,45.19 231.68,45.03 231.68,44.92 231.02,44.26 231.02,44.02 231.27,43.77 231.5,43.77 232.16,44.43 232.27,44.43 232.43,44.27 232.43,44.16 231.77,43.5 231.77,43.27 232.02,43.02 232.26,43.02 232.92,43.68 233.03,43.68 233.19,43.52 233.19,43.41 232.53,42.75 232.53,42.51 233.08,41.96 234.74,41.96 238.16,38.54 238.16,37.54 238.02,37.4 237.89,37.4 237.73,37.56 v1(237.73,37.66)
  BOTTOM w0.089: v1(175.92,79.28) 175.6,78.96 U6.AW8
  BOTTOM w0.102: JDIMM2.169 236.2,35.45 236.39,35.64 236.39,36.92 236.87,37.4 237.47,37.4 v1(237.73,37.66)
DDR_B_DQS#7: length 105.8
  IN1 w0.076: v1(179.18,84.12) 179.18,84.04 179.38,83.83 180.83,83.83 182.05,82.61 182.05,78.4 181.43,77.78 180.9,77.78 180.4,77.29 180.4,74.72 188.25,66.87 194.43,66.87 195.17,66.13 195.17,65.61 210.08,50.7 230.43,50.7 237.11,44.02 238.08,44.02 242.98,39.12 242.98,32.05 241.54,30.61 241.54,29.32 241.83,29.03 241.96,29.03 242.14,29.21 v1(242.14,29.39)
  BOTTOM w0.089: U6.AL2 179.53,84.47 v1(179.18,84.12)
  BOTTOM w0.102: JDIMM2.186 241.3,27.25 241.49,27.44 241.49,28.86 241.72,29.09 242.08,29.09 242.14,29.16 v1(242.14,29.39)
DDR_B_MA0: length 98.9
  IN3 w0.089: v1(160.88,77.88) 161.41,77.35 162.41,77.35 164.13,75.63 164.13,74.91
  IN3 w0.196: v1(215.34,29.06) 215.8,29.52 216.54,29.52 216.72,29.69 216.72,31.52 216.54,31.7 215.68,31.7 215.5,31.88 215.5,32.3 215.68,32.48 216.37,32.48 216.55,32.66 216.55,33.44 216.37,33.62 214.95,33.62 214.77,33.8 214.77,34.22 214.95,34.4 216.22,34.4 216.39,34.58 216.39,35.05 216.22,35.22 213.34,35.22 213.13,35.44 213.13,40.31 204.23,49.21 203.85,49.6 181.21,49.6 174.8,56.01 173.98,56.01 173.65,56.34 173.65,56.62 173.78,56.75 173.78,57.03 173.5,57.31 173.23,57.31 173.09,57.17 172.82,57.17 172.54,57.45 172.54,57.73 172.67,57.86 172.67,58.13 172.4,58.41 172.12,58.41 171.99,58.28 171.71,58.28 164.79,65.2 164.79,68.47 164.13,69.13 164.13,74.91
  BOTTOM w0.089: v1(160.88,77.88) 160.56,77.56 U6.BA30
  BOTTOM w0.16: v1(215.34,29.06) 214.78,28.49 214.78,27.72 214.9,27.59 JDIMM2.98
DDR_B_MA1: length 101.1
  IN3 w0.089: 165.91,74.9 165.91,75.39 165.78,75.52 165.68,75.52 165.47,75.32 165.37,75.32 165.26,75.43 165.26,75.53 165.46,75.74 165.46,75.84 164.82,76.49 164.82,76.59 165.02,76.8 165.02,76.91 164.91,77.01 164.81,77.01 164.6,76.81 164.5,76.81 164.39,76.92 164.39,77.03 164.59,77.23 164.59,77.34 164.48,77.44 164.38,77.44 164.17,77.24 164.06,77.24 163.96,77.35 163.96,77.46 164.16,77.66 164.16,77.77 163.98,77.95 163.87,77.95 163.79,78.02 163.79,78.72 163.71,78.8 163.55,78.8 163.47,78.72 163.47,78.02 163.4,77.95 163.23,77.95 163.16,78.02 163.16,78.72 163.08,78.8 162.93,78.8 162.85,78.72 162.85,78.02 162.78,77.95 162.62,77.95 162.55,78.02 162.55,78.72 162.47,78.8 162.32,78.8 162.24,78.72 162.24,78.02 162.17,77.95 161.65,77.95 161.45,78.15 161.45,78.91 161.01,79.34 v1(160.88,79.34)
  IN3 w0.196: 165.91,74.9 165.91,73.38 166.09,73.19 166.09,65.98 167.12,64.95 168.02,64.95 180.97,52 193.09,52 193.29,51.8 193.29,51.1 193.48,50.9 193.87,50.9 194.07,51.1 194.07,51.8 194.26,52 194.66,52 194.85,51.8 194.85,51.1 195.05,50.9 195.44,50.9 195.63,51.1 195.63,51.8 195.83,52 196.22,52 196.42,51.8 196.42,51.1 196.61,50.9 197,50.9 197.2,51.1 197.2,51.8 197.39,52 197.79,52 197.98,51.8 197.98,51.1 198.18,50.9 198.57,50.9 198.76,51.1 198.76,51.8 198.96,52 199.35,52 199.55,51.8 199.55,51.1 199.74,50.9 200.13,50.9 200.33,51.1 200.33,51.8 200.52,52 200.91,52 201.11,51.8 201.11,51.1 201.31,50.9 201.7,50.9 201.89,51.1 201.89,51.8 202.09,52 202.49,52 202.69,51.8 202.69,51.1 202.89,50.9 204.39,50.9 214.71,40.58 214.71,38.49 v1(214.25,38.04)
  BOTTOM w0.089: v1(160.88,79.34) 160.5,78.96 U6.AW30
  BOTTOM w0.16: JDIMM2.97 214.6,35.44 214.73,35.57 214.73,37.56 v1(214.25,38.04)
DDR_B_MA2: length 102.1
  IN3 w0.089: v1(160.88,78.52) 160.51,78.14 160.51,77.65 160.71,77.45 160.97,77.45 161.28,77.15 162.34,77.15 163.47,76.02 163.47,74.84
  IN3 w0.196: 163.47,74.84 163.47,65.59 168.86,60.2 168.86,59.93 167.96,59.02 167.96,58.73 168.22,58.46 168.51,58.46 169.42,59.37 169.69,59.37 169.97,59.1 169.97,58.82 169.06,57.91 169.06,57.62 169.33,57.36 169.62,57.36 170.52,58.27 170.8,58.27 171.08,57.99 171.08,57.71 170.17,56.8 170.17,56.52 170.43,56.25 170.72,56.25 171.63,57.16 171.91,57.16 172.18,56.88 172.18,56.61 171.49,55.91 171.49,55.62 171.75,55.36 172.04,55.36 172.74,56.05 173.01,56.05 173.71,55.36 174.53,55.36 180.94,48.94 203.58,48.94 212.47,40.04 212.47,35.17 214.59,33.05 214.59,30.78 214.79,30.59 v1(215.34,30.59)
  BOTTOM w0.089: U6.AY30 160.62,78.26 v1(160.88,78.52)
  BOTTOM w0.16: v1(215.34,30.59) 214.3,29.54 JDIMM2.96
DDR_B_MA3: length 101.2
  IN3 w0.089: 164.78,75.03 164.78,76.07 163.17,77.68 161.64,77.68 161.26,78.07 161.26,78.74 161.05,78.95 160.69,78.95 160.46,79.18 160.46,79.56 v1(160.88,79.98)
  IN3 w0.196: 164.78,75.03 164.78,69.4 165.44,68.74 165.44,65.47 166.96,63.95 167.24,63.95 167.52,64.24 167.8,64.24 168.08,63.96 168.08,63.69 167.79,63.4 167.79,63.12 168.22,62.69 168.5,62.69 168.78,62.98 169.06,62.98 169.34,62.7 169.34,62.43 169.05,62.14 169.05,61.86 169.33,61.59 169.6,61.59 169.89,61.87 170.17,61.87 170.44,61.6 170.44,61.32 170.16,61.03 170.16,60.76 170.43,60.48 170.71,60.48 171,60.77 171.27,60.77 171.55,60.49 171.55,60.21 171.26,59.93 171.26,59.65 171.54,59.37 171.82,59.37 171.95,59.51 172.23,59.51 180.39,51.34 181.09,51.34 181.29,51.15 181.29,50.44 181.48,50.25 181.87,50.25 182.07,50.44 182.07,51.15 182.26,51.34 182.66,51.34 182.85,51.15 182.85,50.44 183.05,50.25 183.53,50.25 183.73,50.44 183.73,51.15 183.92,51.34 184.32,51.34 184.51,51.15 184.51,50.44 184.71,50.25 185.1,50.25 185.29,50.44 185.29,51.15 185.49,51.34 185.88,51.34 186.08,51.15 186.08,50.44 186.27,50.25 186.66,50.25 186.86,50.44 186.86,51.15 187.05,51.34 187.44,51.34 187.64,51.15 187.64,50.44 187.84,50.25 188.33,50.25 188.53,50.44 188.53,51.15 188.72,51.34 189.11,51.34 189.31,51.15 189.31,50.44 189.5,50.25 189.9,50.25 190.09,50.44 190.09,51.15 190.29,51.34 190.68,51.34 190.87,51.15 190.87,50.44 191.07,50.25 191.46,50.25 191.66,50.44 191.66,51.15 191.85,51.34 192.24,51.34 192.44,51.15 192.44,50.44 192.63,50.25 204.12,50.25 213.78,40.59 213.78,40.04 213.78,36.65 213.91,36.51 v1(214.25,36.51)
  BOTTOM w0.089: U6.AV30 160.56,79.66 v1(160.88,79.98)
  BOTTOM w0.16: JDIMM2.95 214,35.35 213.79,35.56 213.79,36.05 v1(214.25,36.51)
DDR_B_MA4: length 102.5
  IN3 w0.089: 161.21,72.35 161.09,72.48 161.09,76.53 160.74,76.88 160.28,76.88 159.57,77.6 159.57,78.91 v1(159.94,79.28)
  IN3 w0.196: 161.21,72.35 161.21,60.85 165.7,56.36 165.7,56.08 164.95,55.34 164.95,55.06 165.23,54.78 165.5,54.78 166.25,55.53 166.53,55.53 166.81,55.25 166.81,54.98 166.06,54.23 166.06,53.95 166.33,53.68 166.61,53.4 173.72,53.4 180.13,46.98 188.09,46.98 188.29,46.79 188.29,46.31 188.48,46.11 188.88,46.11 189.07,46.31 189.07,46.79 189.27,46.98 189.66,46.98 189.85,46.79 189.85,46.31 190.05,46.11 190.44,46.11 190.64,46.31 190.64,46.79 190.83,46.98 191.22,46.98 191.42,46.79 191.42,46.31 191.61,46.11 192,46.11 192.2,46.31 192.2,46.79 192.4,46.98 192.79,46.98 192.98,46.79 192.98,46.31 193.18,46.11 203.64,46.11 209.52,40.23 209.52,37.2 213.94,32.78 213.94,30.78 213.74,30.59 v1(213.11,30.59)
  BOTTOM w0.089: v1(159.94,79.28) 159.62,78.96 U6.AW32
  BOTTOM w0.16: v1(213.11,30.59) 213.64,30.06 213.64,28.1 213.1,27.56 JDIMM2.92
DDR_B_MA5: length 101.2
  IN3 w0.089: 162.52,72.35 162.52,75.32 162.74,75.53 162.74,76.48 162.3,76.92 161.24,76.92 160.9,77.26 160.63,77.26 160.32,77.57 160.32,78.21 v1(159.94,78.58)
  IN3 w0.196: 162.52,72.35 162.52,63.24 162.74,63.02 163.02,63.02 163.93,63.94 164.21,63.94 164.48,63.66 164.48,63.38 163.57,62.47 163.57,62.19 163.85,61.92 164.12,61.92 165.04,62.83 165.31,62.83 165.59,62.55 165.59,62.28 164.68,61.36 164.68,61.09 164.95,60.81 165.23,60.81 166.14,61.72 166.42,61.72 166.7,61.45 166.7,61.17 165.78,60.26 165.78,59.98 166.06,59.7 166.33,59.7 167.25,60.62 167.53,60.62 167.8,60.34 167.8,60.06 166.89,59.15 166.89,58.87 171.06,54.7 174.26,54.7 180.67,48.29 197.61,48.29 197.81,48.09 197.81,47.61 198,47.42 198.4,47.42 198.59,47.61 198.59,48.09 198.79,48.29 199.18,48.29 199.37,48.09 199.37,47.61 199.57,47.42 199.96,47.42 200.16,47.61 200.16,48.09 200.35,48.29 200.74,48.29 200.94,48.09 200.94,47.61 201.13,47.42 201.52,47.42 201.72,47.61 201.72,48.09 201.92,48.29 202.34,48.29 202.54,48.09 202.54,47.59 202.72,47.42 204.18,47.42 210.83,40.77 210.83,40.17 211.02,39.97 211.63,39.97 211.82,39.77 211.82,39.41 211.63,39.21 211.02,39.21 210.83,39.02 210.83,37.88 211.02,37.69 211.46,37.69 v1(211.81,38.04)
  BOTTOM w0.089: v1(159.94,78.58) 159.62,78.26 U6.AY32
  BOTTOM w0.16: v1(211.81,38.04) 212.8,37.05 JDIMM2.91
DDR_B_MA6: length 103.6
  IN3 w0.089: 159.98,72.25 160.13,72.4 160.13,76.76 159.38,77.52 159.38,79.53 159.51,79.66 160.21,79.66 160.34,79.78 160.34,80.29 v1(159.94,80.68)
  IN3 w0.196: 159.98,72.25 159.98,68.02 160.56,67.44 160.56,60.58 161.32,59.82 161.32,59.54 160.87,59.09 160.87,58.91 161.24,58.54 161.42,58.54 161.87,58.99 162.15,58.99 162.43,58.71 162.43,58.44 161.68,57.69 161.68,57.41 161.95,57.13 162.23,57.13 162.98,57.88 163.26,57.88 163.53,57.61 163.53,57.33 162.78,56.58 162.78,56.3 163.06,56.03 163.34,56.03 164.09,56.78 164.36,56.78 164.64,56.5 164.64,56.22 163.89,55.47 163.89,55.2 166.34,52.75 173.45,52.75 179.86,46.33 187.24,46.33 187.44,46.14 187.44,45.65 187.64,45.46 203.37,45.46 208.87,39.96 208.87,36.93 212.2,33.6 212.2,29.98 v1(213.11,29.06)
  BOTTOM w0.089: v1(159.94,80.68) 160.32,81.06 U6.AT30
  BOTTOM w0.16: JDIMM2.90 212.5,28.45 v1(213.11,29.06)
DDR_B_MA7: length 99.9
  IN3 w0.089: 159.33,72.17 159.78,72.62 159.78,76.72 159.14,77.35 159.14,77.73 158.63,78.24 158.63,79.51 158.78,79.66 159.24,79.66 159.47,79.89 159.8,79.89 v1(159.94,80.03)
  IN3 w0.196: v1(210.41,30.59) 211.52,31.69 211.52,33.36 208.22,36.66 208.22,39.69 203.1,44.81 186.84,44.81 186.65,45 186.65,45.48 186.45,45.68 186.06,45.68 185.87,45.48 185.87,45 185.67,44.81 185.28,44.81 185.08,45 185.08,45.48 184.89,45.68 184.5,45.68 184.3,45.48 184.3,45 184.11,44.81 183.72,44.81 183.52,45 183.52,45.48 183.32,45.68 182.93,45.68 182.74,45.48 182.74,45.22 182.61,45.09 182.08,45.09 181.95,45.22 181.95,45.48 181.76,45.68 179.59,45.68 173.17,52.09 166.07,52.09 159.91,58.25 159.91,67.17 159.33,67.75 159.33,72.17
  BOTTOM w0.089: U6.AV32 159.57,79.66 v1(159.94,80.03)
  BOTTOM w0.16: v1(210.41,30.59) 211.47,29.53 211.47,27.6 211.3,27.43 JDIMM2.86
DDR_B_MA8: length 100.5
  IN3 w0.089: v1(159.94,77.88) 159.94,77.49 160.36,77.07 160.82,77.07 161.48,76.41 161.48,72.74 161.87,72.35
  IN3 w0.196: v1(211.81,36.51) 211.13,36.51 210.17,37.47 210.17,40.5 203.91,46.76 197.16,46.76 196.96,46.96 196.96,47.44 196.76,47.64 196.37,47.64 196.18,47.44 196.18,46.96 195.98,46.76 195.59,46.76 195.4,46.96 195.4,47.44 195.2,47.64 194.81,47.64 194.61,47.44 194.61,46.96 194.42,46.76 194.03,46.76 193.83,46.96 193.83,47.44 193.64,47.64 180.4,47.64 173.99,54.05 167.56,54.05 167.36,54.25 167.36,54.64 167.56,54.83 168.67,54.83 169.2,55.36 169.2,55.64 168.92,55.92 168.65,55.92 168.34,55.61 168.07,55.61 167.79,55.89 167.79,56.17 168.09,56.47 168.09,56.75 167.82,57.02 167.54,57.02 166.86,56.34 166.58,56.34 166.3,56.62 166.3,56.89 166.99,57.58 166.99,57.85 166.71,58.13 166.43,58.13 165.78,57.48 165.51,57.48 165.23,57.76 165.23,58.03 165.88,58.68 165.88,58.96 165.6,59.24 165.33,59.24 164.68,58.59 164.4,58.59 164.12,58.86 164.12,59.14 164.77,59.79 164.77,60.06 164.5,60.34 164.22,60.34 163.57,59.69 163.29,59.69 163.02,59.97 163.02,60.24 163.67,60.89 163.67,61.17 163.39,61.45 163.11,61.45 162.46,60.8 162.19,60.8 161.91,61.08 161.91,61.35 162.32,61.76 162.32,62.04 161.87,62.5 161.87,72.35
  BOTTOM w0.089: v1(159.94,77.88) 159.62,77.56 U6.BA32
  BOTTOM w0.16: JDIMM2.89 212.2,35.41 212.33,35.54 212.33,36 v1(211.81,36.51)
DDR_B_MA9: length 102
  IN3 w0.089: 158.67,72.9 158.81,73.03 159.45,73.03 159.57,73.16 159.57,76.59 159.26,76.91 159.05,76.91 158.84,77.12 158.84,77.77 158.44,78.17 158.44,79.9 158.57,80.03 v1(159,80.03)
  IN3 w0.196: 158.67,72.9 158.67,67.67 158.48,67.47 158.32,67.47 158.12,67.28 158.12,66.54 158.32,66.34 159.06,66.34 159.26,66.14 159.26,65.8 159.06,65.61 158.87,65.61 158.67,65.41 158.67,65.02 158.87,64.82 159.06,64.82 159.26,64.63 159.26,64.24 159.06,64.04 158.87,64.04 158.67,63.85 158.67,63.46 158.87,63.26 159.06,63.26 159.26,63.06 159.26,62.67 159.06,62.48 158.87,62.48 158.67,62.28 158.67,61.89 158.87,61.69 159.06,61.69 159.26,61.5 159.26,61.11 159.06,60.91 158.87,60.91 158.67,60.72 158.67,60.33 158.87,60.13 159.06,60.13 159.26,59.93 159.26,59.54 159.06,59.35 158.04,59.35 157.85,59.15 157.85,58.76 158.04,58.57 158.67,58.57 158.88,58.35 158.88,58.08 158.77,57.96 158.77,57.69 159.05,57.41 159.32,57.41 159.44,57.53 159.71,57.53 159.99,57.25 159.99,56.97 159.88,56.86 159.88,56.58 160.15,56.3 160.43,56.3 160.54,56.42 160.82,56.42 161.1,56.14 161.1,55.87 160.98,55.75 160.98,55.48 161.26,55.2 161.54,55.2 161.65,55.31 161.93,55.31 162.2,55.04 162.2,54.76 162.09,54.65 162.09,54.37 162.37,54.09 162.64,54.09 162.76,54.21 163.03,54.21 163.31,53.93 163.31,53.65 163.2,53.54 163.2,53.26 163.47,52.99 163.75,52.99 163.86,53.1 164.14,53.1 164.42,52.82 164.42,52.55 164.3,52.43 164.3,52.16 164.58,51.88 164.86,51.88 164.97,51.99 165.25,51.99 165.8,51.44 172.9,51.44 180.19,44.15 202.83,44.15 207.56,39.42 207.56,36.39 210.86,33.09 210.86,32.43 210.55,32.11 v1(210.41,32.11)
  BOTTOM w0.089: U6.AU32 159.48,80.25 159.26,80.03 v1(159,80.03)
  BOTTOM w0.16: JDIMM2.85 211,32.7 v1(210.41,32.11)
DDR_B_MA10: length 105.4
  IN3 w0.089: 168.31,73.87 168.17,74.02 167.54,74.02 167.12,74.44 167.12,75.94 165.21,77.86 165.21,79.45 165.42,79.66 165.75,79.66 165.99,79.9 165.99,80.28 v1(165.58,80.68)
  IN3 w0.196: v1(218.62,38.04) 217.89,38.04 217.4,38.53 217.4,40.66 204.11,53.95 186.9,53.95 186.7,54.15 186.7,56.56 186.51,56.76 186.11,56.76 185.92,56.56 185.92,54.15 185.72,53.95 185.33,53.95 185.14,54.15 185.14,56.56 184.94,56.76 184.55,56.76 184.35,56.56 184.35,54.15 184.16,53.95 183.77,53.95 183.57,54.15 183.57,56.56 183.38,56.76 182.99,56.76 182.79,56.56 182.79,54.15 182.59,53.95 182.21,53.95 181.18,54.98 181.18,55.26 181.78,55.85 181.78,56.13 181.5,56.4 181.22,56.4 181.01,56.18 180.73,56.18 180.45,56.46 180.45,56.74 180.67,56.96 180.67,57.23 180.39,57.51 180.12,57.51 179.9,57.29 179.62,57.29 179.35,57.57 179.35,57.84 179.56,58.06 179.56,58.34 179.29,58.62 179.01,58.62 178.79,58.4 178.52,58.4 178.24,58.67 178.24,58.95 178.46,59.17 178.46,59.45 178.18,59.72 177.9,59.72 177.69,59.5 177.41,59.5 177.13,59.78 177.13,60.06 177.35,60.28 177.35,60.55 177.07,60.83 176.8,60.83 176.58,60.61 176.3,60.61 176.03,60.89 176.03,61.16 176.25,61.38 176.25,61.66 175.97,61.93 175.69,61.93 175.47,61.72 175.2,61.72 174.92,61.99 174.92,62.27 175.14,62.49 175.14,62.76 168.9,69 168.9,71.92 168.58,72.24 168.58,73.6 168.31,73.87
  BOTTOM w0.089: U6.AU23 165.26,80.36 v1(165.58,80.68)
  BOTTOM w0.16: v1(218.62,38.04) 217.6,37.02 JDIMM2.107
DDR_B_MA11: length 100.3
  IN3 w0.089: 158.02,73.1 158.52,73.6 158.52,77.76 158.06,78.21 v1(158.06,78.58)
  IN3 w0.196: v1(210.41,29.06) 209.89,29.58 209.89,33.13 206.91,36.12 206.91,39.15 202.56,43.5 179.92,43.5 172.63,50.79 164.75,50.79 157.2,58.34 157.2,59.96 157.39,60.16 157.83,60.16 158.02,60.35 158.02,60.74 157.83,60.94 157.39,60.94 157.2,61.13 157.2,61.53 157.39,61.72 157.83,61.72 158.02,61.92 158.02,62.31 157.83,62.5 157.39,62.5 157.2,62.7 157.2,63.09 157.39,63.29 157.83,63.29 158.02,63.48 158.02,63.87 157.83,64.07 157.39,64.07 157.2,64.26 157.2,64.65 157.39,64.85 157.83,64.85 158.02,65.05 158.02,65.44 157.83,65.63 157.39,65.63 157.2,65.83 157.2,67.71 157.39,67.9 157.83,67.9 158.02,68.1 158.02,68.4 157.83,68.59 157.39,68.59 157.2,68.79 157.2,69.18 157.39,69.37 157.83,69.37 158.02,69.57 158.02,73.1
  BOTTOM w0.089: v1(158.06,78.58) 157.74,78.26 U6.AY35
  BOTTOM w0.16: JDIMM2.84 210.7,27.57 210.97,27.85 210.97,28.5 v1(210.41,29.06)
