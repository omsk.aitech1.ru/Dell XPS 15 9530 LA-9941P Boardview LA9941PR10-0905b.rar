# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS4: length 58.9
  IN4 w0.076: v1(172.73,71.63) 172.97,71.88 173.1,71.88 173.19,71.79 173.19,69.29 173.03,69.13 173.03,62.39 159.66,49.02 159.66,48.79 159.97,48.48 159.97,48.38 159.8,48.21 159.7,48.21 159.39,48.52 159.16,48.52 158.91,48.26 158.91,48.03 159.21,47.73 159.21,47.62 159.05,47.46 158.94,47.46 158.64,47.76 158.4,47.76 158.08,47.43 158.08,47.19 158.36,46.91 158.36,46.8 158.2,46.64 158.09,46.64 157.81,46.92 157.58,46.92 157.32,46.67 157.32,46.44 157.61,46.15 157.61,46.05 157.44,45.88 157.34,45.88 157.05,46.17 156.82,46.17 156.57,45.92 156.57,45.68 156.85,45.4 156.85,45.29 156.69,45.13 156.58,45.13 156.3,45.41 156.06,45.41 155.81,45.16 155.81,44.93 156.1,44.64 156.1,44.54 155.93,44.37 155.83,44.37 155.54,44.66 155.31,44.66 155.06,44.41 155.06,44.17 155.34,43.89 155.34,43.78 152.54,40.98 152.54,39.85 152.46,39.78 152.23,39.78 152.07,39.61 152.07,39.26 152.23,39.09 152.46,39.09 152.54,39.01 152.54,37.52 152.46,37.44 152.21,37.44 151.98,37.67 v1(151.98,37.78)
  BOTTOM w0.089: v1(172.73,71.63) 172.34,72.03 172.34,73.62 172.64,73.93 172.64,74.44 U6.BE12
  BOTTOM w0.102: v1(151.98,37.78) 151.98,37.52 152.08,37.42 152.38,37.42 152.64,37.16 152.64,35.92 152.1,35.38 JDIMM1.137
DDR_A_DQS5: length 59.8
  IN4 w0.076: v1(176.23,72.56) 176.5,72.3 176.6,72.3 176.8,72.11 176.8,61.73 165.04,49.97 165.04,48.71 157.46,41.14 157.46,32.09 157.67,31.88 157.67,29.09 157.51,28.93 157.4,28.93 v1(157.09,28.63)
  BOTTOM w0.089: v1(176.23,72.56) 176.13,72.46 175.94,72.46 175.81,72.6 175.81,73.45 176.12,73.77 176.12,74.3 175.9,74.52 175.9,74.93 175.57,75.26 U6.BD7
  BOTTOM w0.102: v1(157.09,28.63) 157.09,28.68 156.96,28.81 156.78,28.81 156.67,28.7 156.67,27.67 157.2,27.14 JDIMM1.154
DDR_A_DQS6: length 68
  IN4 w0.076: v1(162.55,37.02) 162.55,37.25 162.35,37.44 162.09,37.44 161.83,37.7 161.83,41.09 169.98,49.23 169.98,49.34 169.47,49.85 169.47,50.14 169.67,50.34 169.95,50.34 170.46,49.83 170.57,49.83 170.73,49.99 170.73,50.1 170.08,50.75 170.08,51.03 170.28,51.23 170.57,51.23 171.22,50.58 171.33,50.58 171.49,50.75 171.49,50.85 170.84,51.5 170.84,51.79 171.04,51.99 171.32,51.99 171.97,51.34 172.08,51.34 172.24,51.5 172.24,51.61 171.59,52.26 171.59,52.54 171.79,52.74 172.08,52.74 172.73,52.09 172.84,52.09 173,52.26 173,52.36 172.35,53.01 172.35,53.3 183.5,64.45 183.5,77.33 183.3,77.53 181.89,77.53 181.82,77.46 181.82,77.19 181.88,77.13 v1(182.09,77.13)
  BOTTOM w0.089: U6.BA2 179.51,78.02 179.35,77.86 179.35,77.74 179.4,77.68 179.88,77.68 179.99,77.57 180.42,77.57 180.63,77.78 181.57,77.78 181.88,77.47 181.88,77.23 181.98,77.13 v1(182.09,77.13)
  BOTTOM w0.102: v1(162.55,37.02) 162.55,37.23 162.39,37.38 162.23,37.38 162.14,37.29 162.14,35.32 162.3,35.16 JDIMM1.171
DDR_A_DQS7: length 71.5
  IN4 w0.076: v1(178.54,80.87) 178.98,80.44 179.09,80.44 179.49,80.44 179.65,80.6 184.82,80.6 186.47,78.95 186.47,63.22 175.97,52.71 175.97,50.67 167.68,42.37 167.68,32.99 166.93,32.24 166.93,29.1 167.17,28.86 167.44,28.86 v1(167.68,28.63)
  BOTTOM w0.089: v1(178.54,80.87) 178.83,81.15 U6.AT3
  BOTTOM w0.102: JDIMM1.188 167.4,27.12 167.2,27.32 167.2,28.68 167.34,28.81 167.49,28.81 v1(167.68,28.63)
DDR_A_DQS#0: length 79.4
  IN4 w0.076: v1(112.22,29.6) 112.22,29.35 112.08,29.21 111.38,29.21 111.16,29.42 111.16,38.42 120.57,47.83 120.57,48.84 134.66,62.92 134.66,67.77 135.16,68.28 135.16,72.61 136.95,74.4 136.95,81.46 141.07,85.58 142.59,85.58 142.77,85.76 145.29,85.76 145.42,85.62 v1(145.42,85.29)
  BOTTOM w0.076: U6.AJ52 145.42,85.34 v1(145.42,85.29)
  BOTTOM w0.102: v1(112.22,29.6) 112.06,29.45 111.82,29.45 111.49,29.12 111.49,27.87 111.6,27.76 JDIMM1.10
DDR_A_DQS#1: length 72.8
  IN4 w0.076: v1(145.42,82.85) 145.23,82.66 143.99,82.66 143.98,82.67 142.15,82.67 139.77,80.29 139.77,72.66 139.69,72.58 139.69,72.08 138.03,70.43 138.03,67.11 137.48,66.55 137.48,65.1 137.9,64.68 137.9,61.16 119.07,42.34 119.07,41.44 119,41.37 118.1,41.37 117.9,41.17 117.9,40.88 118.1,40.68 119.11,40.68 119.23,40.57 119.23,40.41 119.11,40.3 117.03,40.3 116.83,40.1 116.83,39.81 117.03,39.61 118.99,39.61 119.11,39.49 119.11,39.32 118.99,39.19 116.69,39.19 116.52,39.03 116.52,37.43 116.69,37.27 117.04,37.27 117.15,37.16 v1(117.15,37.02)
  BOTTOM w0.076: U6.AP53 145.07,82.5 v1(145.42,82.85)
  BOTTOM w0.102: v1(117.15,37.02) 117.15,37.11 117.33,37.29 117.51,37.29 117.62,37.19 117.62,36 117.19,35.58 117.07,35.58 116.7,35.21 JDIMM1.27
DDR_A_DQS#2: length 65.1
  IN4 w0.076: v1(145.42,79.6) 145.16,79.33 143.01,79.33 142.69,79.01 142.69,70.84 141.01,69.16 141.01,60.07 128.14,47.21 128.14,45.98 127.65,45.49 127.65,45.25 127.97,44.93 127.97,44.83 127.81,44.67 127.7,44.67 127.38,44.99 127.15,44.99 126.89,44.73 126.89,44.5 127.21,44.18 127.21,44.07 127.05,43.91 126.94,43.91 126.62,44.23 126.39,44.23 126.14,43.98 126.14,43.74 126.43,43.45 126.43,43.29 126.32,43.18 126.16,43.18 125.87,43.48 125.64,43.48 125.38,43.22 125.38,42.99 126.19,42.18 126.19,42.02 126.08,41.91 125.92,41.91 125.14,42.69 124.85,42.69 124.65,42.49 124.65,42.21 125.44,41.42 125.44,41.26 125.22,41.04 125.11,41.04 124.79,41.36 124.56,41.36 124.31,41.11 124.31,40.87 124.63,40.55 124.63,40.45 123.25,39.07 123.25,37.54 123.2,37.48 123.08,37.48 v1(122.78,37.78)
  BOTTOM w0.102: U6.AW52 145.42,79.54 v1(145.42,79.6) ; v1(122.78,37.78) 122.51,37.52 122.36,37.52 122.1,37.25 JDIMM1.45
DDR_A_DQS#3: length 64.7
  IN4 w0.076: v1(128.33,29.6) 128.63,29.3 128.76,29.3 128.81,29.36 128.81,30.54 128.98,30.7 129.22,30.7 129.3,30.78 129.3,31.01 129.22,31.08 128.98,31.08 128.81,31.25 128.81,39 131.11,41.3 131.11,45.97 143.98,58.84 143.98,67.82 146.71,70.56 146.71,73.6 147.74,74.63 147.74,76.85 147.99,77.1 148.7,77.1 149.05,77.45 149.05,78.29 149.19,78.43 149.33,78.43 v1(149.61,78.71)
  BOTTOM w0.089: v1(149.61,78.71) 149.63,78.71 U6.AY46
  BOTTOM w0.102: v1(128.33,29.6) 128.19,29.46 127.75,29.46 127.37,29.08 127.37,27.22 127.2,27.05 JDIMM1.62
DDR_A_DQS#4: length 58.9
  IN4 w0.076: v1(151.98,37.02) 152.25,37.29 152.53,37.29 152.69,37.45 152.69,39.08 152.53,39.24 152.3,39.24 152.22,39.32 152.22,39.55 152.3,39.62 152.53,39.62 152.69,39.79 152.69,40.91 155.49,43.72 155.49,43.95 155.21,44.23 155.21,44.34 155.37,44.5 155.48,44.5 155.76,44.22 156,44.22 156.25,44.47 156.25,44.71 155.97,44.99 155.97,45.1 156.13,45.26 156.24,45.26 156.52,44.98 156.75,44.98 157,45.23 157,45.46 156.72,45.75 156.72,45.85 156.88,46.02 156.99,46.02 157.27,45.73 157.51,45.73 157.76,45.98 157.76,46.22 157.48,46.5 157.48,46.61 157.64,46.77 157.75,46.77 158.03,46.49 158.26,46.49 158.51,46.74 158.51,46.97 158.23,47.26 158.23,47.37 158.47,47.61 158.57,47.61 158.88,47.31 159.11,47.31 159.36,47.56 159.36,47.79 159.06,48.09 159.06,48.2 159.22,48.36 159.33,48.36 159.63,48.06 159.87,48.06 160.12,48.31 160.12,48.55 159.82,48.85 159.82,48.96 173.18,62.32 173.18,69.06 173.34,69.22 173.34,71.85 173.16,72.03 173.01,72.03 v1(172.73,72.31)
  BOTTOM w0.089: U6.BD12 172.81,74.97 172.81,73.78 172.55,73.53 172.55,72.48 v1(172.73,72.31)
  BOTTOM w0.102: v1(151.98,37.02) 152.15,37.19 152.28,37.19 152.41,37.07 152.41,36.02 151.87,35.48 151.76,35.48 151.5,35.22 JDIMM1.135
DDR_A_DQS#5: length 59.6
  IN4 w0.076: v1(157.09,29.39) 157.09,29.16 157.17,29.08 157.45,29.08 157.52,29.15 157.52,31.82 157.31,32.02 157.31,41.2 164.88,48.78 164.88,50.04 176.64,61.8 176.64,72.04 176.54,72.14 176.35,72.14 176.23,72.03 v1(176.23,71.86)
  BOTTOM w0.089: v1(176.23,71.86) 175.59,72.51 175.59,73.55 175.95,73.91 175.95,74.2 175.57,74.58 U6.BE7
  BOTTOM w0.102: JDIMM1.152 156.6,27.35 156.44,27.51 156.44,28.8 156.69,29.04 157.01,29.04 157.09,29.12 v1(157.09,29.39)
DDR_A_DQS#6: length 67.9
  IN4 w0.076: v1(181.46,77.13) 181.67,77.34 181.67,77.52 181.82,77.68 183.36,77.68 183.65,77.39 183.65,64.38 172.5,53.23 172.5,53.08 173.15,52.43 173.15,52.19 172.9,51.94 172.66,51.94 172.01,52.59 171.86,52.59 171.75,52.48 171.75,52.32 172.4,51.67 172.4,51.44 172.14,51.19 171.91,51.19 171.26,51.83 171.1,51.83 170.99,51.72 170.99,51.57 171.64,50.92 171.64,50.68 171.39,50.43 171.15,50.43 170.5,51.08 170.35,51.08 170.24,50.97 170.24,50.81 170.89,50.16 170.89,49.93 170.63,49.67 170.4,49.67 169.89,50.18 169.73,50.18 169.62,50.07 169.62,49.91 170.13,49.41 170.13,49.17 161.99,41.03 161.99,37.76 162.16,37.6 162.36,37.6 v1(162.55,37.78)
  BOTTOM w0.089: v1(181.46,77.13) 181.65,77.33 181.65,77.39 181.48,77.57 180.72,77.57 180.56,77.4 179.92,77.4 179.81,77.52 179.34,77.52 U6.BA3
  BOTTOM w0.102: JDIMM1.169 161.7,35.25 161.91,35.46 161.91,37.39 162.13,37.61 162.38,37.61 v1(162.55,37.78)
DDR_A_DQS#7: length 71.7
  IN4 w0.076: v1(179.18,80.87) 179.18,80.67 179.26,80.59 179.42,80.59 179.59,80.75 184.89,80.75 186.62,79.02 186.62,63.15 176.12,52.65 176.12,50.6 167.83,42.31 167.83,32.93 167.08,32.18 167.08,29.17 167.23,29.01 167.57,29.01 167.68,29.12 v1(167.68,29.39)
  BOTTOM w0.089: U6.AT2 179.53,81.22 v1(179.18,80.87)
  BOTTOM w0.102: v1(167.68,29.39) 167.68,29.24 167.47,29.04 167.24,29.04 166.97,28.77 166.97,27.28 166.8,27.1 JDIMM1.186
DDR_A_MA0: length 60
  IN4 w0.117: v1(162.98,70.21) 163.82,69.36 163.82,65.35 142.14,43.67 142.14,40.2 141.53,39.59 141.53,30.61 141.26,30.34 141.26,28.75 v1(140.76,28.25)
  BOTTOM w0.089: v1(162.98,70.21) 162.07,71.11 162.07,75.15 U6.BD28
  BOTTOM w0.16: JDIMM1.98 140.4,27.15 140.28,27.27 140.28,27.77 v1(140.76,28.25)
DDR_A_MA1: length 64.3
  IN4 w0.117: v1(140.17,36.64) 140.59,36.64 140.69,36.54 140.69,35.27 140.57,35.15 140.35,35.15 140.23,35.04 140.23,34.8 140.35,34.69 140.57,34.69 140.69,34.57 140.69,34.34 140.57,34.22 139.53,34.22 139.43,34.12 139.43,33.85 139.53,33.75 140.57,33.75 140.69,33.63 140.69,33.42 140.59,33.31 138.95,33.31 138.85,33.42 138.85,34.19 139.73,35.08 139.73,43.76 142.43,46.45 143.13,46.45 162.1,65.42 162.1,67.13 162.55,67.58 162.55,71.51 162.66,71.61 v1(162.98,71.61)
  BOTTOM w0.089: U6.BD27 162.26,75.15 162.26,72.32 v1(162.98,71.61)
  BOTTOM w0.16: v1(140.17,36.64) 140.61,36.2 140.61,35.69 140.1,35.17 JDIMM1.97
DDR_A_MA2: length 62.3
  IN4 w0.117: v1(162.98,68.81) 163.4,68.38 163.4,65.52 141.72,43.85 141.72,40.38 141.11,39.77 141.11,32.05 141,31.93 139.58,31.93 139.48,31.83 139.48,31.57 139.58,31.47 141,31.47 141.11,31.35 141.11,31.05 141.01,30.95 140.45,30.95 140.34,30.84 140.34,29.87 140.45,29.77 v1(140.76,29.77)
  BOTTOM w0.089: U6.BF28 161.76,71.25
  BOTTOM w0.16: v1(140.76,29.77) 139.8,28.81 JDIMM1.96 ; v1(162.98,68.81) 161.76,70.03 161.76,71.25
DDR_A_MA3: length 63.1
  IN4 w0.117: v1(162.98,67.41) 162.52,66.95 162.52,66.31 162.64,66.19 162.87,66.19 162.98,66.09 162.98,65.83 162.87,65.72 162.64,65.72 162.52,65.61 162.52,65.24 143.12,45.84 142.95,45.84 142.77,46.03 142.6,46.03 142.44,45.86 142.44,45.7 142.62,45.51 142.62,45.34 142.46,45.18 142.29,45.18 142.11,45.37 141.94,45.37 141.77,45.2 141.77,45.03 141.96,44.85 141.96,44.68 141.8,44.52 141.63,44.52 141.44,44.7 141.28,44.7 141.11,44.54 141.11,44.37 141.3,44.19 141.3,43.78 141.2,43.68 140.26,43.68 140.16,43.58 140.16,43.35 140.26,43.25 141.2,43.25 141.3,43.15 141.3,42.88 141.2,42.77 140.26,42.77 140.16,42.67 140.16,42.41 140.26,42.31 141.2,42.31 141.3,42.2 141.3,41.94 141.2,41.84 140.26,41.84 140.16,41.74 140.16,41.47 140.26,41.37 141.2,41.37 141.3,41.27 141.3,41.01 141.2,40.9 140.26,40.9 140.16,40.8 140.16,40.54 140.26,40.44 140.72,40.44 140.82,40.34 140.82,40.07 140.72,39.97 140.26,39.97 140.16,39.87 140.16,39.6 140.26,39.5 140.57,39.5 140.69,39.39 140.69,37.91 140.59,37.81 140.27,37.81 140.17,37.91 v1(140.17,38.17)
  BOTTOM w0.089: 161.45,70.04 161.45,74.45 U6.BE28
  BOTTOM w0.16: JDIMM1.95 139.5,37.5 v1(140.17,38.17) ; v1(162.98,67.41) 161.44,68.94 161.44,70.03 161.45,70.04
DDR_A_MA4: length 60.8
  IN4 w0.117: v1(137.46,29.01) 138.01,29.56 138.01,32.63 137.89,32.75 137.65,32.75 137.53,32.88 137.53,33.09 137.65,33.22 137.89,33.22 138.01,33.33 138.01,33.57 137.89,33.68 137.65,33.68 137.53,33.81 137.53,34.03 137.65,34.15 137.89,34.15 138.01,34.27 138.01,34.5 137.88,34.62 137.65,34.62 137.53,34.75 137.53,43.93 144.13,50.54 144.84,50.54 160.41,66.11 160.41,67.98 v1(160.54,68.11)
  BOTTOM w0.089: U6.BF32 159.32,72.94
  BOTTOM w0.16: v1(160.54,68.11) 159.32,69.33 159.32,72.94 ; JDIMM1.92 138.6,27.86 v1(137.46,29.01)
DDR_A_MA5: length 61.4
  IN4 w0.117: v1(138.37,36.64) 138.37,36.9 138.47,37 138.79,37 138.89,36.9 138.89,35.43 138.45,34.98 138.1,34.98 137.95,35.14 137.95,43.76 144.3,50.12 145.01,50.12 160.83,65.94 160.83,67.65 161.25,68.07 161.25,76.77 161.38,76.9 162.49,76.9 162.62,76.77 162.62,75.93 162.49,75.81 v1(162.16,75.81)
  BOTTOM w0.089: U6.BC27 162.51,76.16 v1(162.16,75.81)
  BOTTOM w0.16: JDIMM1.91 138.3,35.18 137.9,35.57 137.9,36.29 138.25,36.64 v1(138.37,36.64)
DDR_A_MA6: length 62.6
  IN4 w0.117: v1(137.46,27.48) 138.43,28.46 138.43,30.32 138.55,30.44 138.93,30.44 139.05,30.56 139.05,30.79 138.93,30.91 138.55,30.91 138.43,31.02 138.43,31.26 138.55,31.37 138.93,31.37 139.05,31.49 139.05,31.72 138.93,31.84 138.55,31.84 138.43,31.96 138.43,32.19 138.55,32.31 138.93,32.31 139.05,32.43 139.05,32.66 138.93,32.78 138.55,32.78 138.43,32.89 138.43,34.37 139.31,35.25 139.31,43.93 142.25,46.87 142.96,46.87 161.68,65.59 161.68,67.3 162.13,67.76 162.13,72.84 162.3,73.01 v1(162.98,73.01)
  BOTTOM w0.089: U6.BF27 162.57,73.41 v1(162.98,73.01)
  BOTTOM w0.16: v1(137.46,27.48) 138,26.94 JDIMM1.90
DDR_A_MA7: length 62.6
  IN4 w0.117: v1(160.54,69.51) 160.54,69.65 160.41,69.78 160.12,69.78 159.99,69.65 159.99,66.29 144.66,50.96 143.95,50.96 137.1,44.11 137.1,31.86 137.22,31.75 137.46,31.75 137.59,31.62 137.59,31.41 137.46,31.28 137.22,31.28 137.1,31.16 137.1,30.66 137.23,30.53 v1(137.46,30.53)
  BOTTOM w0.089: U6.BC28 161.25,75.66 161.25,70.22 160.63,69.6
  BOTTOM w0.16: 160.63,69.6 v1(160.54,69.51) ; JDIMM1.86 136.8,29.88 v1(137.46,30.53)
DDR_A_MA8: length 62.6
  IN4 w0.117: v1(138.37,38.17) 138.37,37.91 138.47,37.81 138.79,37.81 138.89,37.91 138.89,39.35 138.77,39.47 138.5,39.47 138.37,39.59 138.37,39.81 138.5,39.93 138.77,39.93 138.89,40.05 138.89,40.28 138.77,40.4 138.5,40.4 138.37,40.53 138.37,40.74 138.5,40.87 138.77,40.87 138.89,40.98 138.89,41.22 138.77,41.33 138.5,41.33 138.37,41.46 138.37,41.68 138.5,41.8 138.77,41.8 138.89,41.92 138.89,42.15 138.77,42.27 138.5,42.27 138.37,42.4 138.37,42.61 138.5,42.74 138.77,42.74 138.89,42.85 138.89,43.09 138.77,43.2 138.5,43.2 138.37,43.33 138.37,43.54 138.5,43.67 138.77,43.67 138.89,43.79 138.89,44.11 142.49,47.71 142.66,47.71 142.85,47.52 143.01,47.52 143.18,47.69 143.18,47.85 142.99,48.04 142.99,48.21 143.16,48.37 143.32,48.37 143.51,48.18 143.67,48.18 143.84,48.35 143.84,48.51 143.65,48.7 143.65,48.87 143.82,49.03 143.98,49.03 144.17,48.85 144.34,48.85 144.5,49.01 144.5,49.18 144.31,49.36 144.31,49.53 144.48,49.69 144.63,49.69 144.79,49.54 145.03,49.54 161.25,65.76 161.25,67.48 161.71,67.93 161.71,73.32 161.83,73.44 162.27,73.44 162.39,73.56 162.39,73.78 162.27,73.9 161.83,73.9 161.71,74.02 161.71,74.25 161.83,74.37 161.93,74.37 162.05,74.49 162.05,74.72 161.93,74.84 161.83,74.84 161.71,74.96 161.71,75.22 161.84,75.34 162.43,75.34 162.56,75.22 162.56,74.53 162.69,74.41 v1(162.98,74.41)
  BOTTOM w0.089: U6.BE27 162.63,74.76 v1(162.98,74.41)
  BOTTOM w0.16: JDIMM1.89 137.7,35.11 137.43,35.39 137.43,37.22 v1(138.37,38.17)
DDR_A_MA9: length 60.3
  IN4 w0.117: v1(158.1,75.83) 158.53,75.39 158.53,71.24 156.89,69.59 151.22,69.59 148.35,66.73 148.35,58.34 134.56,44.54 134.56,43.92 134.67,43.8 134.88,43.8 135,43.68 135,43.45 134.88,43.33 134.67,43.33 134.56,43.22 134.56,42.98 134.67,42.87 134.88,42.87 135,42.75 135,42.52 134.88,42.4 134.67,42.4 134.56,42.28 134.56,42.05 134.67,41.93 134.88,41.93 135,41.82 135,41.58 134.88,41.46 134.67,41.46 134.56,41.35 134.56,41.11 134.67,41 134.88,41 135,40.88 135,40.65 134.88,40.53 134.67,40.53 134.56,40.41 134.56,40.18 134.67,40.06 134.88,40.06 135,39.95 135,39.71 134.88,39.6 134.67,39.6 134.56,39.48 134.56,38.31 134.7,38.17 v1(134.97,38.17)
  BOTTOM w0.089: U6.BC32 159.32,76.15 158.99,75.83 v1(158.1,75.83)
  BOTTOM w0.16: v1(134.97,38.17) 136.5,36.64 JDIMM1.85
DDR_A_MA10: length 65.9
  IN4 w0.117: v1(144.52,38.17) 144.52,37.91 144.42,37.81 144.04,37.81 143.94,37.91 143.94,39.34 144.05,39.46 144.35,39.46 144.47,39.57 144.47,39.81 144.35,39.92 144.05,39.92 143.94,40.04 143.94,40.27 144.05,40.39 144.35,40.39 144.47,40.51 144.47,40.74 144.35,40.86 144.05,40.86 143.94,40.97 143.94,41.21 144.05,41.33 144.35,41.33 144.47,41.44 144.47,41.72 144.35,41.84 144.05,41.84 143.94,41.96 143.94,42.19 144.05,42.31 144.35,42.31 144.47,42.42 144.47,43.46 165.94,64.94 165.94,68.79 166.53,69.37 166.53,72.85 166.66,72.97 167.3,72.97 167.42,73.1 167.42,73.31 167.3,73.44 166.04,73.44 165.91,73.57 165.91,73.78 166.04,73.91 167.32,73.91 167.45,74.03 167.45,74.25 167.32,74.37 166.04,74.37 165.91,74.5 165.91,74.71 166.04,74.84 167.34,74.84 167.46,74.97 167.46,75.18 167.34,75.31 165.87,75.31 165.75,75.44 165.75,75.68 165.86,75.79 v1(167.85,75.79)
  BOTTOM w0.089: v1(167.85,75.79) 167.52,75.46 U6.BD20
  BOTTOM w0.16: JDIMM1.107 143.1,37.32 143.95,38.17 v1(144.52,38.17)
DDR_A_MA11: length 62.2
  IN4 w0.117: v1(135.68,28.25) 136.48,28.25 136.68,28.45 136.68,44.28 144.28,51.88 144.45,51.88 144.63,51.69 144.8,51.69 144.96,51.86 144.96,52.02 144.78,52.21 144.78,52.38 144.94,52.54 145.11,52.54 145.29,52.36 145.46,52.36 145.63,52.52 145.63,52.69 145.44,52.87 145.44,53.04 145.6,53.2 145.77,53.2 145.96,53.02 146.12,53.02 146.29,53.18 146.29,53.35 146.1,53.54 146.1,53.7 146.26,53.87 146.43,53.87 146.62,53.68 146.78,53.68 159.57,66.46 159.57,69.94 v1(160.54,70.91)
  BOTTOM w0.089: U6.BF31 160.13,73.5 160.97,72.66 160.97,71.34 v1(160.54,70.91)
  BOTTOM w0.16: v1(135.68,28.25) 136.2,27.73 JDIMM1.84
DDR_A_MA12: length 63.9
  IN4 w0.117: v1(134.97,36.64) 134.56,36.23 134.56,35.1 134.67,34.98 135.3,34.98 135.42,35.1 135.42,44.81 148.78,58.17 148.78,58.54 148.89,58.66 149.13,58.66 149.25,58.77 149.25,59.01 149.13,59.13 148.89,59.13 148.78,59.24 148.78,59.48 148.89,59.59 149.13,59.59 149.25,59.71 149.25,59.95 149.13,60.06 148.89,60.06 148.78,60.18 148.78,60.41 148.89,60.53 149.13,60.53 149.25,60.64 149.25,60.88 149.13,61 148.89,61 148.78,61.11 148.78,61.35 148.89,61.46 149.13,61.46 149.25,61.58 149.25,61.82 149.13,61.93 148.89,61.93 148.78,62.05 148.78,62.28 148.89,62.4 149.13,62.4 149.25,62.51 149.25,62.75 149.13,62.87 148.89,62.87 148.78,62.98 148.78,66.55 150.97,68.74 156.63,68.74 158.99,71.1 158.99,74.26 v1(160.54,75.81)
  BOTTOM w0.089: U6.BC31 160.19,76.16 v1(160.54,75.81)
  BOTTOM w0.16: v1(134.97,36.64) 135.26,36.64 135.9,36 JDIMM1.83
DDR_A_MA13: length 63.6
  IN4 w0.117: v1(167.85,74.39) 168.11,74.39 168.24,74.52 168.24,76.63 168.37,76.75 168.57,76.75 168.69,76.63 168.69,72.13 168.96,71.85 168.96,64.38 161.82,57.24 161.82,56.43 147.85,42.46 147.85,36.02 146.83,35.01 146.57,35.01 146.36,34.79 146.36,31.05 146.48,30.93 146.83,30.93 146.96,31.05 v1(146.96,31.29)
  BOTTOM w0.089: U6.BE20 167.49,74.76 167.85,74.39 v1(167.85,74.39)
  BOTTOM w0.16: JDIMM1.119 146.7,33.23 146.43,32.96 146.43,31.26 146.56,31.14 146.83,31.14 146.96,31.26 v1(146.96,31.29)
DDR_A_MA14: length 62.8
  IN4 w0.117: v1(160.54,72.31) 160.11,71.88 160.11,71.03 159.15,70.07 159.15,66.64 148.8,56.29 148.65,56.29 148.46,56.49 148.29,56.49 148.12,56.32 148.12,56.16 148.32,55.96 148.32,55.82 148.14,55.63 147.99,55.63 147.79,55.83 147.63,55.83 147.46,55.66 147.46,55.5 147.66,55.3 147.66,55.15 147.48,54.97 147.33,54.97 147.13,55.17 146.97,55.17 146.8,55 146.8,54.84 147,54.64 147,54.49 146.81,54.31 146.67,54.31 146.47,54.5 146.31,54.5 136.26,44.46 136.26,29.97 136.06,29.77 v1(135.68,29.77)
  BOTTOM w0.089: U6.BE32 159.65,74.43 159.65,73.2 v1(160.54,72.31)
  BOTTOM w0.16: JDIMM1.80 135,29.09 v1(135.68,29.77)
DDR_A_MA15: length 64.1
  IN4 w0.117: v1(160.54,74.41) 159.52,73.39 159.52,71.04 156.81,68.32 151.14,68.32 149.2,66.38 149.2,63.5 149.3,63.4 149.57,63.4 149.67,63.3 149.67,58.46 135.84,44.63 135.84,33.64 134.9,32.7 134.9,30.94 v1(133.72,29.77)
  BOTTOM w0.089: v1(160.54,74.41) 160.19,74.76 U6.BE31
  BOTTOM w0.16: v1(133.72,29.77) 134.4,29.09 JDIMM1.78
DDR_A_RAS#: length 63.8
  IN4 w0.117: v1(144.5,28.25) 144.91,27.83 144.91,27.44 145.04,27.31 145.81,27.31 145.93,27.44 145.93,27.77 145.82,27.89 145.49,27.89 145.36,28.02 145.36,28.23 145.49,28.36 145.82,28.36 145.93,28.47 145.93,28.71 145.82,28.82 145.04,28.82 144.91,28.95 144.91,29.16 145.04,29.29 145.82,29.29 145.93,29.41 145.93,35.29 146.07,35.43 146.66,35.43 147.43,36.2 147.43,42.63 161.4,56.61 161.4,57.41 168.54,64.55 168.54,71.62 v1(167.85,72.31)
  BOTTOM w0.089: U6.BF20 167.45,72.71 v1(167.85,72.31)
  BOTTOM w0.16: JDIMM1.110 144,27.75 v1(144.5,28.25)
DDR_A_WE#: length 65
  IN4 w0.117: v1(146.47,38.17) 146.47,37.91 146.37,37.81 145.95,37.81 145.82,37.93 145.82,39.21 145.95,39.34 146.46,39.34 146.58,39.47 146.58,39.73 146.46,39.86 145.95,39.86 145.82,39.99 145.82,40.2 145.95,40.33 146.46,40.33 146.58,40.46 146.58,40.67 146.46,40.8 145.95,40.8 145.82,40.92 145.82,41.14 145.95,41.26 146.46,41.26 146.58,41.39 146.58,41.6 146.46,41.73 145.95,41.73 145.82,41.86 145.82,42.07 145.95,42.2 146.46,42.2 146.58,42.33 146.58,42.54 146.46,42.67 145.95,42.67 145.82,42.79 145.82,43.02 146.33,43.53 146.49,43.53 146.73,43.29 146.89,43.29 147.06,43.46 147.06,43.62 146.82,43.86 146.82,44.02 146.99,44.19 147.15,44.19 147.39,43.95 147.55,43.95 147.72,44.12 147.72,44.28 147.48,44.52 147.48,44.68 147.65,44.85 147.81,44.85 148.05,44.61 148.21,44.61 148.38,44.78 148.38,44.94 148.14,45.18 148.14,45.35 148.31,45.51 148.47,45.51 148.71,45.28 148.88,45.28 149.04,45.44 149.04,45.61 148.81,45.84 148.81,46.01 148.97,46.17 149.14,46.17 149.37,45.94 149.54,45.94 149.7,46.1 149.7,46.27 149.47,46.5 149.47,46.67 149.63,46.83 149.8,46.83 150.03,46.6 150.2,46.6 150.36,46.76 150.36,46.93 150.13,47.16 150.13,47.33 150.29,47.5 150.46,47.5 150.69,47.26 150.86,47.26 151.03,47.43 151.03,47.59 150.79,47.83 150.79,47.99 150.96,48.16 151.12,48.16 151.36,47.92 151.52,47.92 151.69,48.09 151.69,48.25 151.45,48.49 151.45,48.65 151.62,48.82 151.78,48.82 152.02,48.58 152.18,48.58 152.35,48.75 152.35,48.91 152.11,49.15 152.11,49.31 152.28,49.48 152.44,49.48 152.68,49.24 152.84,49.24 153.01,49.41 153.01,49.57 152.77,49.81 152.77,49.98 167.37,64.57 167.37,67.98 167.5,68.11 v1(167.85,68.11)
  BOTTOM w0.089: U6.BF21 166.63,72.09
  BOTTOM w0.16: 166.63,72.09 166.63,69.33 v1(167.85,68.11) ; v1(146.47,38.17) 145.1,36.79 145.1,35.64 144.9,35.45 JDIMM1.113
DDR_B_BS0: length 103.5
  IN3 w0.089: v1(165.58,78.58) 165.58,77.75 167.38,75.95 167.38,75.58 167.54,75.41 168.03,75.41 168.64,74.8 168.64,74.16 169.12,73.69
  IN3 w0.196: 169.12,73.69 169.12,72.68 169.56,72.25 169.56,69.27 181.41,57.41 187.35,57.41 187.55,57.22 187.55,54.8 187.75,54.61 188.14,54.61 188.33,54.8 188.33,57.22 188.53,57.41 188.92,57.41 189.11,57.22 189.11,54.8 189.31,54.61 189.7,54.61 189.9,54.8 189.9,57.22 190.09,57.41 190.48,57.41 190.68,57.22 190.68,54.8 190.87,54.61 191.27,54.61 191.46,54.8 191.46,57.22 191.66,57.41 192.05,57.41 192.24,57.22 192.24,54.8 192.44,54.61 192.83,54.61 193.03,54.8 193.03,57.22 193.22,57.41 193.61,57.41 193.81,57.22 193.81,54.8 194,54.61 194.39,54.61 194.59,54.8 194.59,55.25 194.79,55.44 195.18,55.44 195.37,55.25 195.37,54.8 195.57,54.61 204.38,54.61 219.53,39.45 219.53,36.76 219.29,36.51 v1(218.62,36.51)
  BOTTOM w0.089: U6.AY23 165.26,78.26 v1(165.58,78.58)
  BOTTOM w0.16: JDIMM2.109 218.2,35.12 218.14,35.19 218.14,36.03 v1(218.62,36.51)
DDR_B_BS1: length 104.7
  IN3 w0.089: 166.37,74.9 166.37,76.16 v1(164.64,77.88)
  IN3 w0.196: v1(218.45,30.59) 217.68,30.59 217.45,30.81 217.45,31.51 217.65,31.7 218.12,31.7 218.31,31.9 218.31,32.29 218.12,32.48 217.65,32.48 217.45,32.68 217.45,33.22 217.65,33.42 218.22,33.42 218.41,33.61 218.41,34 218.22,34.2 217.26,34.2 217.07,34.4 217.07,35.68 216.87,35.88 215.6,35.88 215.37,36.11 215.37,40.85 203.56,52.65 181.24,52.65 179.53,54.36 179.53,54.64 179.84,54.95 179.84,55.22 179.56,55.5 179.29,55.5 178.97,55.19 178.7,55.19 178.42,55.47 178.42,55.74 178.73,56.05 178.73,56.33 178.46,56.61 178.18,56.61 177.87,56.29 177.59,56.29 177.32,56.57 177.32,56.85 177.63,57.16 177.63,57.44 177.35,57.71 177.07,57.71 176.76,57.4 176.49,57.4 176.21,57.68 176.21,57.95 176.52,58.27 176.52,58.54 176.24,58.82 175.97,58.82 175.66,58.51 175.38,58.51 175.1,58.78 175.1,59.06 175.41,59.37 175.41,59.65 175.14,59.93 174.86,59.93 174.55,59.61 174.27,59.61 174,59.89 174,60.17 174.31,60.48 174.31,60.76 174.03,61.03 173.76,61.03 173.44,60.72 173.17,60.72 172.89,61 172.89,61.27 173.2,61.59 173.2,61.86 172.93,62.14 172.65,62.14 172.34,61.83 172.06,61.83 171.78,62.1 171.78,62.38 172.1,62.69 172.1,62.97 171.82,63.25 171.54,63.25 171.23,62.93 170.95,62.93 170.68,63.21 170.68,63.49 170.99,63.8 170.99,64.08 170.71,64.35 170.44,64.35 170.12,64.04 169.85,64.04 169.57,64.32 169.57,64.59 169.88,64.91 169.88,65.18 169.61,65.46 169.33,65.46 169.02,65.15 168.74,65.15 168.29,65.6 167.39,65.6 166.75,66.25 166.75,73.3 166.37,73.68 166.37,74.9
  BOTTOM w0.089: U6.BA23 164.97,77.56 v1(164.64,77.88)
  BOTTOM w0.16: JDIMM2.108 217.9,30.04 v1(218.45,30.59)
DDR_B_BS2: length 100.1
  IN3 w0.089: v1(157.15,78.56) 157.15,78.43 158.05,77.53 158.05,76.74 156.96,75.65 156.96,73.59 156.55,73.19
  IN3 w0.196: 156.55,73.19 156.55,70.48 155.89,69.82 155.89,68.82 155.7,68.63 154.7,68.63 154.5,68.43 154.5,68.04 154.7,67.85 155.7,67.85 155.89,67.65 155.89,62.17 155.7,61.97 154.03,61.97 153.83,61.77 153.83,61.38 154.03,61.19 155.7,61.19 155.89,60.99 155.89,60.6 155.7,60.41 154.06,60.41 153.87,60.21 153.87,59.82 154.06,59.62 155.7,59.62 155.89,59.43 155.89,57.8 164.21,49.48 172.09,49.48 179.38,42.19 200.17,42.19 203.87,38.49 204.54,38.49 205.6,37.43 205.6,35.5 207.97,33.13 207.97,32.73 v1(208.59,32.11)
  BOTTOM w0.089: v1(157.15,78.56) 157.15,78.04 U6.BA36
  BOTTOM w0.16: v1(208.59,32.11) 208.82,32.11 209.2,32.49 JDIMM2.79
DDR_B_CAS#: length 106
  IN3 w0.089: v1(167.46,79.98) 167.02,79.54 166.34,79.54 166.15,79.34 166.15,77.95 167.04,77.06 167.82,77.06 167.95,76.94 168.42,76.94 169.17,76.19 169.65,76.19 170.7,75.14
  IN3 w0.196: 170.7,75.14 170.86,74.98 170.86,69.81 179.83,60.84 180.51,60.84 180.7,60.64 180.7,59.97 180.9,59.78 181.29,59.78 181.48,59.97 181.48,60.64 181.68,60.84 182.07,60.84 182.27,60.64 182.27,58.91 182.46,58.72 182.85,58.72 183.05,58.91 183.05,60.64 183.24,60.84 183.63,60.84 183.83,60.64 183.83,58.91 184.03,58.72 184.42,58.72 184.61,58.91 184.61,60.64 184.81,60.84 185.2,60.84 185.39,60.64 185.39,58.91 185.59,58.72 185.99,58.72 186.18,58.91 186.18,60.64 186.38,60.84 186.77,60.84 186.97,60.64 186.97,58.91 187.16,58.72 202.11,58.72 202.49,58.34 202.49,58.06 201.81,57.39 201.81,57.11 202.09,56.83 202.37,56.83 203.04,57.51 203.32,57.51 203.6,57.23 203.6,56.96 203.14,56.5 203.14,56.22 203.42,55.95 203.69,55.95 204.15,56.4 204.43,56.4 221.53,39.3 221.53,35.11 221.34,34.91 221.02,34.91 220.83,35.11 220.83,36.67 220.63,36.87 220.38,36.87 220.18,36.67 v1(220.18,36.51)
  BOTTOM w0.089: U6.AV20 167.14,79.66 v1(167.46,79.98)
  BOTTOM w0.16: JDIMM2.115 220,35.22 219.72,35.5 219.72,36.05 v1(220.18,36.51)
DDR_B_D0: length 95.3
  IN1 w0.076: v1(143.3,90.03) 142.92,90.03 141.41,88.52 141.41,63.87 162.05,43.24 176.4,43.24 179.14,40.5 179.25,40.5 179.53,40.78 179.63,40.78 179.74,40.67 179.74,40.56 179.46,40.28 179.46,40.18 179.57,40.07 179.68,40.07 179.96,40.35 180.07,40.35 180.17,40.24 180.17,40.13 179.89,39.85 179.89,39.74 180,39.64 180.11,39.64 180.39,39.92 180.5,39.92 180.61,39.81 180.61,39.7 180.32,39.42 180.32,39.31 180.43,39.2 180.54,39.2 180.82,39.49 180.93,39.49 181.04,39.38 181.04,39.27 180.76,38.99 180.76,38.88 180.86,38.77 180.97,38.77 181.56,39.36 181.66,39.36 181.77,39.25 181.77,39.14 181.19,38.56 181.19,38.45 181.29,38.34 181.4,38.34 181.89,38.83 182,38.83 182.1,38.72 182.1,38.61 181.62,38.13 181.62,38.02 181.73,37.91 181.83,37.91 182.6,38.67 182.7,38.67 182.81,38.57 182.81,38.46 182.05,37.7 182.05,37.59 182.16,37.48 182.26,37.48 182.55,37.76 182.65,37.76 182.76,37.65 182.76,37.55 182.48,37.26 182.48,37.16 182.59,37.05 182.7,37.05 182.98,37.33 183.08,37.33 183.19,37.22 183.19,37.11 182.91,36.83 182.91,36.73 v1(183.9,35.73)
  BOTTOM w0.089: v1(143.3,90.03) 143.56,89.76 U6.AC54
  BOTTOM w0.102: v1(183.9,35.73) 184.6,35.04 JDIMM2.5
DDR_B_D1: length 98.6
  IN1 w0.076: v1(145.42,90.17) 144.92,89.66 142.88,89.66 141.64,88.42 141.64,63.97 162.14,43.47 178.7,43.47 179.17,43.01 179.17,42.9 178.6,42.33 178.6,42.22 178.71,42.11 178.82,42.11 179.38,42.68 179.49,42.68 179.6,42.57 179.6,42.47 179.03,41.9 179.03,41.79 179.14,41.68 179.25,41.68 179.82,42.25 179.92,42.25 180.03,42.14 180.03,42.04 179.46,41.47 179.46,41.36 179.57,41.25 179.68,41.25 180.25,41.82 180.35,41.82 180.46,41.71 180.46,41.6 179.89,41.04 179.89,40.93 180,40.82 180.11,40.82 180.68,41.39 180.79,41.39 180.89,41.28 180.89,41.17 180.33,40.6 180.33,40.5 180.43,40.39 180.54,40.39 181.11,40.96 181.22,40.96 181.33,40.85 181.33,40.74 180.76,40.17 180.76,40.07 180.87,39.96 180.97,39.96 181.54,40.53 181.65,40.53 181.76,40.42 181.76,40.31 181.36,39.91 181.36,39.8 181.47,39.7 181.57,39.7 181.97,40.09 182.08,40.09 183.13,39.04 183.13,38.03 v1(183.9,37.26)
  BOTTOM w0.089: U6.AC52 145.77,89.82 v1(145.42,90.17)
  BOTTOM w0.102: JDIMM2.7 185.2,35.96 v1(183.9,37.26)
DDR_B_D2: length 96.6
  IN1 w0.076: v1(146.12,88.54) 145.75,88.17 144.06,88.17 142.56,86.67 142.56,64.35 162.52,44.39 181.88,44.39 184.98,41.29 184.98,41.18 184.83,41.03 184.83,40.93 184.94,40.82 185.05,40.82 185.2,40.97 185.3,40.97 185.41,40.86 185.41,40.75 184.86,40.2 184.86,40.09 184.97,39.98 185.08,39.98 185.63,40.53 185.74,40.53 185.84,40.43 185.84,40.32 185.29,39.77 185.29,39.66 185.4,39.55 185.51,39.55 186.06,40.1 186.17,40.1 186.27,40 186.27,39.89 185.72,39.34 185.72,39.23 185.83,39.12 185.94,39.12 186.49,39.67 186.6,39.67 186.71,39.56 186.71,39.46 186.15,38.9 186.15,38.8 186.26,38.69 186.37,38.69 186.92,39.24 187.03,39.24 187.14,39.13 187.14,39.03 186.59,38.47 186.59,38.37 186.69,38.26 186.8,38.26 187.35,38.81 187.46,38.81 187.76,38.51 187.76,36.13 v1(187.37,35.73)
  BOTTOM w0.089: U6.AE51 146.47,88.19 v1(146.12,88.54)
  BOTTOM w0.102: JDIMM2.15 187.6,35.5 v1(187.37,35.73)
DDR_B_D3: length 94.3
  IN1 w0.076: v1(187.37,37.26) 184.4,40.22 184.4,40.33 184.52,40.45 184.52,40.56 184.41,40.66 184.3,40.66 184.19,40.55 184.08,40.55 183.95,40.67 183.95,40.78 184.5,41.33 184.5,41.44 184.4,41.55 184.29,41.55 183.74,41 183.63,41 183.52,41.11 183.52,41.21 184.07,41.76 184.07,41.87 183.97,41.98 183.86,41.98 183.31,41.43 183.2,41.43 183.09,41.54 183.09,41.64 183.64,42.2 183.64,42.3 183.53,42.41 183.43,42.41 182.88,41.86 182.77,41.86 182.66,41.97 182.66,42.08 183.21,42.63 183.21,42.74 183.1,42.84 183,42.84 182.44,42.29 182.34,42.29 182.23,42.4 182.23,42.51 182.78,43.06 182.78,43.17 182.67,43.27 182.56,43.27 182.01,42.72 181.9,42.72 180.47,44.16 162.42,44.16 142.33,64.25 142.33,87.54 v1(143.32,88.54)
  BOTTOM w0.089: U6.AE54 143.73,88.13 v1(143.32,88.54)
  BOTTOM w0.102: v1(187.37,37.26) 188.2,36.43 JDIMM2.17
DDR_B_D4: length 94.7
  IN1 w0.076: v1(184.6,29.83) 184.12,29.83 183.43,30.52 183.43,31.88 173.23,42.08 161.63,42.08 139.88,63.83 139.88,87.71 140.32,88.16 140.32,89.07 141.78,90.53 144.35,90.53 v1(144.72,90.17)
  BOTTOM w0.089: v1(144.72,90.17) 145.07,89.82 U6.AC53
  BOTTOM w0.102: v1(184.6,29.83) 184.17,29.41 184.17,27.91 184.3,27.78 JDIMM2.4
DDR_B_D5: length 96.3
  IN1 w0.076: v1(146.12,90.17) 145.52,90.77 141.69,90.77 140.09,89.17 140.09,88.25 139.65,87.81 139.65,63.74 161.53,41.85 173.14,41.85 183.2,31.79 183.2,30.43 183.99,29.64 183.99,28.91 v1(184.6,28.3)
  BOTTOM w0.089: U6.AC51 146.47,89.81 v1(146.12,90.17)
  BOTTOM w0.102: JDIMM2.6 184.9,28 v1(184.6,28.3)
DDR_B_D6: length 95.4
  IN1 w0.076: v1(187.81,28.3) 186.42,29.7 186.42,36.08 178.8,43.7 162.23,43.7 141.87,64.06 141.87,87.93 143.02,89.09 144.88,89.09 v1(145.42,88.54)
  BOTTOM w0.089: U6.AE52 145.77,88.19 v1(145.42,88.54)
  BOTTOM w0.102: JDIMM2.16 187.9,28.22 v1(187.81,28.3)
DDR_B_D7: length 95
  IN1 w0.076: v1(144.72,88.54) 144.35,88.91 143.17,88.91 142.1,87.84 142.1,64.16 162.33,43.93 178.89,43.93 186.65,36.17 186.65,30.06 186.88,29.83 v1(187.81,29.83)
  BOTTOM w0.089: v1(144.72,88.54) 145.07,88.19 U6.AE53
  BOTTOM w0.102: v1(187.81,29.83) 188.5,29.14 JDIMM2.18
DDR_B_D8: length 92.4
  IN1 w0.076: v1(148.67,80.81) 148.12,80.26 148.12,79.48 147.82,79.18 145.91,79.18 145.73,79 145.73,78.62 145.53,78.42 145.21,78.42 144.26,77.46 144.26,76.66 143.61,76.02 143.61,64.62 162.91,45.33 183.16,45.33 190.63,37.86 190.63,34.6 190.7,34.53 191.2,34.53 191.28,34.45 191.28,34.3 191.2,34.22 190.7,34.22 190.63,34.15 190.63,33.99 190.7,33.92 191.2,33.92 191.28,33.84 191.28,33.69 191.2,33.61 190.38,33.61 190.3,33.69 190.3,37.18 190.23,37.26 v1(189.91,37.26)
  BOTTOM w0.089: U6.AU47 149.12,80.36 v1(148.67,80.81)
  BOTTOM w0.102: JDIMM2.23 190,35.21 190.34,35.55 190.34,36.83 v1(189.91,37.26)
DDR_B_D9: length 92.2
  IN1 w0.076: v1(191.11,28.3) 190.08,29.34 190.08,35.19 190,35.26 188.32,35.26 188.25,35.34 188.25,39.59 182.97,44.87 162.72,44.87 143.15,64.43 143.15,76.27 143.63,76.75 143.63,79.46 144.37,80.2 144.37,80.62 144.55,80.81 v1(147.73,80.81)
  BOTTOM w0.089: U6.AU49 148.18,80.36 v1(147.73,80.81)
  BOTTOM w0.102: v1(191.11,28.3) 190.3,27.49 JDIMM2.24
DDR_B_D10: length 94.7
  IN1 w0.076: v1(151.49,80.11) 151.1,79.73 151.1,77.56 150.25,76.72 149.58,76.72 149.54,76.68 149.54,76.33 149.35,76.14 148.91,76.14 148.72,76.33 148.72,76.53 148.46,76.78 148.02,76.78 147.86,76.63 147.86,76.36 146.73,75.22 146.73,64.4 163.76,47.36 184,47.36 184.5,46.86 184.61,46.86 184.93,47.19 185.04,47.19 185.15,47.08 185.15,46.97 184.82,46.65 184.82,46.54 184.93,46.43 185.04,46.43 185.62,47.01 185.73,47.01 185.83,46.9 185.83,46.8 185.25,46.22 185.25,46.11 185.4,45.96 185.51,45.96 186.09,46.54 186.2,46.54 194.3,38.44 194.3,28.7 v1(193.91,28.3)
  BOTTOM w0.089: U6.AV43 151.94,79.66 v1(151.49,80.11)
  BOTTOM w0.102: JDIMM2.36 193.9,28.3 v1(193.91,28.3)
DDR_B_D11: length 93.5
  IN1 w0.076: v1(150.55,80.11) 150.32,80.11 150.18,79.97 150.18,77.58 149.73,77.14 146.57,77.14 145.22,75.79 145.22,74.86 146.27,73.81 146.27,66.8 146.2,66.73 145.96,66.73 145.88,66.65 145.88,66.5 145.96,66.42 146.2,66.42 146.27,66.35 146.27,66.19 146.2,66.12 145.48,66.12 145.4,66.04 145.4,65.89 145.48,65.81 146.2,65.81 146.27,65.74 146.27,65.58 146.2,65.51 145.48,65.51 145.4,65.43 145.4,65.28 145.48,65.2 146.2,65.2 146.27,65.13 146.27,64.21 163.57,46.9 183.81,46.9 186.02,44.69 186.13,44.69 186.71,45.27 186.82,45.27 186.93,45.17 186.93,45.06 186.35,44.48 186.35,44.37 186.45,44.26 186.56,44.26 187.14,44.84 187.25,44.84 187.36,44.74 187.36,44.63 186.78,44.05 186.78,43.94 186.88,43.83 186.99,43.83 187.57,44.41 187.68,44.41 187.79,44.3 187.79,44.2 187.21,43.62 187.21,43.51 187.32,43.4 187.42,43.4 188,43.98 188.11,43.98 193.8,38.3 193.8,36.36 v1(193.17,35.73)
  BOTTOM w0.089: v1(150.55,80.11) 150.8,80.11 151.03,79.88 U6.AV45
  BOTTOM w0.102: v1(193.17,35.73) 193.6,35.31 JDIMM2.35
DDR_B_D12: length 94.4
  IN1 w0.076: v1(193.91,29.83) 193.51,30.22 193.51,30.75 194.02,31.26 194.02,38.39 186.69,45.72 186.58,45.72 186,45.14 185.9,45.14 185.79,45.25 185.79,45.36 186.37,45.94 186.37,46.05 186.26,46.16 186.15,46.16 185.57,45.58 185.47,45.58 183.91,47.13 163.67,47.13 146.5,64.3 146.5,75.4 146.99,75.9 146.99,76.75 147.2,76.96 150.25,76.96 150.93,77.64 150.93,80.25 v1(151.49,80.81)
  BOTTOM w0.089: v1(151.49,80.81) 151.94,80.36 U6.AU43
  BOTTOM w0.102: v1(193.91,29.83) 193.3,29.22 JDIMM2.34
DDR_B_D13: length 94.9
  IN1 w0.076: v1(150.55,80.81) 150,80.26 150,77.66 149.66,77.32 146.34,77.32 144.97,75.94 144.97,74.54 146.04,73.47 146.04,70.22 145.97,70.14 145.25,70.14 145.17,70.06 145.17,69.91 145.25,69.84 145.97,69.84 146.04,69.76 146.04,69.61 145.97,69.53 145.25,69.53 145.17,69.45 145.17,69.3 145.25,69.23 145.97,69.23 146.04,69.15 146.04,69 145.97,68.92 145.25,68.92 145.17,68.84 145.17,68.69 145.25,68.62 145.97,68.62 146.04,68.54 146.04,68.39 145.97,68.31 145.25,68.31 145.17,68.24 145.17,68.02 145.25,67.95 145.97,67.95 146.04,67.87 146.04,67.72 145.97,67.64 145.25,67.64 145.17,67.56 145.17,67.41 145.25,67.34 145.97,67.34 146.04,67.26 146.04,67.11 145.97,67.03 145.25,67.03 145.17,66.95 145.17,66.8 145.25,66.73 145.58,66.73 145.65,66.65 145.65,66.5 145.58,66.42 145.25,66.42 145.17,66.35 145.17,64.98 163.48,46.67 183.72,46.67 187.37,43.02 187.48,43.02 188.06,43.6 188.17,43.6 193.57,38.2 193.57,37.65 v1(193.17,37.26)
  BOTTOM w0.089: v1(150.55,80.81) 151,80.36 U6.AU45
  BOTTOM w0.102: v1(193.17,37.26) 192.74,36.83 192.74,35.55 193,35.3 JDIMM2.33
DDR_B_D14: length 91.8
  IN1 w0.076: v1(148.67,80.11) 148.3,79.74 148.3,78.58 148.14,78.43 145.98,78.43 145.76,78.2 145.76,77.46 143.84,75.54 143.84,64.72 163,45.56 183.25,45.56 190.85,37.96 190.85,34.91 190.93,34.83 192.08,34.83 192.16,34.75 192.16,34.51 192.08,34.44 191.58,34.44 191.51,34.36 191.51,30.22 v1(191.11,29.83)
  BOTTOM w0.089: U6.AV47 149.12,79.66 v1(148.67,80.11)
  BOTTOM w0.102: JDIMM2.22 189.7,28.41 v1(191.11,29.83)
DDR_B_D15: length 90.2
  IN1 w0.076: v1(147.73,80.11) 147.64,80.02 144.65,80.02 144.37,79.73 144.37,77.92 144.03,77.59 144.03,76.79 143.38,76.14 143.38,64.53 162.81,45.1 183.06,45.1 188.47,39.69 188.47,38.89 188.55,38.82 189.01,38.82 189.09,38.74 189.09,38.59 189.01,38.51 188.55,38.51 188.47,38.44 188.47,38.26 188.55,38.19 189.37,38.19 189.44,38.11 189.44,37.96 189.37,37.88 188.55,37.88 188.47,37.81 188.47,37.65 188.55,37.58 189.37,37.58 189.44,37.5 189.44,37.35 189.37,37.27 188.55,37.27 188.47,37.2 188.47,37.04 188.55,36.97 189.37,36.97 189.44,36.89 189.44,36.74 189.37,36.66 188.55,36.66 188.47,36.59 188.47,36.43 188.55,36.36 189.37,36.36 189.44,36.28 189.44,36.13 189.37,36.05 188.55,36.05 188.47,35.98 188.47,35.81 188.55,35.73 v1(189.91,35.73)
  BOTTOM w0.089: U6.AV49 148.18,79.66 v1(147.73,80.11)
  BOTTOM w0.102: v1(189.91,35.73) 189.4,35.22 JDIMM2.21
DDR_B_D16: length 86.3
  IN1 w0.076: v1(195.71,37.26) 194.79,38.18 194.79,38.63 193.11,40.31 193.11,40.42 193.27,40.58 193.27,40.69 193.17,40.8 193.06,40.8 192.89,40.64 192.79,40.64 192.68,40.74 192.68,40.85 192.84,41.02 192.84,41.12 192.74,41.23 192.63,41.23 192.46,41.07 192.35,41.07 192.25,41.17 192.25,41.28 192.41,41.45 192.41,41.56 192.3,41.66 192.2,41.66 192.03,41.5 191.92,41.5 191.82,41.61 191.82,41.71 191.98,41.88 191.98,41.99 191.87,42.09 191.76,42.09 191.6,41.93 191.49,41.93 191.38,42.04 191.38,42.14 191.55,42.31 191.55,42.42 191.44,42.53 191.33,42.53 191.17,42.36 191.06,42.36 190.95,42.47 190.95,42.58 191.12,42.74 191.12,42.85 191.01,42.96 190.9,42.96 190.74,42.79 190.63,42.79 190.52,42.9 190.52,43.01 190.69,43.17 190.69,43.28 190.58,43.39 190.47,43.39 190.31,43.22 190.2,43.22 190.09,43.33 190.09,43.44 190.26,43.6 190.26,43.71 190.15,43.82 190.04,43.82 189.87,43.65 189.77,43.65 189.66,43.76 189.66,43.87 189.82,44.04 189.82,44.14 189.72,44.25 189.61,44.25 189.44,44.09 189.34,44.09 189.23,44.19 189.23,44.3 189.39,44.47 189.39,44.57 189.28,44.68 189.18,44.68 189.01,44.52 188.9,44.52 188.8,44.63 188.8,44.73 188.96,44.9 188.96,45.01 188.85,45.11 188.75,45.11 188.58,44.95 188.47,44.95 188.37,45.06 188.37,45.16 188.53,45.33 188.53,45.44 188.42,45.54 188.31,45.54 188.15,45.38 188.04,45.38 187.93,45.49 187.93,45.6 188.1,45.76 188.1,45.87 187.99,45.98 187.88,45.98 187.72,45.81 187.61,45.81 187.5,45.92 187.5,46.03 187.67,46.19 187.67,46.3 187.56,46.41 187.45,46.41 187.29,46.24 187.18,46.24 187.07,46.35 187.07,46.46 187.24,46.62 187.24,46.73 187.13,46.84 187.02,46.84 186.86,46.67 186.75,46.67 186.64,46.78 186.64,46.89 186.81,47.05 186.81,47.16 186.7,47.27 186.59,47.27 186.42,47.1 186.32,47.1 186.21,47.21 186.21,47.32 186.37,47.49 186.37,47.59 186.27,47.7 186.16,47.7 185.99,47.54 185.89,47.54 185.58,47.84 163.96,47.84 147.21,64.6 147.21,73.88 147.64,74.3 147.64,75.61 147.92,75.89 147.92,76 v1(148.32,76.4)
  BOTTOM w0.089: U6.BC49 148.07,76.16 v1(148.32,76.4)
  BOTTOM w0.102: v1(195.71,37.26) 194.8,36.34 JDIMM2.39
DDR_B_D17: length 83.2
  IN1 w0.076: v1(148.3,74.41) 147.44,73.55 147.44,64.69 164.06,48.07 186.22,48.07 196.11,38.18 196.11,31.91 196.03,31.83 195.79,31.83 195.71,31.91 v1(195.71,35.73)
  BOTTOM w0.089: v1(148.3,74.41) 147.96,74.76 U6.BE49
  BOTTOM w0.102: JDIMM2.41 195.4,35.34 195.12,35.62 195.12,35.8 195.29,35.98 195.47,35.98 v1(195.71,35.73)
DDR_B_D18: length 86.9
  IN1 w0.076: v1(149.97,75.11) 150.67,74.41 150.67,72.01 150.35,71.69 150.35,70.45 151.33,69.47 154.26,69.47 156.91,66.82 156.91,59.53 157.64,58.81 157.64,58.7 157.03,58.09 157.03,57.98 157.14,57.87 157.24,57.87 157.86,58.48 157.96,58.48 158.07,58.37 158.07,58.27 157.46,57.65 157.46,57.55 157.57,57.44 157.67,57.44 158.29,58.05 158.4,58.05 158.5,57.94 158.5,57.84 157.89,57.22 157.89,57.12 158,57.01 158.11,57.01 158.72,57.62 158.83,57.62 158.93,57.51 158.93,57.4 158.32,56.79 158.32,56.68 158.43,56.58 158.54,56.58 159.15,57.19 159.26,57.19 159.37,57.08 159.37,56.97 158.75,56.36 158.75,56.25 158.86,56.14 158.97,56.14 159.21,56.39 159.32,56.39 159.43,56.28 159.43,56.17 159.18,55.93 159.18,55.82 164.9,50.1 187.76,50.1 199.68,38.18 199.68,37.65 v1(199.29,37.26)
  BOTTOM w0.089: v1(149.97,75.11) 149.62,75.46 U6.BD47
  BOTTOM w0.102: v1(199.29,37.26) 198.77,37.26 198.64,37.13 198.64,35.61 198.4,35.37 JDIMM2.51
DDR_B_D19: length 87.3
  IN1 w0.076: v1(199.29,35.73) 199.91,36.36 199.91,38.28 187.86,50.33 165,50.33 161.29,54.04 161.29,54.15 161.9,54.76 161.9,54.87 161.79,54.98 161.68,54.98 161.07,54.36 160.96,54.36 160.86,54.47 160.86,54.58 161.47,55.19 161.47,55.3 161.36,55.41 161.25,55.41 160.64,54.8 160.53,54.8 160.42,54.9 160.42,55.01 161.04,55.62 161.04,55.73 160.93,55.84 160.82,55.84 160.21,55.23 160.1,55.23 159.99,55.34 159.99,55.44 160.61,56.06 160.61,56.16 160.5,56.27 160.39,56.27 159.78,55.66 159.67,55.66 159.56,55.77 159.56,55.87 160.18,56.49 160.18,56.6 160.07,56.7 159.96,56.7 159.7,56.44 159.59,56.44 159.48,56.55 159.48,56.65 159.74,56.92 159.74,57.03 157.14,59.63 157.14,66.92 154.36,69.7 151.42,69.7 150.58,70.54 150.58,71.6 150.9,71.91 150.9,74.88 v1(149.97,75.81)
  BOTTOM w0.089: U6.BC47 149.62,76.16 v1(149.97,75.81)
  BOTTOM w0.102: v1(199.29,35.73) 199,35.44 JDIMM2.53
DDR_B_D20: length 84.8
  IN1 w0.076: v1(196.46,29.83) 196.86,30.22 196.86,31.88 196.56,32.17 196.56,38.37 186.41,48.53 164.25,48.53 147.9,64.88 147.9,72.4 148.92,73.43 148.92,75.11 v1(148.3,75.73)
  BOTTOM w0.089: U6.BD49 148.03,75.46 v1(148.3,75.73)
  BOTTOM w0.102: v1(196.46,29.83) 195.1,28.47 JDIMM2.40
DDR_B_D21: length 84.4
  IN1 w0.076: v1(196.46,28.3) 196.05,28.72 196.05,31.06 196.34,31.35 196.34,38.28 186.31,48.3 164.15,48.3 147.67,64.78 147.67,72.45 148.69,73.47 148.69,74.76 v1(148.3,75.15)
  BOTTOM w0.089: v1(148.3,75.15) 148.26,75.11 U6.BD50
  BOTTOM w0.102: v1(196.46,28.3) 195.7,27.54 JDIMM2.42
DDR_B_D22: length 85.8
  IN1 w0.076: v1(198.73,29.83) 199.13,30.22 199.13,31.36 199.05,31.43 198.54,31.43 198.46,31.51 198.46,31.66 198.54,31.74 199.05,31.74 199.13,31.82 199.13,31.97 198.77,32.33 198.77,38.08 186.97,49.88 164.81,49.88 156.69,58 156.69,66.73 154.17,69.24 151.23,69.24 150.13,70.35 150.13,71.79 150.44,72.1 150.44,73.94 v1(149.97,74.41)
  BOTTOM w0.089: v1(149.97,74.41) 149.62,74.76 U6.BE47
  BOTTOM w0.102: v1(198.73,29.83) 198.1,29.2 JDIMM2.50
DDR_B_D23: length 85.2
  IN1 w0.076: v1(198.73,28.3) 198.23,28.81 198.23,34.32 198.31,34.39 198.46,34.39 198.54,34.47 198.54,34.62 198.46,34.7 198.31,34.7 198.23,34.77 198.23,34.93 198.31,35 198.46,35 198.54,35.08 198.54,35.23 198.46,35.31 198.31,35.31 198.23,35.38 198.23,35.54 198.31,35.61 198.46,35.61 198.54,35.69 198.54,35.84 198.46,35.92 198.31,35.92 198.23,35.99 198.23,36.14 198.31,36.22 198.46,36.22 198.54,36.3 198.54,36.45 198.46,36.53 198.31,36.53 198.23,36.6 198.23,36.9 198.54,37.21 198.54,37.98 186.87,49.65 164.71,49.65 156.46,57.9 156.46,66.63 154.07,69.02 151.14,69.02 149.7,70.45 149.7,72.74 v1(149.97,73.01)
  BOTTOM w0.089: v1(149.97,73.01) 149.56,73.41 U6.BF47
  BOTTOM w0.102: v1(198.73,28.3) 198.7,28.27 JDIMM2.52
DDR_B_D24: length 85.1
  IN1 w0.076: v1(201.85,37.26) 200.94,38.17 200.94,38.58 188.25,51.27 169.37,51.27 164.21,56.43 164.11,56.43 163.56,55.88 163.45,55.88 163.35,55.99 163.35,56.1 163.89,56.64 163.89,56.75 163.78,56.86 163.67,56.86 163.13,56.31 163.02,56.31 162.91,56.42 162.91,56.53 163.46,57.07 163.46,57.18 163.35,57.29 163.24,57.29 162.7,56.74 162.59,56.74 162.48,56.85 162.48,56.96 163.03,57.5 163.03,57.61 162.92,57.72 162.81,57.72 162.27,57.18 162.16,57.18 162.05,57.28 162.05,57.39 162.6,57.94 162.6,58.04 162.49,58.15 162.38,58.15 161.84,57.61 161.73,57.61 161.62,57.71 161.62,57.82 162.16,58.37 162.16,58.47 162.06,58.58 161.95,58.58 161.4,58.04 161.3,58.04 158.52,60.82 158.52,67.8 156.6,69.72 155.67,69.72 154.75,70.64 152.11,70.64 151.69,71.07 151.69,72.51 152,72.83 152,74 v1(151.6,74.41)
  BOTTOM w0.089: v1(151.6,74.41) 151.25,74.76 U6.BE44
  BOTTOM w0.102: v1(201.85,37.26) 201.24,36.64 201.24,36.4 200.2,35.36 JDIMM2.57
DDR_B_D25: length 85.4
  IN1 w0.076: v1(151.6,75.11) 152.23,74.47 152.23,72.7 151.91,72.38 151.91,71.16 152.21,70.87 154.84,70.87 155.76,69.95 156.7,69.95 158.75,67.9 158.75,62.21 159.84,61.12 159.84,61.01 159.3,60.47 159.3,60.36 159.41,60.25 159.52,60.25 160.06,60.8 160.17,60.8 160.27,60.69 160.27,60.58 159.73,60.04 159.73,59.93 159.84,59.82 159.95,59.82 160.49,60.36 160.6,60.36 160.71,60.26 160.71,60.15 160.16,59.6 160.16,59.5 160.27,59.39 160.38,59.39 160.92,59.93 161.03,59.93 161.14,59.83 161.14,59.72 160.59,59.17 160.59,59.07 160.7,58.96 160.81,58.96 161.35,59.5 161.46,59.5 161.57,59.39 161.57,59.29 161.02,58.74 161.02,58.63 161.13,58.53 161.24,58.53 161.78,59.07 161.89,59.07 169.46,51.5 188.93,51.5 202.25,38.18 202.25,36.13 v1(201.85,35.73)
  BOTTOM w0.089: v1(151.6,75.11) 151.25,75.46 U6.BD44
  BOTTOM w0.102: v1(201.85,35.73) 201.18,35.73 200.8,35.35 JDIMM2.59
DDR_B_D26: length 87.9
  IN1 w0.076: v1(204.37,37.26) 203.96,37.66 203.96,38.05 189.39,52.62 169.93,52.62 162.94,59.6 162.94,59.71 163.5,60.28 163.5,60.38 163.4,60.49 163.29,60.49 162.72,59.93 162.62,59.93 162.51,60.04 162.51,60.14 163.07,60.71 163.07,60.82 162.97,60.92 162.86,60.92 162.29,60.36 162.19,60.36 162.08,60.47 162.08,60.57 162.64,61.14 162.64,61.25 162.53,61.36 162.43,61.36 161.86,60.79 161.75,60.79 161.65,60.9 161.65,61.01 162.21,61.57 162.21,61.68 162.1,61.79 162,61.79 161.43,61.22 161.32,61.22 161.21,61.33 161.21,61.44 161.78,62 161.78,62.11 161.67,62.22 161.56,62.22 161,61.65 160.89,61.65 160.78,61.76 160.78,61.87 161.35,62.43 161.35,62.54 161.24,62.65 161.13,62.65 160.57,62.08 160.46,62.08 160.35,62.19 160.35,62.3 160.92,62.87 160.92,62.97 159.87,64.02 159.87,68.51 157.31,71.06 156.58,71.06 155.04,72.6 153.06,72.6 152.74,72.92 152.74,75.33 v1(153.22,75.81)
  BOTTOM w0.089: U6.BC42 152.87,76.16 v1(153.22,75.81)
  BOTTOM w0.102: v1(204.37,37.26) 203.2,36.09 JDIMM2.67
DDR_B_D27: length 85.7
  IN1 w0.076: v1(204.37,35.73) 204.76,36.13 204.76,38.18 190.1,52.85 170.02,52.85 165.91,56.96 165.91,57.07 166.47,57.64 166.47,57.74 166.36,57.85 166.26,57.85 165.69,57.29 165.58,57.29 165.47,57.39 165.47,57.5 166.04,58.07 166.04,58.17 165.93,58.28 165.82,58.28 165.26,57.72 165.15,57.72 165.04,57.83 165.04,57.93 165.61,58.5 165.61,58.61 165.5,58.71 165.39,58.71 164.83,58.15 164.72,58.15 164.61,58.26 164.61,58.36 165.18,58.93 165.18,59.04 165.07,59.14 164.96,59.14 164.4,58.58 164.29,58.58 164.18,58.69 164.18,58.8 164.75,59.36 164.75,59.47 164.64,59.58 164.53,59.58 163.96,59.01 163.86,59.01 163.75,59.12 163.75,59.23 164.31,59.79 164.31,59.9 164.21,60.01 164.1,60.01 163.53,59.44 163.43,59.44 163.32,59.55 163.32,59.66 163.88,60.22 163.88,60.33 160.09,64.12 160.09,68.6 157.4,71.29 156.68,71.29 155.14,72.83 153.4,72.83 v1(153.22,73.01)
  BOTTOM w0.089: v1(153.22,73.01) 152.82,73.41 U6.BF42
  BOTTOM w0.102: v1(204.37,35.73) 203.8,35.17 JDIMM2.69
DDR_B_D28: length 85
  IN1 w0.076: v1(151.6,73.01) 151.46,72.87 151.46,70.97 152.02,70.41 154.65,70.41 155.57,69.49 156.51,69.49 158.29,67.71 158.29,60.72 163.51,55.5 163.62,55.5 164.16,56.05 164.27,56.05 164.38,55.94 164.38,55.83 163.97,55.43 163.97,55.32 164.08,55.22 164.19,55.22 164.59,55.62 164.7,55.62 169.27,51.04 188.15,51.04 200.71,38.48 200.71,30.39 v1(201.27,29.83)
  BOTTOM w0.089: v1(151.6,73.01) 151.19,73.41 U6.BF44
  BOTTOM w0.102: JDIMM2.56 199.9,28.46 v1(201.27,29.83)
DDR_B_D29: length 86.5
  IN1 w0.076: v1(201.27,28.3) 200.46,29.12 200.46,38.41 188.06,50.81 169.18,50.81 165.2,54.79 165.1,54.79 164.94,54.63 164.83,54.63 164.72,54.74 164.72,54.85 164.88,55 164.88,55.11 164.77,55.22 164.66,55.22 164.12,54.67 164.01,54.67 158.06,60.63 158.06,67.61 156.42,69.26 155.48,69.26 154.56,70.18 151.87,70.18 151.23,70.82 151.23,72.59 151.12,72.7 151.12,75.33 v1(151.6,75.81)
  BOTTOM w0.089: v1(151.6,75.81) 151.25,76.16 U6.BC44
  BOTTOM w0.102: JDIMM2.58 200.5,27.53 v1(201.27,28.3)
DDR_B_D30: length 87.3
  IN1 w0.076: v1(204.05,29.83) 205.22,31 205.22,38.37 190.29,53.3 170.21,53.3 166.67,56.85 166.67,56.96 167.23,57.52 167.23,57.63 161.26,63.6 161.26,72.59 160.73,73.12 158.04,73.12 156.05,75.11 v1(153.22,75.11)
  BOTTOM w0.089: U6.BD42 152.87,75.46 v1(153.22,75.11)
  BOTTOM w0.102: v1(204.05,29.83) 203.5,29.28 JDIMM2.68
DDR_B_D31: length 86.6
  IN1 w0.076: v1(204.05,28.3) 203.66,28.7 203.66,30.75 204.99,32.09 204.99,38.28 190.19,53.08 170.12,53.08 166.29,56.9 166.29,57.01 166.85,57.58 166.85,57.68 161.03,63.5 161.03,72.35 160.62,72.77 158.02,72.77 156.38,74.41 v1(153.22,74.41)
  BOTTOM w0.089: v1(153.22,74.41) 152.87,74.76 U6.BE42
  BOTTOM w0.102: v1(204.05,28.3) 204.1,28.26 JDIMM2.70
DDR_B_D32: length 98.7
  IN1 w0.076: v1(224.7,35.75) 224.94,35.75 225.02,35.68 225.02,33.3 224.94,33.22 223.68,33.22 223.61,33.3 223.61,33.47 223.68,33.55 224.55,33.55 224.62,33.63 224.62,33.78 224.55,33.85 223.68,33.85 223.61,33.93 223.61,34.08 223.68,34.16 224.55,34.16 224.62,34.24 224.62,34.39 224.55,34.46 223.68,34.46 223.61,34.54 223.61,34.69 223.68,34.77 224.55,34.77 224.62,34.85 224.62,35 224.55,35.07 223.99,35.07 223.91,35.15 223.91,39.72 223.17,40.46 205.68,40.46 190.42,55.72 175.5,55.72 168.33,62.89 168.33,76.84 v1(169.37,77.87)
  BOTTOM w0.089: U6.BA16 169.68,77.56 v1(169.37,77.87)
  BOTTOM w0.102: JDIMM2.129 224.2,35.25 v1(224.7,35.75)
DDR_B_D33: length 99.8
  IN1 w0.076: v1(170.28,80.68) 169.74,80.14 169.74,77.72 168.56,76.55 168.56,62.98 168.65,62.9 168.75,62.79 168.86,62.79 169.36,63.29 169.46,63.29 169.63,63.12 169.63,63.01 169.13,62.52 169.13,62.41 169.24,62.3 169.35,62.3 169.85,62.8 169.95,62.8 170.06,62.69 170.06,62.58 169.57,62.09 169.57,61.98 169.67,61.87 169.78,61.87 170.28,62.37 170.38,62.37 170.49,62.26 170.49,62.15 170,61.66 170,61.55 170.1,61.44 170.21,61.44 170.71,61.94 170.82,61.94 170.92,61.83 170.92,61.72 170.43,61.23 170.43,61.12 170.54,61.01 170.64,61.01 171.14,61.51 171.25,61.51 171.35,61.4 171.35,61.29 170.86,60.79 170.86,60.69 175.59,55.95 190.51,55.95 205.77,40.69 223.26,40.69 224.14,39.81 224.14,38.87 224.22,38.79 224.56,38.79 224.64,38.72 224.64,38.57 224.56,38.49 224.22,38.49 224.14,38.41 224.14,36.98 224.22,36.9 224.63,36.9 224.7,36.98 v1(224.7,37.28)
  BOTTOM w0.089: U6.AU16 169.96,80.36 v1(170.28,80.68)
  BOTTOM w0.102: v1(224.7,37.28) 225.28,36.7 225.28,35.62 224.8,35.13 JDIMM2.131
