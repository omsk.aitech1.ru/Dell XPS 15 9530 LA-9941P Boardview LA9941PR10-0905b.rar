# Allegro board LA9941PR10-0905b.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS on BOTTOM (solid shape): 16.64,106.59 17.8,106.59 18.06,106.85 19.31,106.85 20.33,105.83 20.33,103.77 19.98,103.42 18.98,103.42 18.92,103.48 18.92,104.38 18.3,105.01 14.52,105.01 14.21,105.32 14.21,106.64 14.43,106.85 16.38,106.85
+5VS on BOTTOM (solid shape): 41.75,48.67 41.75,47.88 41.07,47.21 41.07,43.83 40.78,43.53 40.19,43.53 40.14,43.59 40.14,44.22 39.63,44.22 39.59,44.26 39.59,44.68 39.63,44.72 40.14,44.72 40.14,45.42 39.63,45.42 39.59,45.45 39.59,45.89 39.62,45.92 40.14,45.92 40.14,46.7 40.13,46.7 40.13,48.7 40.25,48.82 41.6,48.82
+5VS on IN2 (solid shape): 20.36,105.61 20.36,104.28 20.17,104.09 18.77,104.09 18.2,104.66 18.2,104.66 18.03,104.83 18.03,105.98 18.21,106.17 19.8,106.17
+5VS on IN2 (solid shape): 42.02,46.96 42.02,45.66 41.92,45.56 40.06,45.56 39.74,45.88 39.74,46.84 40.19,47.29 41.7,47.29
+5VS on IN2 (solid shape): outline of 714 points within 26.21,66.43 30.52,82.63
+5VS on IN3 (solid shape): 41.01,46.97 41.01,44.53 40.8,44.33 39.51,44.33 39.28,44.56 39.28,46.87 39.48,47.07 40.91,47.07
+5VS on IN3 (solid shape): 34.48,44.79 34.48,43.09 33.64,42.25 33.64,41.23 33.89,40.98 34.07,40.98 34.2,40.85 34.2,40.24 34.02,40.06 32.24,40.06 32.12,40.19 32.12,44.61 32.35,44.84 34.43,44.84
+5VS on IN4 (solid shape): 41.83,45.64 41.83,44.94 41.49,44.6 41.26,44.6 40.41,45.45 40.41,46.49 40.62,46.69 40.78,46.69
+5VS on IN4 (solid shape): 51.94,36.61 52.4,36.61 52.72,36.28 52.72,35.43 52.58,35.29 51.82,35.29 50.81,36.3 50.81,36.53 51.24,36.97 51.58,36.97
+5VS_HDD on TOP (solid shape): 39.04,31.41 39.04,29.95 38.37,29.27 36.92,29.27 36.82,29.37 36.81,29.44 36.79,29.5 36.79,31.09 37.16,31.46 39,31.46
+5VS_HDD on BOTTOM (solid shape): 30.05,26.83 30.05,24.53 29.82,24.3 29.03,24.3 28.5,24.84 28.5,26.61 28.85,26.97 29.91,26.97
+5VS_HDD on BOTTOM (solid shape): 62.32,36.25 62.32,35.62 62.34,35.59 62.82,35.59 62.86,35.55 62.86,35.16 62.83,35.13 62.38,35.13 62.32,35.07 62.32,34.4 62.34,34.38 62.83,34.38 62.87,34.34 62.87,33.97 62.83,33.93 62.35,33.93 62.33,33.91 62.33,33.2 62.45,33.08 62.7,33.08 62.81,32.97 62.81,32.54 62.43,32.16 60.81,32.16 60.48,32.49 60.48,36.33 60.61,36.46 62.11,36.46
+5VS_HDD on IN2 (solid shape): 39.53,30.79 39.53,30.03 38.62,29.12 37.07,29.12 36.89,29.3 36.89,30.72 37.2,31.02 39.3,31.02
+5VS_HDD on IN2 (solid shape): 62.88,32.91 62.88,31.04 62.73,30.9 60.83,30.9 60.58,31.15 60.58,32.66 61.05,33.13 62.66,33.13
+5VS_HDD on IN4 (solid shape): 38.41,30.37 38.41,28.31 38.32,28.23 37.04,28.23 36.86,28.4 36.86,30.35 37.04,30.52 38.26,30.52
+5VS_HDD on IN4 (solid shape): 30.72,25.99 30.72,24.44 30.55,24.27 29.2,24.27 29.13,24.28 29.06,24.27 28.97,24.27 28.68,24.57 28.68,25.93 28.89,26.15 30.56,26.15
+5VS_HDDAPL on BOTTOM (solid shape): 63.7,35.81 63.7,34.66 64.72,33.64 65.67,33.64 66.06,33.26 66.06,32.6 65.67,32.21 63.73,32.21 62.76,33.18 62.49,33.18 62.46,33.22 62.46,33.8 63,33.8 63,34.51 62.46,34.51 62.46,35 63,35 63,35.71 62.46,35.71 62.46,36.21 62.55,36.31 63.2,36.31
+5VS_KBL on BOTTOM (solid shape): 227.75,22.17 230.04,22.17 230.16,22.05 230.16,20.9 229.85,20.59 225.71,20.59 225.67,20.6 225.62,20.62 225.57,20.62 225.52,20.62 225.47,20.62 225.42,20.6 225.38,20.59 225.26,20.59 225.08,20.4 225.08,20.15 224.85,19.92 221.48,19.92 221.16,20.24 221.16,21.22 226.63,21.22 226.63,22.11 225.49,22.11 225.49,21.22 221.16,21.22 221.16,23.16 221.51,23.51 226.42,23.51
+5VS_TPS on BOTTOM (solid shape): 40,46.57 40,46.08 39.95,46.04 39.5,46.04 39.45,45.99 39.45,45.33 39.51,45.27 39.99,45.27 40.01,45.25 40.01,44.9 39.94,44.83 39.54,44.83 39.46,44.75 39.46,44.16 39.53,44.09 39.99,44.09 40.01,44.06 40.01,43.53 39.96,43.48 38.58,43.48 37.54,44.52 37.02,44.52 36.96,44.58 36.96,46.36 37.21,46.61 39.95,46.61
+V1.05V_B+ on TOP (solid shape): 243.33,65.1 243.33,64.2 243.58,63.94 245.3,63.94 245.4,63.84 245.4,62.55 245.03,62.17 238.76,62.17 238.76,62.69 238.05,62.69 238.05,62.17 237.56,62.17 237.56,62.69 236.85,62.69 236.85,62.17 235.65,62.17 235.27,62.56 235.27,64.9 235.58,65.22 243.2,65.22
+V1.05V_B+ on BOTTOM (solid shape): 247.18,65.16 247.18,62.27 247.03,62.12 240.7,62.12 240.13,62.68 240.13,64.87 240.43,65.17 247.17,65.17
+V18R on TOP (solid shape): 166.91,14.71 166.91,14.46 167.07,14.3 167.07,14.28 167.13,14.15 167.27,14.08 167.8,13.55 168.86,13.55 168.92,13.49 168.92,12.52 168.83,12.44 167.62,12.44 167.26,12.8 167.26,13.15 167.1,13.3 167.1,13.37 167.03,13.37 166.69,13.71 166.69,14.01 166.72,14.03 166.85,14.23 166.72,14.44 166.69,14.45 166.69,14.55 166.69,14.56 166.69,14.74 166.75,14.8 166.81,14.8
+VCC_CORE on TOP (solid shape): outline of 2741 points within 147.89,81.29 174.43,106.81
+VCC_CORE on BOTTOM (solid shape): outline of 836 points within 120.08,80.91 140.31,100.66
+VCC_CORE on BOTTOM (solid shape): outline of 4576 points within 143.44,81.11 175.55,115.45
+VCC_CORE on IN3 (solid shape): outline of 9662 points within 120.03,74.61 176.7,105.67
+VCC_CORE on IN4 (solid shape): outline of 4983 points within 142.73,82.94 174.66,103.16
+VCC_CORE on VCC: 126.4,67.86 125.92,68.34 125.92,100.23 132.22,106.59 132.3,109.08 136.36,113.14 137.53,113.14 140.47,116.09 156.27,116.09 156.27,111.79 156.93,111.13 175.85,111.13 179.77,107.22 179.77,94.58 179.18,93.99 175.72,93.99 174.69,92.95 174.69,87.41 176.85,85.25 176.85,82.03 176.49,81.67 147.61,81.67 147.25,82.03 147.25,89.9 146.73,90.43 137.75,90.43 136.71,89.39 136.71,67.86
+VCC_PWR_SRC1 on TOP (solid shape): 118.02,110.25 118.02,109.61 117.7,109.29 117.7,108.72 118.12,108.3 118.12,107.84 117.98,107.71 112.43,107.71 112.18,107.96 112.18,110.25 112.43,110.5 117.77,110.5
+VCC_PWR_SRC1 on BOTTOM (solid shape): 115.54,110.17 116.25,110.17 116.25,110.7 116.74,110.7 116.74,110.17 117.45,110.17 117.45,110.7 118.1,110.7 118.17,110.62 118.17,109.64 117.09,108.56 117.09,107.64 116.91,107.45 112.35,107.45 112.1,107.7 112.1,110.17 112.63,110.7 115.54,110.7
+VCC_PWR_SRC2 on TOP (solid shape): 118.66,73.42 121.7,73.42 121.8,73.31 121.8,70.76 121.16,70.12 113.83,70.12 113.58,70.37 113.58,73.55 113.83,73.8 118.28,73.8
+VCC_PWR_SRC2 on BOTTOM (solid shape): 123.8,76.91 123.8,66.64 123.44,66.27 120.14,66.27 119.7,66.72 119.7,67.62 120.36,68.29 120.36,69.72 119.96,70.12 116.93,70.12 116.93,70.68 114.85,70.68 114.64,70.47 114.64,70.07 113.86,70.07 113.6,70.32 113.6,73.37 113.83,73.6 116.31,73.6 116.85,74.14 116.85,77.08 117.16,77.38 123.33,77.38
+VCCAFDI_VRM on TOP (solid shape): 255.27,38.47 255.27,37.39 255.08,37.21 254.64,37.21 254.46,37.02 254.46,35.51 254.83,35.14 256.49,35.14 256.65,34.98 256.65,33.59 257.31,32.92 257.31,30.44 257.08,30.2 255.84,30.2 255.67,30.37 255.67,30.81 255.74,30.89 256.24,30.89 256.43,31.08 256.43,32.13 256.08,32.47 254.65,32.47 254.44,32.27 254.44,31.82 254.38,31.75 253.59,31.75 253.48,31.87 253.48,38.64 253.55,38.71 255.03,38.71
+VCCAFDI_VRM on IN1 (solid shape): outline of 826 points within 254.79,35.02 264.45,40.31
+VCCAFDI_VRM on IN4 (solid shape): 263.99,35.86 264.08,35.88 264.2,35.88 264.26,35.81 264.26,35.52 263.4,34.66 262.74,34.66 262.31,34.23 262.31,33.62 262.97,32.96 262.97,32.35 262.83,32.21 262.2,32.21 261.71,32.7 261.71,34.95 262.64,35.88 263.89,35.88
+VCCP on TOP (solid shape): 263.13,31.45 263.13,29.22 262.88,28.96 262.57,28.96 262.38,29.15 262.38,31.12 262.39,31.13 262.39,31.55 262.49,31.66 262.93,31.66
+VCCP on TOP (solid shape): 270.14,20.72 270.14,20.58 270.02,20.46 269.61,20.46 269.56,20.41 269.56,19.99 269.6,19.96 270.09,19.96 270.12,19.92 270.12,19.53 269.95,19.35 268.72,19.35 268.43,19.65 268.42,19.65 268.3,19.76 267.71,19.76 267.59,19.87 267.59,20.58 267.69,20.68 269.06,20.68 269.2,20.82 270.03,20.82
+VCCP on TOP (solid shape): outline of 335 points within 251.53,41.02 269.09,51.19
+VCCP on BOTTOM (solid shape): outline of 975 points within 203.45,51.76 255.33,67.25
+VCCP on IN2 (solid shape): outline of 215 points within 264.94,18.43 268.95,20.99
+VCCP on IN3 (solid shape): outline of 2349 points within 252.92,28.52 270.14,60.12
+VCCP on VCC: 263.69,26.17 260.9,28.96 256.71,28.96 255.84,29.83 255.84,50.41 253.05,53.2 253.05,57.06 249.24,60.88 249.24,64.8 250.1,65.67 256.97,65.67 262.22,54.4 271.33,45.95 271.33,28.31 269.2,26.17
AGND on TOP (solid shape): 13.96,30.26 13.96,30.04 13.95,30.04 13.95,28.89 13.9,28.84 13.63,28.84 13.63,29.37 13.19,29.37 13.19,28.84 12.91,28.84 12.86,28.89 12.86,30.06 12.99,30.19 12.99,30.19 13.22,30.41 13.8,30.41
AGND on TOP (solid shape): 20.75,37.61 20.76,37.53 20.76,36.3 20.53,36.08 18.79,36.08 18.6,36.27 18.6,36.8 18.61,36.8 18.62,36.9 18.61,37 18.6,37.01 18.6,38.04 18.73,38.17 20.19,38.17
AGND on BOTTOM (solid shape): 22.86,44.36 23.4,44.36 23.56,44.2 23.56,43.7 23.05,43.7 23.05,40.14 23.43,39.76 24.45,39.76 24.57,39.63 24.57,39.25 22.16,39.25 21.65,39.77 21.65,40.39 21.32,40.71 21.32,40.71 21.12,40.91 18.31,40.91 17.75,41.47 17.75,41.64 17.86,41.75 17.91,41.77 18.15,41.77 18.71,42.33 18.71,42.99 18.83,43.11 18.83,43.11 18.88,43.15 21.46,43.15 21.77,43.47 21.77,44.63 21.96,44.82 22.4,44.82
AGND on GND1: 4.49,30.11 4.13,30.47 4.13,37.68 13.16,37.68 13.9,38.31 13.42,39.15 13.42,44.58 13.9,45.42 13.16,46.04 5.56,46.04 5.56,47.25 16.97,47.25 17.81,46.41 24.65,46.41 25,46.05 25,44.39 24.93,44.31 22.84,44.31 22.52,43.98 22.52,39.96 23.1,39.38 27.29,39.38 27.49,39.58 27.49,40.77 27.55,40.83 28.48,40.83 28.64,40.67 28.64,36.94 27.7,36 24.22,32.77 18.12,32.77 15.45,30.11
AGND on VCC: 4.82,36.67 10.65,36.67 13.16,36.67 14.79,37.75 14.43,39.67 14.43,44.06 14.79,45.98 13.16,47.06 10.65,47.06 10.65,47.25 16.07,47.25 16.07,47.25 16.97,47.25 17.81,46.41 24.65,46.41 25,46.05 25,44.39 24.93,44.31 22.84,44.31 22.52,43.98 22.52,39.96 23.08,39.39 27.3,39.39 27.49,39.59 27.49,40.77 27.55,40.83 28.48,40.83 28.64,40.67 28.64,36.94 27.77,36.08 24.23,32.78 24.22,32.77 18.1,32.77 15.44,30.11 4.48,30.11 4.12,30.48 4.12,36.36 4.2,36.44 4.59,36.44
AGND on GND2: 4.49,30.11 4.13,30.47 4.13,36.08 4.12,36.08 4.12,37.68 13.16,37.68 13.9,38.31 13.42,39.15 13.42,44.58 13.9,45.42 13.16,46.04 5.52,46.04 5.52,47.25 16.97,47.25 17.81,46.41 24.65,46.41 25,46.05 25,44.39 24.93,44.31 22.84,44.31 22.52,43.98 22.52,39.96 23.1,39.38 27.29,39.38 27.49,39.58 27.49,40.77 27.55,40.83 28.48,40.83 28.64,40.67 28.64,36.94 27.7,36 24.22,32.77 18.12,32.77 15.45,30.11
AGND on GND3: 4.49,30.11 4.13,30.47 4.13,37.68 13.16,37.68 13.9,38.31 13.42,39.15 13.42,44.58 13.9,45.42 13.16,46.04 5.52,46.04 5.52,47.25 16.97,47.25 17.81,46.41 24.65,46.41 25,46.05 25,44.39 24.93,44.31 22.84,44.31 22.52,43.98 22.52,39.96 23.1,39.38 27.29,39.38 27.49,39.58 27.49,40.77 27.55,40.83 28.48,40.83 28.64,40.67 28.64,36.94 27.7,36 24.22,32.77 18.12,32.77 15.45,30.11
GND on TOP (solid shape): 10.52,23.95 10.52,21.92 10.39,21.79 7.28,21.79 7.15,21.92 7.15,24.02 7.41,24.27 10.2,24.27
GND on TOP (solid shape): 105.09,12.66 105.09,11.01 104.97,10.88 98.31,10.88 98.22,10.97 98.22,11.86 99.07,12.71 105.04,12.71
GND on TOP (solid shape): 119.93,106.95 119.93,103.52 119.67,103.26 112.43,103.26 112.31,103.39 112.31,107.33 112.43,107.45 119.42,107.45
GND on TOP (solid shape): 187.01,110.4 187.01,108.72 186.93,108.64 185.91,108.64 185.76,108.8 185.76,110.65 185.81,110.7 186.7,110.7
GND on TOP (solid shape): 211.5,124.5 211.5,121.48 211.06,121.04 210.39,121.04 210.31,121.12 210.31,124.48 210.45,124.62 211.38,124.62
GND on TOP (solid shape): 219.52,64.71 219.52,64.14 219.39,64.02 217.1,64.02 216.91,64.21 216.91,64.65 217.1,64.84 219.39,64.84
GND on TOP (solid shape): 230.38,108.66 230.38,106.8 230.14,106.56 228.4,106.56 228.02,106.94 228.02,108.69 228.1,108.77 230.28,108.77
GND on TOP (solid shape): 253.15,36.58 253.15,31.64 252.97,31.46 251.99,31.46 251.85,31.6 251.85,36.88 251.88,36.9 252.83,36.9
GND on TOP (solid shape): 29.88,81.1 29.88,76.91 29.69,76.72 27.66,76.72 27.53,76.85 27.53,81.29 27.6,81.36 29.63,81.36
GND on TOP (solid shape): 35.95,17.89 35.95,16.67 35.7,16.42 30.11,16.42 30.01,16.52 30.01,17.54 30.49,18.02 35.82,18.02
GND on TOP (solid shape): 36.01,95.72 36.01,88.15 35.73,87.87 33.82,87.87 33.72,87.97 33.72,89.18 33.2,89.69 33.2,94.44 34.66,95.9 35.83,95.9
GND on TOP (solid shape): 81.13,31.11 81.13,26.63 81.04,26.54 78.57,26.54 78.33,26.78 78.33,30.62 78.88,31.17 81.06,31.17
GND on TOP (solid shape): 35.6,48.2 11.62,48.2 11.62,49 34.8,49 34.8,83.5 12.38,83.5 12.28,83.6 12.18,83.68 12.18,84.3 35.6,84.3
GND on TOP (solid shape): 126.43,118.43 126.43,115.68 127.15,114.96 127.15,114.1 127.06,114.01 126.89,114.01 126.66,114.24 122.9,114.24 122.54,114.59 122.54,118.28 122.95,118.68 126.18,118.68
GND on TOP (solid shape): 143.32,124.23 143.32,121.31 142.74,120.72 141.92,120.72 141.73,120.53 141.73,119.77 141.6,119.64 140.71,119.64 140.59,119.77 140.59,124.47 140.78,124.66 142.89,124.66
GND on TOP (solid shape): 248.29,36.77 248.29,34.06 248.18,33.96 246.83,33.96 246.39,34.4 246.39,34.51 246.39,34.51 246.39,35.28 246.39,35.28 246.39,36.48 246.8,36.89 248.16,36.89
GND on TOP (solid shape): 182.43,123.52 182.43,122.82 182.31,122.69 181.78,122.69 181.65,122.57 181.65,121.81 181.39,121.81 181.39,122.44 181.14,122.69 180.89,122.69 180.76,122.82 180.76,123.58 180.89,123.71 182.24,123.71
GND on TOP (solid shape): 125.64,16.4 125.64,14.97 125.57,14.9 125.57,13.96 125.46,13.86 125.11,13.86 125.03,13.93 125.03,14.8 125.41,15.18 125.41,16.4 125.49,16.47 125.57,16.47
GND on TOP (solid shape): 127.27,24.07 127.27,22.45 126.97,22.15 126.43,22.15 126.42,22.16 125.92,22.16 125.22,21.46 124.65,21.46 124.57,21.54 124.57,24.36 124.46,24.47 124.46,24.86 124.67,25.07 126.26,25.07
GND on TOP (solid shape): 95.31,23.63 95.31,18.55 96.33,17.53 97.72,17.53 97.98,17.28 97.98,15.76 97.47,15.25 91.88,15.25 91.76,15.37 91.76,16.14 91.88,16.26 92.77,16.26 93.41,16.9 93.41,23.38 93.79,23.76 95.18,23.76
GND on TOP (solid shape): 166.03,125.23 170.98,125.23 171.23,124.98 171.23,121.93 170.85,121.55 162.43,121.55 162.1,121.88 162.1,125.56 162.15,125.61 165.66,125.61
GND on TOP (solid shape): 167.03,13.19 167.03,12.81 167.98,11.86 168.85,11.86 168.95,11.76 168.95,10.95 168.82,10.82 167.62,10.82 167.34,11.09 167.34,11.36 167.02,11.69 166.48,11.69 166.39,11.78 166.39,13.18 166.47,13.26 166.97,13.26
GND on TOP (solid shape): 116.96,77.86 125.26,77.86 125.9,77.23 125.9,74.31 125.39,73.8 119.16,73.8 118.78,74.18 113.2,74.18 113.07,74.05 110.91,74.05 110.66,74.31 110.66,77.74 111.48,78.56 116.27,78.56
GND on TOP (solid shape): 128.82,14.11 131.74,14.11 131.99,13.86 131.99,13.85 132.14,13.7 132.14,12.2 132.08,12.14 131.53,12.14 131.22,11.82 128.16,11.82 127.42,12.56 127.42,14.41 127.65,14.64 128.29,14.64
GND on TOP (solid shape): 188.12,123.14 188.12,121.85 187.64,121.37 187.35,121.37 187.07,121.09 186.15,121.09 185.89,121.35 184.16,121.35 183.91,121.6 183.91,123.15 184.06,123.3 187.97,123.3
GND on TOP (solid shape): 76.24,23.38 76.24,19.16 76.59,18.8 77.46,18.8 77.56,18.7 77.56,18.04 77.46,17.94 76.49,17.94 76.24,17.69 76.24,16.65 75.98,16.4 72.68,16.4 72.56,16.52 72.56,23.25 72.81,23.51 76.11,23.51
GND on TOP (solid shape): 159.83,68.52 159.83,67.76 157.92,65.86 157.29,65.86 157.19,65.95 157.19,65.97 157,66.63 156.72,67.25 156.72,67.27 156.72,68.21 157.1,68.59 159.76,68.59
GND on TOP (solid shape): 266.88,33.35 266.88,32.97 267.14,32.72 268.03,32.72 268.15,32.59 268.15,32.34 268.47,32.02 268.47,31.38 268.41,31.32 267.9,31.32 267.84,31.38 267.84,31.83 267.65,32.02 266.12,32.02 266.06,32.08 266.06,33.16 266.38,33.48 266.76,33.48
GND on TOP (solid shape): 211.45,84.46 212.09,84.46 212.34,84.21 212.34,79.31 211.64,78.61 211.64,77.92 211.39,77.67 210.63,77.67 210.5,77.8 210.5,79.19 210.76,79.45 210.76,80.4 210.44,80.72 210.44,84.84 210.5,84.91 211.01,84.91
GND on TOP (solid shape): 13.53,28.71 13.55,28.68 14.31,28.68 14.46,28.53 14.46,27.92 14.36,27.82 14.26,27.82 13.69,27.82 13.43,28.08 12.98,28.08 12.86,28.19 12.86,28.66 12.89,28.68 13.27,28.68 13.29,28.71 13.29,29.27 13.53,29.27
GND on TOP (solid shape): 126.05,19.39 126.05,18.43 125.94,18.32 125.94,16.62 124.34,16.62 124.32,16.64 124.32,18.22 124.34,18.24 124.95,18.24 125.03,18.32 125.03,19.39 125.08,19.44 125.18,19.44 125.23,19.39 125.23,18.37 125.36,18.24 125.62,18.24 125.82,18.45 125.82,19.39 125.87,19.44 126,19.44
GND on TOP (solid shape): 244.84,68.44 244.84,65.7 245.12,65.42 245.12,64.38 244.95,64.2 243.68,64.2 243.55,64.33 243.55,65.21 243.35,65.41 239.89,65.41 239.71,65.59 239.71,66.85 239.87,67 240.09,67 240.22,67.13 240.79,67.13 241.55,67.89 241.55,68.14 241.98,68.57 244.72,68.57
GND on TOP (solid shape): 160.06,126.65 160.06,121.3 158.41,119.65 155.26,119.65 155.13,119.77 154.11,120.28 153.22,120.53 152.06,120.53 151.93,120.66 151.93,121.27 152.16,121.5 154.93,121.5 155.29,121.13 156.3,121.13 156.5,121.33 156.5,126.73 156.78,127.01 159.7,127.01
GND on TOP (solid shape): 179.19,126.82 179.19,126.36 179.84,125.71 179.84,124.78 180.1,124.52 180.1,122.73 179.68,122.31 174.15,122.31 173.95,122.11 171.84,122.11 171.62,122.33 171.62,126.25 171.74,126.38 172.38,126.38 172.63,126.12 178.04,126.12 178.11,126.19 178.11,126.82 178.18,126.89 179.12,126.89
GND on TOP (solid shape): 47.03,21.22 47.03,18.04 46.9,17.92 45.12,17.92 44.87,17.67 44.87,17.28 44.74,17.16 43.98,17.16 43.85,17.03 43.85,16.52 43.73,16.4 40.81,16.4 40.55,16.65 40.55,18.55 40.68,18.68 42.2,18.68 42.33,18.81 42.33,19.59 41.59,20.33 41.59,21.12 41.64,21.17 45.07,21.17 45.5,21.6 46.65,21.6
GND on TOP (solid shape): 266.9,30.9 266.9,29.81 267.11,29.59 267.11,28.98 266.86,28.73 266.86,28.26 266.51,27.92 266.5,27.91 266.43,27.88 266.37,27.83 266.07,27.53 265.51,27.53 265.51,27.33 265.18,27.33 265.02,27.5 265.02,28.29 265.02,28.51 265.02,28.53 264.81,28.73 264.81,29.55 264.88,29.62 266.22,29.62 266.44,29.84 266.41,29.94 266.4,30.06 266.45,30.17 266.48,30.2 266.48,30.65 266.46,30.68 266.44,30.89 266.59,31.03 266.77,31.03
GND on TOP (solid shape): 11.45,103.16 12.48,103.16 12.94,102.7 12.94,101.1 9.87,98.03 9.87,95.54 9.38,95.05 7.42,95.05 7.19,95.28 7.19,96.41 7.14,96.47 0.95,96.47 0.95,101.1 8.84,101.1 10.08,100.82 9.8,102.06 9.8,104.29 9.82,104.3 10.31,104.3
GND on TOP (solid shape): 158.68,98.37 158.68,96.57 158.64,96.48 158.54,96.48 158.06,96.18 158.54,95.89 158.64,95.89 158.68,95.8 158.68,95.32 159.07,94.94 159.07,84.46 158.84,84.24 155.41,84.24 154.81,84.84 154.81,94.37 155.19,94.75 156.46,94.75 156.97,95.26 156.97,98.37 157.03,98.43 158.62,98.43
GND on TOP (solid shape): 28.84,60.54 28.92,60.46 29.88,60.46 29.96,60.39 29.96,60.29 29.91,60.24 28.94,60.24 28.84,60.13 28.84,59.25 27.04,59.25 27.04,63.87 28.84,63.87
GND on TOP (solid shape): 21.35,78.26 21.43,78.27 21.78,78.27 21.85,78.26 21.93,78.27 22.28,78.27 22.32,78.26 22.35,78.26 22.43,78.23 22.46,78.16 22.46,78.12 22.47,78.08 22.47,77.73 22.46,77.66 22.47,77.58 22.47,76.66 22.44,76.58 22.36,76.55 22.32,76.55 22.28,76.54 21.93,76.54 21.85,76.55 21.78,76.54 21.63,76.54 21.48,76.39 21.48,75.45 21.43,75.4 21.27,75.4 21.22,75.45 21.22,76.47 21.15,76.54 20.93,76.54 20.88,76.55 20.84,76.55 20.76,76.58 20.73,76.65 20.73,76.75 20.71,76.76 20.71,77.09 20.73,77.16 20.71,77.23 20.71,77.59 20.73,77.66 20.71,77.73 20.71,78.02 20.74,78.09 20.75,78.16 20.78,78.23 20.85,78.26 20.89,78.26 20.93,78.27 21.28,78.27
GND on TOP (solid shape): 276.9,10.9 279.3,13.3 281.7,10.9 281.7,9.5 280.95,9.5 280.6,9.65 280.45,10 280.45,10.9 279.3,12.05 278.15,10.9 278.15,9 277.86,8.29 277.15,8 276.9,8
GND on TOP (solid shape): 139.15,128.79 139.15,126.15 138.61,125.37 138.77,124.44 138.77,123.2 138.61,123.04 138.51,123.01 138.44,123.1 137.89,124.01 136.83,124.16 135.32,122.9 136.93,121.76 137,121.74 137.07,121.74 137.16,121.67 137.14,121.56 136.76,121.19 129.75,121.19 128.61,122.34 128.61,124.4 128.61,124.42 128.12,125.69 126.75,125.75 125.61,125.75 125.41,125.94 125.41,126.12 125.87,126.58 125.87,126.68 125.88,126.69 126.38,127.54 126.55,128.5 126.55,128.75 126.77,129.28 127.3,129.5 138.44,129.5
GND on TOP (solid shape): 9.64,88.1 9.64,87.41 9.13,86.9 8.18,86.9 7.79,86.5 4.49,86.5 3.41,85.43 3.41,84.01 4.4,83.02 10.11,83.02 11.32,83.5 12.32,82.66 12.55,82.43 14.34,82.43 14.67,82.1 14.67,81.24 14.34,80.91 12.56,80.91 12.38,80.73 12.38,71.36 14.67,69.07 14.67,62.9 14.18,62.42 12.86,62.42 12.38,61.93 12.38,51.7 12.84,51.24 14.01,51.24 14.57,50.68 14.57,49.97 14.11,49.51 14.11,48.34 13.65,47.89 0.95,47.89 0.95,49.41 10.41,49.41 11.25,48.92 11.87,49.66 11.87,63.76 11.25,64.5 10.41,64.01 0.95,64.01 0.95,67.91 10.41,67.91 11.25,67.42 11.87,68.16 11.87,82.26 11.25,83 10.41,82.51 0.95,82.51 0.95,87.01 7.17,87.01 7.17,88.35 9.38,88.35
GND on TOP (solid shape): outline of 336 points within 231.81,115.28 257.05,129.5
GND on TOP (solid shape): outline of 95 points within 0.95,0.25 290.85,15.76
GND on TOP (solid shape): outline of 531 points within 268.08,32.14 274.68,43.31
GND on TOP (solid shape): outline of 233 points within 0.95,40.35 290.85,129.5
GND on BOTTOM (solid shape): 232.3,118 228.8,118 228.8,127.75 193.3,127.75 193.3,129.5 232.3,129.5
GND on BOTTOM (solid shape): 3.87,31.45 3.87,29.9 3.72,29.75 2.98,29.75 2.65,30.08 2.65,31.33 3.01,31.68 3.64,31.68
GND on BOTTOM (solid shape): 111.8,68.11 111.8,64.81 111.75,64.76 110.46,64.76 110.25,64.97 110.25,68.07 110.44,68.26 111.65,68.26
GND on BOTTOM (solid shape): 125.94,117.51 125.94,114.92 125.89,114.87 123.3,114.87 123.23,114.94 123.23,117.51 123.28,117.56 125.89,117.56
GND on BOTTOM (solid shape): 143.52,123.66 143.52,121.24 143.47,121.19 141.01,121.19 140.96,121.24 140.96,123.66 141.01,123.71 143.47,123.71
GND on BOTTOM (solid shape): 159.95,67.64 159.95,63.25 159.7,63 157.22,63 157.1,63.13 157.1,67.51 157.41,67.83 159.76,67.83
GND on BOTTOM (solid shape): 181.89,66.75 181.89,63.06 181.67,62.84 177.86,62.84 177.67,63.03 177.67,66.4 178.12,66.84 181.8,66.84
GND on BOTTOM (solid shape): 187.01,112.3 187.01,108.77 186.83,108.59 186.05,108.59 185.86,108.78 185.86,112.28 186.12,112.53 186.78,112.53
GND on BOTTOM (solid shape): 249.65,12.09 249.65,11.61 249.6,11.56 247.4,11.56 247.29,11.68 247.29,12.08 247.43,12.22 249.52,12.22
GND on BOTTOM (solid shape): 145.35,13.09 145.35,11.31 144.97,10.93 142.41,10.93 142.17,11.16 142.17,13.34 142.3,13.47 144.97,13.47
GND on BOTTOM (solid shape): 60.41,19.31 60.41,16.77 60.03,16.39 57.48,16.39 57.32,16.55 57.32,19.26 57.49,19.44 60.29,19.44
GND on BOTTOM (solid shape): 116.62,77.59 116.62,74.43 116.24,74.05 110.78,74.05 110.66,74.18 110.66,77.74 110.78,77.86 116.36,77.86
GND on BOTTOM (solid shape): 120.05,106.82 120.05,103.26 119.93,103.14 112.56,103.14 112.13,103.57 112.13,106.89 112.43,107.2 119.67,107.2
GND on BOTTOM (solid shape): 256.03,74.98 256.03,72.31 255.91,72.19 253.75,72.19 253.74,72.18 253.15,72.18 252.87,72.46 252.87,74.98 253,75.11 255.91,75.11
GND on BOTTOM (solid shape): 257.81,10.7 257.81,9.05 257.74,8.98 256.83,8.98 256.77,9.05 256.77,10.7 256.84,10.78 257.73,10.78
GND on BOTTOM (solid shape): 131.38,99.05 131.38,95.58 131.06,95.26 127.63,95.26 127.38,95.51 127.38,99.03 127.99,99.64 130.79,99.64
GND on BOTTOM (solid shape): 185.49,111.57 185.49,109.18 185.04,108.72 179.51,108.72 179.07,109.16 179.07,111.13 179.07,111.14 179.07,111.54 179.17,111.65 185.42,111.65
GND on BOTTOM (solid shape): 17.74,48 6.27,48 6.27,48.82 16.86,48.82 16.86,83.8 6.3,83.8 6.3,84.6 17.74,84.6
GND on BOTTOM (solid shape): 76.37,23.63 76.37,16.65 76.24,16.52 72.66,16.52 72.56,16.63 72.56,23.63 72.68,23.76 76.24,23.76
GND on BOTTOM (solid shape): 186.5,119.26 186.5,118.82 185.99,118.31 185.99,116.97 185.61,116.59 182.78,116.59 182.7,116.67 182.7,119.24 182.85,119.39 186.37,119.39
GND on BOTTOM (solid shape): 79.16,27.57 79.16,26.48 79.26,26.38 79.26,26.07 78.96,25.77 78.96,25.64 78.78,25.46 78.45,25.46 78.37,25.54 78.37,26.05 78.91,26.58 78.91,27.57 78.98,27.65 79.08,27.65
GND on BOTTOM (solid shape): 126.76,24.73 126.76,22.49 126.3,22.04 125.1,22.04 124.91,22.23 124.91,24.13 124.43,24.6 124.43,24.83 124.56,24.96 126.52,24.96
GND on BOTTOM (solid shape): 128.88,75.86 128.88,66.54 128.5,66.16 124.41,66.16 124.05,66.52 124.05,76.91 124.18,77.04 127.7,77.04
GND on BOTTOM (solid shape): 139.38,80.83 139.38,77.43 138.73,76.78 128.31,76.78 127.38,77.71 127.38,81.32 127.44,81.38 136.77,81.38 136.94,81.55 138.66,81.55
GND on BOTTOM (solid shape): 205.22,94.95 205.22,93.87 205.16,93.81 204.77,93.81 204.58,93.99 204.58,94.89 204.01,95.46 203.25,95.46 203.19,95.52 203.19,95.77 203.25,95.84 203.5,95.84 203.76,96.09 204.08,96.09
GND on BOTTOM (solid shape): 96.84,23.69 98.3,23.69 98.42,23.57 98.42,16.64 98.11,16.33 98.11,15.57 97.48,14.94 91.61,14.94 91.22,15.32 91.22,23.91 91.71,24.4 96.13,24.4
GND on BOTTOM (solid shape): 128.81,14.11 131.74,14.11 131.99,13.86 131.99,11.95 131.86,11.82 131.26,11.82 131.25,11.82 127.58,11.82 127.29,12.1 127.29,14.11 127.82,14.64 128.28,14.64
GND on BOTTOM (solid shape): 160.06,126.78 160.06,121.3 158.58,119.82 151.28,119.82 151.15,119.95 151.15,120.85 151.21,120.92 155.82,120.92 156.4,121.5 156.4,126.82 156.59,127.01 159.83,127.01
GND on BOTTOM (solid shape): 28.11,44.65 28.11,44.15 27.88,43.92 27.63,43.92 27.3,43.6 27.3,41.35 27.05,41.09 26.47,41.09 24.75,42.81 23.94,42.81 23.81,42.93 23.81,43.9 24.63,44.72 28.04,44.72
GND on BOTTOM (solid shape): 166.44,125.36 170.86,125.36 171.23,124.98 171.23,121.93 170.85,121.55 165.01,121.55 164.65,121.91 164.65,123.39 163.96,124.09 162.98,124.09 162.73,124.35 162.73,125.46 162.88,125.61 166.18,125.61
GND on BOTTOM (solid shape): 203.53,90.78 203.84,90.78 203.88,90.82 204.33,90.82 205.22,89.93 205.22,88.85 204.33,87.96 203.25,87.96 203.19,88.03 203.19,88.28 203.25,88.34 204.01,88.34 204.58,88.92 204.58,89.93 204.14,90.38 203.25,90.38 203.19,90.44 203.19,90.76 203.25,90.82 203.5,90.82
GND on BOTTOM (solid shape): 17.49,21.83 17.49,21.22 17.04,20.77 17.04,19.1 16.76,18.82 14.73,18.82 14.4,19.15 14.41,19.29 14.35,19.42 14.35,19.55 14.55,19.76 15.4,19.76 15.71,20.07 15.71,21.24 16.38,21.91 17.41,21.91
GND on BOTTOM (solid shape): 172.63,126.12 174.47,126.12 174.73,125.87 177.83,125.87 177.98,126.02 179.53,126.02 180.05,125.5 180.05,122.69 179.68,122.31 174.16,122.31 174,122.15 171.78,122.15 171.62,122.32 171.62,126.25 171.74,126.38 172.38,126.38
GND on BOTTOM (solid shape): 47.03,21.6 47.03,18.17 46.77,17.92 45.12,17.92 45,17.79 45,16.62 44.77,16.4 40.88,16.4 40.68,16.6 40.68,19.34 40.78,19.44 41.82,19.44 41.97,19.6 41.97,20.18 41.87,20.28 40.81,20.28 40.68,20.41 40.68,21.35 41.31,21.98 46.65,21.98
GND on BOTTOM (solid shape): 244.57,68.05 245.53,68.05 245.63,67.95 245.63,65.7 245.35,65.41 241.03,65.41 240.93,65.51 240.93,66.4 241.99,67.16 242.75,68.21 244.42,68.21
GND on BOTTOM (solid shape): 204.08,93.68 204.08,93.62 204.3,93.39 204.3,93.38 204.37,93.28 204.48,93.21 204.49,93.2 205.08,92.61 205.08,92.6 205.13,92.48 205.22,92.39 205.22,91.39 205.09,91.27 204.84,91.27 204.71,91.39 204.71,92.28 204.08,92.92 203.38,92.92 203.25,93.04 203.25,93.23 203.31,93.3 203.44,93.3 203.63,93.49 203.63,93.68 203.76,93.81 203.95,93.81
GND on BOTTOM (solid shape): 189.78,126.91 189.78,125.82 189.82,125.77 190.89,125.77 191.15,126.04 191.15,126.87 191.23,126.96 191.33,126.96 191.38,126.91 191.38,125.8 191.22,125.65 191.22,123.67 191.2,123.65 188.05,123.65 187.84,123.44 187.84,121.84 187.1,121.09 186.27,121.09 186.02,121.34 183.45,121.34 182.9,121.9 182.9,123.19 183.01,123.3 186.5,123.3 186.73,123.53 186.73,125.46 187.04,125.77 189.47,125.77 189.55,125.85 189.55,126.89 189.62,126.97 189.72,126.97
GND on BOTTOM (solid shape): 136.11,129.39 136.11,126.93 133.06,123.88 131.02,123.88 130.4,124.28 129.66,124.23 128.78,124.23 128.61,124.4 128.61,124.42 128.12,125.69 126.75,125.75 125.61,125.75 125.41,125.94 125.41,126.12 125.87,126.58 125.87,126.68 125.88,126.69 126.38,127.54 126.55,128.5 126.55,128.75 126.77,129.28 127.3,129.5 136,129.5
GND on BOTTOM (solid shape): 10.31,103.74 10.31,102.93 10.46,102.78 12.5,102.78 12.94,102.33 12.94,101.58 11.47,100.11 10.02,100.11 9.71,99.8 9.71,99.74 9.65,99.74 8.25,98.97 8.93,97.52 8.94,97.52 9.09,97.37 9.71,97.37 9.71,95.43 9.35,95.07 7.82,95.07 7.19,95.07 7.19,96.42 7.12,96.48 0.95,96.48 0.95,101.1 8.84,101.1 10.08,100.82 9.8,102.06 9.8,103.84 10.21,103.84
GND on BOTTOM (solid shape): outline of 110 points within 135.07,112.48 140.68,115.79
GND on BOTTOM (solid shape): 276.55,10.9 279.3,13.65 282.05,10.9 282.05,9.5 280.95,9.5 280.6,9.65 280.45,10 280.45,10.9 279.3,12.05 278.15,10.9 278.15,9 277.86,8.29 277.15,8 276.55,8
GND on BOTTOM (solid shape): 9.71,88.02 9.71,87.52 9.09,86.9 8.19,86.9 7.79,86.5 4.39,86.5 3.49,85.61 3.49,83.79 4.26,83.02 10.11,83.02 10.33,83.25 10.6,83.41 11.64,83.41 12.14,83 12.38,82.38 12.43,82.33 14.4,82.33 14.79,81.94 14.79,81.33 14.34,80.88 12.41,80.88 12.38,80.85 12.38,71.36 14.68,69.05 14.68,62.7 14.4,62.42 12.81,62.42 12.38,61.99 12.38,51.65 12.75,51.28 14.14,51.28 14.59,50.83 14.59,48.27 14.38,48.06 6.11,48.06 5.93,47.89 0.95,47.89 0.95,49.41 10.41,49.41 11.25,48.92 11.87,49.66 11.87,63.76 11.25,64.5 10.41,64.01 0.95,64.01 0.95,67.91 10.41,67.91 11.25,67.42 11.87,68.16 11.87,82.26 11.25,83 10.41,82.51 0.95,82.51 0.95,87.01 7.17,87.01 7.17,88.32 7.2,88.35 9.37,88.35
GND on BOTTOM (solid shape): outline of 394 points within 232.09,115.27 257.05,129.5
GND on BOTTOM (solid shape): outline of 170 points within 0.25,0.25 290.85,28.07
GND on BOTTOM (solid shape): outline of 242 points within 0.95,40.35 290.85,129.5
GND on IN1 (solid shape): 76.37,23.57 76.37,18.77 76.67,18.46 81.77,18.46 82.19,18.04 82.19,11.32 81.84,10.97 78.04,10.97 77.77,11.24 77.77,14.48 75.86,16.4 72.68,16.4 72.56,16.52 72.56,20.47 72.68,20.59 73.89,20.59 74.21,20.91 74.21,23.11 74.89,23.78 76.16,23.78
GND on IN1 (solid shape): 11.49,103.13 12.51,103.13 12.94,102.7 12.94,101.1 9.87,98.03 9.87,95.54 9.38,95.05 7.44,95.05 7.2,95.3 7.2,96.41 7.16,96.45 0.95,96.45 0.95,101.1 8.84,101.1 10.08,100.82 9.8,102.06 9.8,104.24 9.84,104.27 10.35,104.27
GND on IN1 (solid shape): 9.64,88.1 9.64,87.43 9.1,86.9 8.18,86.9 7.78,86.5 4.53,86.5 3.41,85.39 3.41,84.01 4.4,83.02 10.11,83.02 11.31,83.51 12.31,82.69 12.56,82.43 14.34,82.43 14.67,82.1 14.67,81.24 14.34,80.91 12.61,80.91 12.38,80.68 12.38,71.36 14.67,69.07 14.67,62.9 14.18,62.42 12.91,62.42 12.38,61.88 12.38,51.67 12.81,51.24 14.01,51.24 14.57,50.68 14.57,50 14.11,49.54 14.11,48.73 13.7,48.32 10.55,48.32 10.12,47.89 0.95,47.89 0.95,49.41 10.41,49.41 11.25,48.92 11.87,49.66 11.87,63.76 11.25,64.5 10.41,64.01 0.95,64.01 0.95,67.91 10.41,67.91 11.25,67.42 11.87,68.16 11.87,82.26 11.25,83 10.41,82.51 0.95,82.51 0.95,87.01 7.17,87.01 7.19,87.03 7.19,88.32 9.41,88.32
GND on IN1 (solid shape): outline of 157 points within 0.25,0.25 290.85,29.09
GND on IN1 (solid shape): outline of 230 points within 0.95,40.35 290.85,129.5
GND on IN2 (solid shape): 120.05,106.82 120.05,103.26 119.93,103.14 112.56,103.14 112.13,103.57 112.13,106.89 112.43,107.2 119.67,107.2
GND on IN2 (solid shape): 160.06,126.78 160.06,121.3 158.58,119.82 151.28,119.82 151.15,119.95 151.15,120.85 151.21,120.92 155.82,120.92 156.4,121.5 156.4,126.82 156.59,127.01 159.83,127.01
GND on IN2 (solid shape): 166.44,125.36 170.86,125.36 171.23,124.98 171.23,121.93 170.85,121.55 165.01,121.55 164.65,121.91 164.65,123.39 163.96,124.09 162.98,124.09 162.73,124.35 162.73,125.46 162.88,125.61 166.18,125.61
GND on IN2 (solid shape): 172.63,126.12 174.47,126.12 174.73,125.87 177.83,125.87 177.98,126.02 178.82,126.02 180.05,124.78 180.05,122.69 179.68,122.31 174.16,122.31 174,122.15 171.78,122.15 171.62,122.32 171.62,126.25 171.74,126.38 172.38,126.38
GND on IN2 (solid shape): 11.51,103.11 12.58,103.11 12.91,102.78 12.91,101.07 9.84,98 9.84,95.54 9.38,95.08 7.18,95.08 7.18,96.42 7.14,96.47 0.95,96.47 0.95,101.1 8.84,101.1 10.08,100.82 9.8,102.06 9.8,104.16 9.91,104.27 10.34,104.27
GND on IN2 (solid shape): 9.64,88.1 9.64,87.43 9.09,86.89 8.17,86.89 7.79,86.5 4.53,86.5 3.41,85.39 3.41,84.01 4.4,83.02 10.11,83.02 11.32,83.51 12.31,82.68 12.56,82.43 14.29,82.43 14.57,82.15 14.57,81.24 14.26,80.93 12.69,80.93 12.38,80.63 12.38,71.28 14.64,69.02 14.64,62.92 14.13,62.42 12.97,62.42 12.38,61.83 12.38,51.6 12.76,51.21 14.01,51.21 14.54,50.68 14.54,50.02 14.11,49.59 14.11,49.16 13.9,48.95 12.17,48.95 11.15,48.4 10.11,48.9 4.41,48.9 3.39,47.89 0.95,47.89 0.95,49.41 10.41,49.41 11.25,48.92 11.87,49.66 11.87,63.76 11.25,64.5 10.41,64.01 0.95,64.01 0.95,67.91 10.41,67.91 11.25,67.42 11.87,68.16 11.87,82.26 11.25,83 10.41,82.51 0.95,82.51 0.95,87.01 7.17,87.01 7.17,88.28 7.19,88.3 9.43,88.3
GND on IN2 (solid shape): outline of 157 points within 0.25,0.25 290.85,29.09
GND on IN2 (solid shape): outline of 230 points within 0.95,40.35 290.85,129.5
GND on IN3 (solid shape): 116.62,77.48 116.62,74.43 116.24,74.05 110.78,74.05 110.66,74.18 110.66,77.74 110.78,77.86 116.24,77.86
GND on IN3 (solid shape): 120.05,106.82 120.05,103.26 119.93,103.14 112.56,103.14 112.13,103.57 112.13,106.89 112.43,107.2 119.67,107.2
GND on IN3 (solid shape): 11.48,103.13 12.58,103.13 12.91,102.8 12.91,101.05 9.84,97.98 9.84,95.54 9.36,95.05 7.19,95.05 7.19,96.43 7.15,96.47 0.95,96.47 0.95,101.1 8.84,101.1 10.08,100.82 9.8,102.06 9.8,104.12 9.95,104.27 10.34,104.27
GND on IN3 (solid shape): 9.59,88.02 9.59,87.36 9.08,86.85 8.13,86.85 7.79,86.5 4.53,86.5 3.39,85.36 3.39,84.14 4.51,83.02 10.11,83.02 11.35,83.5 12.33,82.61 12.51,82.43 14.29,82.43 14.57,82.15 14.57,81.26 14.21,80.91 12.69,80.91 12.38,80.6 12.38,71.25 14.64,68.99 14.64,62.97 14.13,62.47 13.02,62.47 12.38,61.83 12.38,51.67 12.81,51.24 13.98,51.24 14.54,50.68 14.54,50 14.11,49.56 14.11,49.16 13.91,48.96 12.17,48.96 11.16,48.4 10.11,48.9 4.41,48.9 3.39,47.89 0.95,47.89 0.95,49.41 10.41,49.41 11.25,48.92 11.87,49.66 11.87,63.76 11.25,64.5 10.41,64.01 0.95,64.01 0.95,67.91 10.41,67.91 11.25,67.42 11.87,68.16 11.87,82.26 11.25,83 10.41,82.51 0.95,82.51 0.95,87.01 7.15,87.01 7.18,87.04 7.18,88.27 9.33,88.27
GND on IN3 (solid shape): outline of 157 points within 0.25,0.25 290.85,29.09
GND on IN3 (solid shape): outline of 230 points within 0.95,40.35 290.85,129.5
GND on IN4 (solid shape): 116.62,77.48 116.62,74.43 116.24,74.05 110.78,74.05 110.66,74.18 110.66,77.74 110.78,77.86 116.24,77.86
GND on IN4 (solid shape): 120.05,106.82 120.05,103.26 119.93,103.14 112.56,103.14 112.13,103.57 112.13,106.89 112.43,107.2 119.67,107.2
GND on IN4 (solid shape): 76.37,23.57 76.37,18.77 76.67,18.46 81.77,18.46 82.19,18.04 82.19,11.32 81.84,10.97 78.04,10.97 77.77,11.24 77.77,14.48 75.86,16.4 72.68,16.4 72.56,16.52 72.56,23.63 72.71,23.78 76.16,23.78
GND on IN4 (solid shape): 11.21,102.83 12.56,102.83 12.89,102.5 12.89,101.05 9.84,98 9.84,95.56 9.31,95.03 7.18,95.03 7.18,96.43 7.16,96.45 0.95,96.45 0.95,101.1 8.84,101.1 10.08,100.82 9.8,102.06 9.8,103.74 9.89,103.83 10.21,103.83
GND on IN4 (solid shape): 9.59,88.04 9.59,87.36 9.08,86.85 8.15,86.85 7.8,86.5 4.51,86.5 3.36,85.36 3.36,84.16 4.5,83.02 10.11,83.02 11.34,83.5 12.33,82.63 12.5,82.46 14.24,82.46 14.54,82.15 14.54,81.24 14.21,80.91 12.69,80.91 12.38,80.6 12.38,71.2 14.64,68.94 14.64,63.05 14.06,62.47 12.99,62.47 12.38,61.86 12.38,51.67 12.81,51.24 14.01,51.24 14.54,50.71 14.54,50 14.08,49.54 14.08,49.18 13.86,48.96 12.17,48.96 11.16,48.4 10.11,48.9 4.46,48.9 3.45,47.89 0.95,47.89 0.95,49.41 10.41,49.41 11.25,48.92 11.87,49.66 11.87,63.76 11.25,64.5 10.41,64.01 0.95,64.01 0.95,67.91 10.41,67.91 11.25,67.42 11.87,68.16 11.87,82.26 11.25,83 10.41,82.51 0.95,82.51 0.95,87.01 7.17,87.01 7.21,87.05 7.21,88.3 9.33,88.3
GND on IN4 (solid shape): outline of 157 points within 0.25,0.25 290.85,29.09
GND on IN4 (solid shape): outline of 230 points within 0.95,40.35 290.85,129.5
GND on GND1: outline of 255 points within 0.26,0.26 290.84,129.49 ; 1 cut-out
GND on VCC: 183.3,26.93 170.35,39.89 161.07,39.89 153.91,46.92 153.83,47 153.73,47 137.49,47 137.22,47.26 137.22,89.18 137.96,89.92 146.51,89.92 146.75,89.69 146.75,81.82 147.4,81.16 176.7,81.16 177.35,81.82 177.35,85.46 175.19,87.62 175.19,92.74 175.94,93.48 182.96,93.48 195.9,80.55 195.9,74.07 210.52,59.44 237.15,59.44 246.7,49.9 246.7,34.07 247.2,33.56 247.2,28.31 245.83,26.93
GND on VCC: 224.16,74.21 222.82,75.55 222.82,97.27 219.88,100.21 203.75,100.21 200.47,103.49 200.47,107.6 200.47,107.6 200.47,107.7 200.47,107.81 200.47,107.81 200.39,107.88 200.32,107.96 193.53,114.61 191.58,116.57 191.58,128.48 240.53,128.48 241.64,125.83 244.3,124.73 245.8,124.73 248.46,125.83 249.57,128.48 254.03,128.48 254.03,128.25 254.55,127 255.8,126.48 256.03,126.48 256.03,122.67 252.33,122.67 248.56,118.9 252.33,115.13 254.53,115.13 254.53,104.73 256.03,104.73 256.03,74.69 236.53,74.69 236.05,74.21 ; 1 cut-out
GND on GND2: outline of 255 points within 0.26,0.26 290.84,129.49 ; 1 cut-out
GND on GND3: outline of 255 points within 0.26,0.26 290.84,129.49 ; 1 cut-out
GND_DSP on TOP (solid shape): 31.66,31.64 34.86,31.64 35.09,31.4 35.09,29.73 34.77,29.41 28.06,29.41 27.75,29.73 24.06,29.73 22.92,28.58 22.03,28.58 21.91,28.71 21.91,28.84 22.03,28.96 22.03,29.98 22.16,30.11 23.18,30.11 23.94,30.87 25.46,30.87 25.72,30.61 28,30.61 28.13,30.49 29.53,30.49 29.88,30.85 29.88,31.76 30.01,31.89 31.41,31.89
VCC on BOTTOM (solid shape): 78,31.19 78,30.27 78.34,29.93 78.34,29.79 78.26,29.7 77.33,29.7 76.78,30.25 73.6,30.25 73.32,29.97 73.32,29.13 73.2,29 71.58,29 71.47,29.11 71.47,30.19 71.67,30.38 71.67,31.1 72.07,31.5 77.68,31.5
VIN on TOP (solid shape): 65.91,32.67 65.91,29.07 65.61,28.77 63.85,28.77 63.55,29.07 63.55,32.62 63.9,32.97 65.61,32.97
VIN on BOTTOM (solid shape): 66.02,31.41 66.02,30.72 65.97,30.67 64.5,30.67 64.17,30.34 64.17,29.47 63.89,29.19 63.21,29.19 62.71,28.69 57.82,28.69 57.73,28.77 57.73,29.76 58.38,30.41 58.38,31.43 58.97,32.02 65.42,32.02
VIN on BOTTOM (solid shape): 27.93,87.82 32.68,87.82 32.81,87.69 32.81,85.74 32.55,85.48 27.91,85.48 27.82,85.4 27.82,84.69 27.75,84.62 26.58,84.62 26.57,84.63 26.21,84.63 26.15,84.69 26.15,87.99 26.22,88.07 27.68,88.07
VIN on IN1 (solid shape): outline of 6673 points within 16.14,27.47 62.6,87.87
+CLK_PLLVDD on TOP (solid shape): 211.01,85.73 210.12,84.84 210.12,83.45 210.06,83.38 209.55,83.38 209.48,83.45 209.48,86.24 211.01,86.24
+CLK_PLLVDD on TOP (solid shape): 210.62,80.34 210.62,79.72 210.18,79.27 210.18,76.78 210.06,76.65 209.04,76.65 208.98,76.72 208.98,80.4 209.04,80.46 210.5,80.46
+CLK_PLLVDD on BOTTOM (solid shape): 210.72,85.65 210.72,84.22 210.59,84.09 210.59,83.76 211.12,83.23 211.12,82.7 211.04,82.62 210.76,82.62 210.53,82.39 210.18,82.39 210.07,82.5 210.07,82.81 210.11,82.81 210.34,83.12 210.07,83.39 209.64,83.82 209.64,84.75 209.42,84.97 209.42,85.59 209.64,85.81 210.56,85.81
+EDPVDD on TOP (solid shape): 83.75,40.99 83.75,39.14 83.65,39.04 81.91,39.04 81.49,39.46 81.49,41.07 81.67,41.25 83.5,41.25
+EDPVDD on BOTTOM (solid shape): 83.78,39.72 83.78,39.05 83.6,38.87 81.57,38.87 81.26,39.19 81.26,39.76 81.38,39.89 83.6,39.89
+EDPVDD on BOTTOM (solid shape): 59.82,42.38 60.21,42.38 61.02,41.56 62.5,41.56 63.05,41 63.05,39.92 62.76,39.63 60.55,39.63 58.37,41.82 58.37,42.15 58.72,42.5 59.69,42.5
+EDPVDD on IN4 (solid shape): 59.83,42.38 60.18,42.38 60.81,41.75 62.02,41.75 62.18,41.71 62.61,41.29 83.37,41.29 84.23,40.43 84.23,39.92 83.79,39.48 83.79,38.96 83.47,38.64 74.92,38.64 74.19,39.36 74.13,39.45 74.04,39.51 73.97,39.58 71.66,39.58 71.21,39.12 67.9,39.12 67.89,39.13 67.73,39.17 67.56,39.13 67.55,39.12 67.32,39.12 67.31,39.13 67.14,39.17 66.98,39.13 66.97,39.12 65.67,39.12 65.39,38.84 59.97,38.84 58.32,40.49 58.32,42.25 58.56,42.49 59.72,42.49
+FBA_DLL_AVDD on TOP (solid shape): 231.83,110.78 231.83,110.23 232,110.06 232.26,110.06 232.51,109.8 232.51,107.07 232.39,106.95 230.67,106.95 230.61,107.01 230.61,107.52 231.31,107.52 231.56,107.77 231.56,108.66 231.43,108.79 230.8,108.79 230.26,109.32 230.26,110.99 230.3,111.03 231.58,111.03
+FBA_DLL_AVDD on IN3 (solid shape): outline of 369 points within 221.96,99 226.4,105.45
+FBA_PLL_AVDD on TOP (solid shape): 229.91,109.99 229.91,109.36 229.85,109.3 228.38,109.3 226.93,110.74 226.93,111.64 227.19,111.89 228.01,111.89
+FBA_PLL_AVDD on IN4 (solid shape): outline of 2078 points within 216.66,90.63 231.1,111.77
+FBA_VREFD_H on TOP (solid shape): 210.08,126.31 210.08,122.09 209.87,121.87 209.1,121.87 208.74,122.23 208.74,125.64 209.51,126.41 209.98,126.41
+GPU_CORE on TOP (solid shape): 183.53,118.63 183.53,111.39 182.71,110.57 157.52,110.57 156.98,111.11 156.98,114.06 156.99,114.07 157.23,115.04 157.27,116.04 157.27,116.07 158,116.8 168.31,116.8 168.77,117.26 168.88,117.28 168.95,117.19 168.95,116.39 169.14,116.2 169.14,116.2 169.17,116.17 170.99,116.17 171.02,116.2 171.04,116.2 171.04,116.22 171.16,116.34 171.16,116.68 171.44,116.68 171.94,116.86 171.42,116.99 171.16,116.99 171.16,117.97 176.01,117.97 176.29,118.24 176.29,119.26 176.52,119.49 182.66,119.49
+GPU_CORE on TOP (solid shape): outline of 1250 points within 211.07,86.62 223.45,98.81
+GPU_CORE on BOTTOM (solid shape): 182.56,119.15 182.56,116.41 182.75,116.22 185.16,116.22 185.32,116.06 185.32,112.88 184.59,112.15 179.36,112.15 178.6,111.39 178.6,109.81 178.53,109.74 170.07,109.74 169.49,109.17 165.61,109.17 165.04,109.74 155.76,109.74 155.54,109.96 155.54,112.77 156.57,113.8 156.57,114.57 157.2,115.2 177.58,115.2 177.59,115.21 178.6,116.22 178.62,116.22 179.54,117.13 179.54,119.34 182.37,119.34
+GPU_CORE on IN2 (solid shape): outline of 15665 points within 156.21,84.08 223.18,120.94
+GPU_CORE on IN3 (solid shape): outline of 4439 points within 156.63,86.7 221.81,119.21
+GPU_CORE on IN4 (solid shape): outline of 6129 points within 156.63,85.66 221.55,119.44
+GPU_CORE on VCC: 197.02,75.95 196.4,76.57 196.4,80.76 183.17,93.99 180.81,93.99 180.27,94.52 180.27,107.43 176.06,111.64 157.14,111.64 156.78,112 156.78,116.23 160.85,120.3 179.54,120.3 183.28,124.04 190.53,124.04 191.07,123.5 191.07,116.36 193.25,114.18 199.96,107.6 199.96,103.28 203.54,99.7 219.67,99.7 222.31,97.06 222.31,76.62 221.65,75.95
+INV_PWR_SRC on TOP (solid shape): 74.69,39.49 80.26,39.49 80.94,38.81 86.29,38.81 86.42,38.68 86.42,37.41 86.19,37.18 84.35,37.18 84.21,37.04 80.22,37.04 80.2,37.02 73.73,37.02 73.7,37.05 73.66,37.09 73.66,37.3 73.51,37.97 73.36,37.3 73.36,37.09 73.32,37.05 73.28,37.02 72.91,37.02 72.51,37.42 72.51,39.05 72.43,39.13 72.43,39.38 72.55,39.5 74.67,39.5
+INV_PWR_SRC on BOTTOM (solid shape): 74.23,41.35 74.23,39 74.04,38.81 72.75,38.81 72.49,39.06 72.49,39.07 72.37,39.19 72.37,41.29 72.43,41.36 72.49,41.36 72.52,41.38 74.19,41.38
+PCH_USB_DCPSUS3 on IN2 (solid shape): outline of 426 points within 258.04,35.06 261.91,41.54
+PCH_VCCCLK on TOP (solid shape): outline of 85 points within 263.58,33.04 267.58,41.35
+PCH_VCCCLK on IN2 (solid shape): 266.03,35.85 266.03,35.03 266.41,34.65 266.94,34.65 267.07,34.53 267.07,33.94 266.91,33.79 266.23,33.79 265.54,34.48 264.5,34.48 264.37,34.6 264.37,36.23 264.63,36.48 265.39,36.48
+PCH_VCCCLK3_3 on TOP (solid shape): 272.09,33.61 272.09,32.15 272.03,32.08 271.96,32.08 271.95,32.09 271.86,32.1 271.76,32.09 271.76,32.08 271.46,32.08 271.34,32.2 270.37,32.2 270.25,32.08 269.61,32.08 269.49,32.2 269.49,33.22 269.75,33.47 270.31,33.47 270.57,33.73 271.96,33.73
+PCH_VCCCLK3_3 on IN2 (solid shape): 271.54,33.38 271.54,32.72 271.31,32.49 269.91,32.49 269.53,32.88 269.53,33.41 269.73,33.61 271.31,33.61
+PCH_VCCDSW on TOP (solid shape): 270.19,27.04 270.42,26.84 270.72,26.91 270.79,26.94 270.86,26.92 271.15,26.85 271.38,27.04 271.39,27.07 272.78,27.07 273.23,26.63 273.23,26.15 272.55,26.15 272.47,26.18 272.45,26.26 272.27,26.58 271.9,26.54 271.89,26.53 271.78,26.53 271.76,26.54 271.53,26.62 271.31,26.53 271.1,26.53 271.09,26.53 270.94,26.57 270.79,26.53 270.78,26.53 269.8,26.53 269.53,26.65 269.27,26.53 268.61,26.53 268.56,26.53 268.45,26.53 268.31,26.66 268.31,26.92 268.46,27.07 270.18,27.07
+PCH_VPROC on TOP (solid shape): 261.49,21.17 261.49,20.2 261.3,20.01 258.95,20.01 258.86,20.1 258.86,21.24 259.07,21.45 261.21,21.45
+PLLVDD on TOP (solid shape): 214.12,84.65 214.12,80.62 213.9,80.4 212.86,80.4 212.72,80.53 212.72,84.46 212.34,84.84 211.39,84.84 211.33,84.91 211.33,85.35 211.39,85.42 213.36,85.42
+V_DDR_REFB_R on TOP (solid shape): outline of 185 points within 176.54,81.93 179.67,83.1
+VCHGR on TOP (solid shape): 106.92,15.43 106.92,13.32 106.67,13.07 99.18,13.07 98.73,12.62 98.47,12.62 98.47,12.37 98.06,11.95 98.06,11.29 97.88,11.11 93.58,11.11 93.44,11.26 93.44,12.81 96.76,12.81 96.76,13.58 93.44,13.58 93.44,14.88 93.53,14.97 96.94,14.97 96.95,14.98 97.61,14.98 98,15.38 100.24,15.38 100.45,15.58 106.76,15.58
+VCHGR on BOTTOM (solid shape): 98.61,32.58 98.61,30.68 98.36,30.42 96.9,30.42 96.2,29.73 96.2,25.22 96.07,25.09 91.69,25.09 91.44,25.34 91.44,28.27 91.57,28.39 93.28,28.39 93.79,28.9 93.79,32.33 94.3,32.84 98.36,32.84
+VCHGR on IN1 (solid shape): outline of 265 points within 93.34,13.98 109.54,29.6
+VDISPLAY_VCC on BOTTOM (solid shape): outline of 89 points within 10.19,109.5 15.62,115.1
+VGA_B+ on TOP (solid shape): 156.31,124.92 156.31,121.39 156.21,121.29 155.38,121.29 155.07,121.61 151.61,121.61 151.3,121.93 151.3,123.02 152.24,123.96 154.98,123.96 155.11,124.09 155.11,124.6 155.11,124.98 155.18,125.06 156.17,125.06
+VGA_B+ on TOP (solid shape): outline of 157 points within 161.84,125.74 178.84,128.35
+VGA_B+ on BOTTOM (solid shape): 176.82,128.03 176.82,126.5 176.7,126.38 172.89,126.38 172.5,126.76 171.74,126.76 171.74,128.03 172,128.28 176.57,128.28
+VGA_B+ on BOTTOM (solid shape): 168.57,128.03 168.57,126.12 168.12,125.67 166.5,125.67 166.4,125.77 162.19,125.77 161.84,126.12 161.84,127.77 162.22,128.16 168.44,128.16
+VGA_B+ on BOTTOM (solid shape): 154.09,127.52 154.09,124.22 154.72,123.58 155.99,123.58 156.25,123.33 156.25,121.7 155.72,121.17 151.16,121.17 151.09,121.25 151.09,123.47 151.6,123.98 151.6,124.92 152.13,124.92 152.13,125.62 151.6,125.62 151.6,126.12 152.13,126.12 152.13,126.82 151.6,126.82 151.6,127.49 151.81,127.7 153.91,127.7
+VGA_B+ on IN3 (solid shape): outline of 2318 points within 150.92,118.88 177.2,128.79
+VLDOIN_1.35V on TOP (solid shape): 129.22,18.68 129.22,18.05 128.97,17.79 127.82,17.79 127.76,17.73 126.15,17.73 126.11,17.77 126.11,17.89 126.16,17.94 127.34,17.94 127.63,18.23 127.63,18.36 127.63,18.36 127.63,18.58 127.76,18.71 129.2,18.71
+VSBP on TOP (solid shape): 67.73,34.88 67.73,34.11 67.44,33.82 66.48,33.82 65.94,34.36 65.94,35.22 66.18,35.47 67.14,35.47
+VSBP on TOP (solid shape): 30.38,22.61 30.38,21.69 30.03,21.34 27.98,21.34 27.8,21.52 27.8,22.41 28.12,22.73 30.26,22.73
+VSBP on TOP (solid shape): 218.87,61.93 218.87,61.64 218.35,61.12 215.85,61.12 215.76,61.21 215.76,61.69 215.89,61.82 217.17,61.82 217.44,62.09 218.72,62.09
+VSBP on TOP (solid shape): 13.5,26.09 14.03,26.09 14.2,25.92 14.2,24.27 14.07,24.14 12.68,24.14 12.42,23.89 12.42,22.34 12.39,22.31 10.81,22.31 10.71,22.42 10.71,24.86 12.09,24.86 12.09,24.81 12.1,24.76 12.11,24.71 12.14,24.66 12.17,24.61 12.2,24.57 12.24,24.54 12.29,24.51 12.34,24.5 12.39,24.48 12.44,24.48 12.5,24.48 12.55,24.5 12.6,24.51 12.65,24.54 12.69,24.57 12.72,24.61 12.75,24.66 12.78,24.71 12.79,24.76 12.8,24.81 12.8,24.86 12.79,24.92 12.78,24.97 12.75,25.01 12.72,25.06 12.69,25.1 12.65,25.13 12.6,25.16 12.55,25.18 12.5,25.19 12.44,25.19 12.39,25.19 12.34,25.18 12.29,25.16 12.24,25.13 12.2,25.1 12.17,25.06 12.14,25.01 12.11,24.97 12.1,24.92 12.09,24.86 10.71,24.86 10.71,25.54 11.09,25.92 12.74,25.92 12.91,26.09 13.35,26.09 13.35,26.11 13.5,26.11
+VSBP on TOP (solid shape): 118.86,24.28 118.86,19.98 119.74,19.11 119.74,18.49 119.71,18.42 119.64,18.39 119.31,18.03 119.64,17.68 119.71,17.65 119.74,17.58 119.74,16.95 119.7,16.87 119.62,16.85 119.21,16.5 119.62,16.14 119.7,16.12 119.74,16.04 119.74,15.61 119.81,15.53 119.81,13.12 119.69,13 116.08,13 115.72,13.35 115.02,13.35 114.91,13.46 114.91,14.27 115.28,14.63 117.78,14.63 118,14.85 118,15.38 118,15.39 118.02,15.5 118,15.61 118,15.62 118,16.02 118,16.02 118.02,16.14 118,16.25 118,16.26 118,17.95 117.74,18.21 117.74,18.22 117.66,18.39 117.49,18.47 117.47,18.47 117.08,18.86 117.08,24.45 117.34,24.71 118.43,24.71
+VSBP on BOTTOM (solid shape): 174.15,21.99 174.15,21.6 174.36,21.39 174.51,21.39 174.62,21.28 174.62,21 174.51,20.89 173.67,20.89 173.43,21.13 173.42,21.16 173.42,21.95 173.52,22.06 174.09,22.06
+VSBP on IN1 (solid shape): 69.61,35.8 69.61,34.27 69.38,34.04 67.3,34.04 66.66,34.68 66.66,35.32 67.39,36.05 69.35,36.05
+VSBP on IN1 (solid shape): 118.92,18.21 118.92,17.01 118.5,16.59 116.98,16.59 116.72,16.85 116.72,17.94 117.1,18.31 118.82,18.31
+VSBP on IN1 (solid shape): 14.86,25.44 14.86,24.88 14.26,24.28 13.97,24.28 12.93,25.32 12.93,25.72 13.38,26.17 14.14,26.17
+VSBP on IN1 (solid shape): 28.92,22.28 28.92,21.63 28.64,21.35 27.87,21.35 27.67,21.54 27.67,21.82 27.61,21.88 27.34,21.88 27.25,21.97 27.25,22.87 27.33,22.95 28.25,22.95
+VSBP on IN3 (solid shape): 118.58,24.67 118.58,23.33 118.26,23.01 117.5,23.01 117.12,23.39 117.12,24.63 117.33,24.85 118.4,24.85
+VSBP on IN3 (solid shape): 174.81,22.28 174.81,21.22 174.38,20.79 173.58,20.79 173.45,20.92 173.45,21.99 173.89,22.42 174.67,22.42
+VSBP on IN4 (solid shape): 218.96,62.01 218.96,61.2 218.81,61.04 217.71,61.04 217.54,61.22 217.54,61.93 217.71,62.11 218.86,62.11
+VSBP on IN4 (solid shape): 174.81,22.06 174.81,21.19 174.71,21.09 174.63,21.02 174.56,20.94 174.33,20.71 173.75,20.71 173.44,21.01 173.44,21.03 173.42,21.15 173.37,21.25 173.37,22.36 173.57,22.56 174.31,22.56
+VSBP_AMP_AVCC on TOP (solid shape): 14.51,32.82 14.51,32.04 14.11,31.63 13.8,31.63 13.27,31.1 13.27,30.61 13.07,30.41 12.36,30.41 12.18,30.59 12.18,31.45 12.28,31.55 12.74,31.55 13.68,32.49 13.68,32.93 13.78,33.03 14.31,33.03
+VSBP_AMP_AVCC on BOTTOM (solid shape): 16.9,33.1 16.9,31.58 16.8,31.48 15.15,31.48 14.9,31.73 14.18,31.73 14.06,31.86 14.06,32.85 14.46,33.25 14.52,33.28 16.72,33.28
+VSBP_AMP_AVCC on BOTTOM (solid shape): 9.69,29.11 9.69,27.64 9.84,27.49 10.06,27.49 10.07,27.49 10.17,27.47 10.26,27.49 10.27,27.49 10.32,27.49 10.48,27.34 10.48,27.08 10.4,27.01 9.41,27.01 9.23,27.19 9.23,29.07 9.36,29.2 9.6,29.2
+VSBP_AMP_AVCC on IN4 (solid shape): 11.64,27.59 11.64,27.16 11.39,26.91 9.38,26.91 9.28,27.01 9.28,27.62 9.43,27.77 11.47,27.77
+VSBP_AMP_AVCC on IN4 (solid shape): 14.77,32.9 14.77,31.28 14.62,31.12 13.65,31.12 13.47,31.3 13.47,32.82 13.7,33.05 14.62,33.05
