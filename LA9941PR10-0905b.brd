# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_DSP:
  vias: v2(34.38,31.43)
V1N: length 32.6
  IN1 w0.254: v1(119.44,85.91) 119.55,85.8 120.08,85.8 120.29,86.01 120.29,95.91 124.89,100.51 124.89,102.11 124.63,102.37 124.37,102.37 v1(124.24,102.24)
  BOTTOM w0.254: v1(119.44,85.91) 119.87,85.48 PL702.3 ; v1(124.24,102.24) v2(127.04,102.24) 127.56,102.24 129.54,104.22 129.54,105.56 PR745.1 128.97,106.74 PR721.1
V2N: length 21.1
  IN1 w0.254: v1(124.01,104.15) 123.91,104.15 123.38,103.62 123.38,100.01 119.9,96.53 119.06,96.53 v1(118.93,96.65)
  BOTTOM w0.102: v2(128.01,104.12) PR717.1
  BOTTOM w0.254: v1(118.93,96.65) 119.31,96.28 PL701.3 ; PR717.1 PR744.1 126.86,105.48 124.14,105.48 123.89,105.23 123.89,104.27 v1(124.01,104.15)
VCC:
  vias: v2(74.03,31.02)
VCC_PGOOD: length 3.3
  BOTTOM w0.203: PU700.3 124,119.04 122.2,120.84 PR719.2
VCCSENSE: length 35.5
  TOP w0.254: v1(130.88,117.58) v2(131.41,117.58) 131.9,117.58 131.93,117.62 137.05,117.62 138.84,115.83 145.83,115.83 146.56,115.1 146.56,111.41 145.23,110.08 RU96.2 144.97,108.64 144.97,107.73 146.75,105.96 146.75,104.37 147.49,103.63 v1(147.89,103.63)
  BOTTOM w0.254: PC734.2 129.92,119.36 PC718.2 129.86,119.42 PR733.2 ; PC734.2 PC736.1 ; PC734.2 129.96,117.58 v1(130.88,117.58) ; v1(147.89,103.63) 147.76,103.49 147.74,103.49 U6.C50
VDD_1.35V: length 6.9
  TOP w0.203: PU400.11 124.33,15.39 124.13,15.18 123.76,15.18
  TOP w0.254: PR401.1 124.71,12.2 123.61,13.3 PC410.1
  TOP w0.508: PC410.1 PR402.2 122.34,14.4 v2(122.62,14.68) 123.12,15.18 123.76,15.18
VIN: length 43.3
  TOP w0.457: v1(59.6,28.92) 59.6,28.59 PC103.1
  TOP w0.508: 65.21,32.77 65.71,33.27 68.76,33.27 v8(70.12,34.63) 74.19,34.63 PD200.2 76.01,33.76 76.01,33.99 v1(76.86,34.84) ; v1(52.11,38.93) 57.33,38.93 v8(61.73,34.53) 63.73,32.52 64.17,32.52
  BOTTOM w0.508: PR214.1 84.06,34.86 83.21,35.72 78.38,35.72 78.18,35.52 77.2,35.52 76.86,35.17 v1(76.86,34.84) ; v1(48.14,38.27) 47.42,37.55 PR291.1
  vias: v1(28.23,87.58) v1(28.23,86.98) v1(28.82,87.58) v1(28.82,86.98) v1(29.45,87.58) v1(29.45,86.98) v1(30.04,87.58) v1(30.04,86.98) v1(30.67,87.58) v1(30.67,86.98) v1(31.28,87.58) v1(31.28,86.98) v1(31.92,87.58) v1(31.92,86.98) v1(58.71,29.45) v1(58.99,28.92) v1(59.32,29.45) v1(59.91,29.45) v1(60.19,28.92) v1(60.52,29.45) v1(60.8,28.92) v1(61.1,29.45) v1(61.43,28.89) v1(61.71,29.45) v1(62.04,28.89) v1(63.84,31.63) v1(64.45,31.63) v8(63.84,29.98)
VSSSENSE: length 36.6
  TOP w0.254: v1(147.1,102.9) 147.1,103.48 146.37,104.21 146.37,105.8 144.59,107.58 144.59,108.68 RU99.1 144.37,109.06 144.85,109.54 144.85,110.24 146.18,111.56 146.18,114.94 145.67,115.45 138.68,115.45 136.89,117.24 132.09,117.24 131.19,116.34 v1(130.88,116.34) ; PC737.2 127.61,115.96 v1(127.67,116.02)
  BOTTOM w0.203: v1(127.67,116.02) 127.67,116.02 PU700.13
  BOTTOM w0.254: U6.D50 147.45,102.54 v1(147.1,102.9) ; v1(130.88,116.34) 130.73,116.19 129.49,116.19 PC736.2 128.28,116.02 v1(127.67,116.02)
+CLK_PLLVDD: length 6.9
  TOP w0.102: v2(208.63,86.85) 208.93,86.85 CV569.1
  IN3 w0.508: v1(209.74,85.35) 210.37,84.72 v1(210.37,80.21)
+EC_VCCA: length 5.3
  TOP w0.089: UE1.B11 162.03,19.91 161.58,19.91 161.28,20.21 161.24,20.21 161.16,20.29
  TOP w0.508: 161.16,20.29 v2(160.23,21.22) 159.71,21.74 CE10.1 158.57,22.42 LE1.2
+EDPVDD: length 172.5
  TOP w0.102: v8(81.14,41.13) 81.8,40.47 CV3501.1
  TOP w0.508: RV333.1 223.38,21.23 223.82,20.79 223.82,19.65 223.4,19.24 RV416.2 222.63,19.08 v1(222.63,18.51) ; RV334.1 216.88,18.56 216.44,18.13 v1(216.44,18.12)
  IN1 w0.508: v1(222.63,18.51) 216.84,18.51 v1(216.44,18.12) 216.44,17.53 214.77,15.86 211.45,15.86 209.79,14.19 v1(209.79,12.99)
  IN2 w0.508: v4(132.5,23.88) 132.8,23.58 143.87,23.58 v1(144.6,22.85) ; v4(97.72,38.34) 104.65,31.41 v4(106.08,31.41)
  IN3 w0.508: v4(106.08,31.41) 105.39,30.71 105.39,28.31 106.99,26.71 119.55,26.71 122.16,24.1 126.12,24.1 127.74,25.72 130.67,25.72 132.5,23.89 v4(132.5,23.88) ; v1(209.79,12.99) 209.27,13.51 207.48,13.51 207.06,13.93 195.28,13.93 190.3,18.91 178.81,18.91 173.62,24.1 160.2,24.1 159.39,23.29 153.4,23.29 153.18,23.5 145.25,23.5 v1(144.6,22.85)
  IN4 w0.508: 83.95,40.08 93.89,40.08 96.26,37.7 97.09,37.7 v4(97.72,38.34)
  BOTTOM w0.254: v1(82.33,39.26) 82.33,39.31 82.05,39.6 JEDP1.21 ; 81.55,39.6 JEDP1.22 ; JEDP1.19 83.05,40.11 83.5,39.66 v1(83.5,39.26) ; v1(82.92,39.26) 82.92,39.45 82.55,39.82 JEDP1.20
  vias: v1(58.63,42.15) v1(59.24,42.15) v1(59.85,42.15)
+FB_VREF: length 4.4
  TOP w0.102: v2(222.71,98.93) 222.96,98.93 v1(223.26,98.62)
  TOP w0.508: v1(223.26,98.62) 223.39,98.75 RV342.2 223.89,99.51 RV343.1 CV638.1
  BOTTOM w0.254: UV1.H26 223.64,99 v1(223.26,98.62)
+FBA_DLL_AVDD: length 9.9
  TOP w0.102: CV3513.1 v8(231.98,106.11)
  IN3 w0.508: v1(231.28,109.56) 230.21,109.56 225.62,104.97
  BOTTOM w0.381: v1(222.27,99.25) 222.27,99.62 UV1.K27
+FBA_PLL_AVDD: length 2.9
  TOP w0.102: v8(225.11,90.71) 225.11,90.97 225,91.07 v1(224.6,91.07)
  TOP w0.508: CV636.1 223.84,90.99 224.52,90.99 v1(224.6,91.07)
  BOTTOM w0.254: UV1.H17 224.3,91.36 v1(224.6,91.07)
  BOTTOM w0.305: UV1.U27 216.72,99.9 v1(217.16,100.33)
  vias: v1(227.26,111.36) v1(227.26,110.75)
+FBA_VREFC_H: length 12.5
  TOP w0.508: RV372.1 211.59,126.08 RV373.2 211.59,127.38 210.93,128.04 v2(209.23,128.04) RV369.1 v3(204.66,128.04)
  GND1 w0.508: v3(204.66,128.04) 204.19,128.04 v5(204.18,128.05)
  IN1 w0.508: v5(204.18,128.05) 203.02,128.05 v4(202.26,127.29)
  IN4 w0.508: v6(202.26,126.5) v4(202.26,127.29)
  GND3 w0.508: v7(202.27,126.07) 202.27,126.49 v6(202.26,126.5)
+FBA_VREFC_L: length 29.8
  TOP w0.508: v1(220.12,126.65) 219.9,126.86 CV651.1 RV356.1 ; RV360.2 227.34,114.56 RV359.1 228.33,114 228.69,113.64 230.36,113.64 ; v1(230.97,113.65) 230.97,113.64 230.36,113.64 ; 230.36,113.64 v2(230.36,113.65)
  IN4 w0.508: v1(227.21,121.65) 228.84,120.02 228.84,115.99 230.97,113.85 v1(230.97,113.65)
  BOTTOM w0.254: UV5.J14 220.3,126.46 v1(220.12,126.65)
  BOTTOM w0.508: v1(227.21,121.65) 228.26,122.69 228.26,126.04 227.82,126.47 227.82,126.5 227.24,127.08 220.55,127.08 v1(220.12,126.65)
+FBA_VREFD_H: length 16.2
  IN3 w0.508: v1(209.07,123.27) 209.07,121.76 208.6,121.29 197.29,121.29 196.27,122.32 v1(196.27,122.47)
  BOTTOM w0.254: UV6.U10 v1(196.27,122.47) ; UV6.A10 v1(209.07,123.27)
  vias: v2(208.89,122.44)
+FBA_VREFD_L: length 25.2
  TOP w0.508: v1(227.09,123.25) v2(227.56,122.77) 228.51,121.82 RV355.1 CV650.1 CV776.1 227.77,119.23 227.77,117.74 228.23,117.28 RV358.2 228.23,115.55 RV357.1
  IN3 w0.508: v1(227.09,123.25) 227.09,122.83 225.93,121.67 223.14,121.67 222.12,120.66 220.98,120.66 220.34,121.29 214.87,121.29 214.3,121.86 v1(214.3,122.47)
  BOTTOM w0.254: UV5.A10 226.71,122.87 v1(227.09,123.25) ; UV5.U10 v1(214.3,122.47)
+FBB_VREFC_H: length 7.7
  TOP w0.508: RV399.2 254.82,100.32 RV398.1 254.81,101.79 CV726.1 RV395.1 254.33,102.71 v1(254.23,102.81)
  BOTTOM w0.254: UV10.J14 254.35,104.88 254.62,104.61 v2(254.62,103.92) 254.62,103.21 v1(254.23,102.81)
+FBB_VREFC_L: length 11.9
  TOP w0.508: RV382.1 RV386.2 ; RV386.2 v1(254.77,79.62) ; RV386.2 CV701.1 RV385.1
  BOTTOM w0.254: 254.4,86.36 253.92,86.85 UV9.J14
  BOTTOM w0.508: v1(254.77,79.62) v2(254.77,81.95) 254.77,86 254.4,86.36
+FBB_VREFD_H: length 28.1
  TOP w0.508: v1(249.39,110.88) v2(249.39,112.52) 249.39,113.56 249.78,113.95 CV725.1 CV789.1 RV394.1 ; RV397.2 253.54,113.13 RV396.1 253.05,113.04 252.87,113.22 v1(252.87,113.51)
  IN3 w0.508: v1(252.87,113.51) 252.87,113.44 252.08,112.66 250.12,112.66 249.39,111.92 v1(249.39,110.88) 249.11,110.88 248.22,109.99 248.22,99.25 v1(249.26,98.2)
  BOTTOM w0.254: UV10.A10 249.79,98.48 249.54,98.48 v1(249.26,98.2) ; v1(249.39,110.88) UV10.U10
+FBB_VREFD_L: length 35.7
  TOP w0.508: RV383.1 249.67,76.35 v1(248.69,77.33) v2(248.69,78.1) 248.69,78.81 249.29,79.41 v1(249.29,80.17) ; v1(249.39,92.85) 249.43,92.89 CV778.1 RV384.2
  IN4 w0.508: v1(248.69,77.33) 252.26,77.33 254.16,79.23 254.16,93.33 253.17,94.32 250.33,94.32 249.39,93.38 v1(249.39,92.85)
  BOTTOM w0.254: v1(249.39,92.85) UV9.U10 ; UV9.A10 249.79,80.37 249.58,80.17 v1(249.29,80.17)
  BOTTOM w0.508: CV700.1 RV381.1 248.28,77.73 v1(248.69,77.33)
+GPU_CORE: length 85.6
  TOP w0.508: RZ15.1 206.93,69.46 207.71,70.24 211.64,70.24 v1(212.66,71.25) ; PR825.1 172.66,110.94 172.65,110.94
  IN3 w0.508: v1(212.66,71.25) 212.66,72.01 211.64,73.03 211.64,86.62 v1(211.42,86.85)
  GND3 w0.254: v7(222.26,89.95) v4(222.26,89.57) ; v7(221.3,90.91) v4(221.3,91.42)
  BOTTOM w0.254: UV1.P19 219.8,93.53 v1(219.33,94) 218.93,94.4 UV1.R20 ; UV1.R17 218.77,91.4 218.45,91.72 v1(218.45,91.93) 218.45,92.08 218.77,92.4 UV1.R18 ; v7(221.3,90.91) 220.81,91.4 UV1.N17 ; UV1.R15 UV1.P14 219.8,88.31 v1(220.2,87.9) ; v7(222.26,89.95) 221.81,90.4 UV1.M16 ; UV1.M21 221.82,95.4 222.25,94.97 222.25,93.85 UV1.M19 ; UV1.N15 v1(220.33,89.87) ; v1(219.31,89.9) 219.8,90.38 UV1.P16 ; UV1.M14 221.8,88.57 v1(222.11,88.88)
  BOTTOM w0.305: UV1.N20 220.8,94.59 221.61,95.4 UV1.M21 ; UV1.Y13 213.8,87.27 v1(213.4,86.87) 212.93,86.4 UV1.AA12 ; v1(211.42,92.91) 210.93,93.4 UV1.AC19 ; v1(211.42,92.91) 211.42,92.91 211.41,92.91 v1(211.42,92.91) ; v1(211.42,92.91) 211.8,92.53 UV1.AB18 ; UV1.Y18 v1(213.27,92.93) UV1.AA19 ; UV1.R20 218.8,94.59 219.61,95.4 UV1.P21 ; UV1.M12 221.67,86.4 v1(221.2,86.87) 220.8,87.27 UV1.N13 ; UV1.AB22 211.8,96.51 v1(211.46,96.85) 210.91,97.4 UV1.AC23 ; UV1.P12 219.33,86.87 v1(219.2,86.87) 218.8,87.27 UV1.R13 ; UV1.T23 217.33,96.93 v1(217.14,96.93) 216.8,96.59 UV1.U22 ; UV1.T16 217.8,90.46 v1(217.26,91) 216.86,91.4 UV1.U17 ; UV1.V18 v1(215.27,92.93) UV1.W19 ; UV1.Y15 213.8,89.27 v1(213.4,88.87) 212.93,88.4 UV1.AA14 ; UV1.AB13 211.8,87.23 v1(211.42,86.85) 210.97,86.4 UV1.AC12 ; UV1.W23 214.86,97.4 v1(215.34,96.93) 215.8,96.46 UV1.V22 ; UV1.N22 220.8,96.53 v1(221.13,96.86) 221.67,97.4 UV1.M23 ; UV1.W21 214.99,95.4 v1(215.4,94.99) 215.8,94.59 UV1.V20 ; UV1.W16 214.88,90.4 v1(215.45,90.97) 215.8,91.32 UV1.V17 ; UV1.T12 217.73,86.4 v1(217.25,86.89) 216.8,87.33 UV1.U13 ; UV1.W14 214.93,88.4 v1(215.4,88.87) 215.8,89.27 UV1.V15 ; UV1.U20 216.8,94.59 v1(217.2,94.99) 217.61,95.4 UV1.T21 ; UV1.U18 216.8,92.43 217.21,92.84 v1(217.21,92.89) 217.72,93.4 UV1.T19 ; UV1.AC16 211.28,90.88 v1(211.54,90.88) 211.8,91.15 UV1.AB17 ; UV1.T14 217.67,88.4 v1(217.2,88.87) 216.8,89.27 UV1.U15 ; UV1.P19 219.75,93.4 218.8,92.45 UV1.R18 ; UV1.Y22 213.8,96.44 v1(213.32,96.92) 212.84,97.4 UV1.AA23 ; UV1.R17 UV1.P16 ; v1(220.14,91.88) 220.22,91.88 220.75,92.4 UV1.N18 UV1.M19 ; UV1.Y20 213.8,94.53 v1(213.4,94.93) 212.93,95.4 UV1.AA21 ; UV1.P23 219.61,97.4 v1(219.14,96.93) 218.8,96.59 UV1.R22 ; UV1.W12 214.83,86.4 v1(215.3,86.87) 215.8,87.37 UV1.V13 ; UV1.Y17 213.8,91.21 v1(213.46,90.87) 212.99,90.4 UV1.AA16 ; UV1.AC14 210.93,88.4 v1(211.4,88.87) 211.8,89.27 UV1.AB15 ; UV1.AC21 210.84,95.4 v1(211.4,94.84) 211.8,94.44 UV1.AB20
  vias: v1(196.98,104.85) v1(215.24,95.93) v1(215.23,93.81) v1(215.2,91.9) v1(215.29,89.82) v4(205.68,96.63) v4(205.7,94.38) v4(206.84,89.73) v4(213.88,95.99) v4(216.09,95.99) v4(219.94,95.99) v8(166.99,111.31) v9(157.58,114.82) v9(157.58,114.19) v9(157.58,113.55) v9(157.58,112.92) v9(157.58,112.28) v9(158.22,114.82) v9(158.22,114.19) v9(158.22,113.55) v9(158.22,112.92) v9(158.22,112.28) v9(158.92,114.82) v9(158.92,114.19) v9(158.94,113.52) v9(159.55,114.82) v9(159.55,114.19) v9(160.82,114.82) v9(160.82,114.19) v9(161.46,114.82) v9(161.46,114.19) v9(161.45,113.52) v9(162.09,114.82) v9(162.09,114.19) v9(162.09,113.55) v9(162.09,112.92) v9(162.09,112.28) v9(162.73,114.82) v9(162.73,114.19) v9(162.73,113.55) v9(162.73,112.92) v9(162.73,112.28) v9(163.36,114.82) v9(163.36,114.19) v9(163.36,113.55) v9(163.36,112.92) v9(163.36,112.28) v9(164,114.82) v9(164,114.19) v9(164,113.55) v9(164,112.92) v9(164,112.28) v9(164.63,114.82) v9(164.63,114.19) v9(164.63,113.55) v9(164.63,112.92) v9(164.63,112.28) v9(165.27,114.82) v9(165.27,114.19) v9(165.27,113.55) v9(165.27,112.92) v9(165.27,112.28) v9(167.04,114.82) v9(167.04,114.19) v9(167.68,114.82) v9(167.68,114.19) v9(168.24,113.52) v9(168.31,114.82) v9(168.31,114.19) v9(168.95,114.82) v9(168.95,114.19) v9(168.95,113.55) v9(169.58,114.82) v9(169.58,114.19) v9(169.71,113.42) v9(169.71,112.79) v9(169.71,112.15) v9(170.22,114.82) v9(170.22,114.19) v9(170.35,113.42) v9(170.35,112.79) v9(170.35,112.15) v9(170.85,114.82) v9(170.85,114.19) v9(170.98,113.42) v9(170.98,112.79) v9(170.98,112.15) v9(171.49,114.82) v9(171.49,114.19) v9(171.62,113.42) v9(171.62,112.79) v9(171.62,112.15) v9(172.12,114.82) v9(172.12,114.19) v9(172.25,113.42) v9(172.25,112.79) v9(172.25,112.15) v9(172.76,114.82) v9(172.76,114.19) v9(172.89,113.42) v9(172.89,112.79) v9(172.89,112.15) v9(173.39,114.82) v9(173.39,114.19) v9(173.57,113.5) v9(174.03,114.82) v9(174.03,114.19) v9(175.3,114.82) v9(175.3,114.19) v9(175.3,113.55) v9(175.93,114.82) v9(175.93,114.19) v9(176.08,113.48) v9(176.57,114.82) v9(176.57,114.19) v9(176.82,113.42) v9(176.82,112.79) v9(176.85,112.15) v9(176.82,111.46) v9(176.8,110.8) v9(177.2,114.82) v9(177.2,114.19) v9(177.46,113.42) v9(177.46,112.79) v9(177.48,112.15) v9(177.46,111.46) v9(177.46,110.82) v9(177.84,114.82) v9(177.84,114.19) v9(178.09,113.42) v9(178.09,112.79) v9(178.12,112.15) v9(178.12,111.45) v9(178.12,110.82) v9(178.47,114.82) v9(178.47,114.19) v9(178.73,115.84) v9(178.73,113.42) v9(178.73,112.79) v9(178.75,112.15) v9(179.26,116.47) v9(179.36,115.84) v9(179.39,112.53) v9(179.74,115.07) v9(180,115.84) v9(180.02,112.53) v9(180.38,115.07) v9(180.63,115.84) v9(180.66,112.53) v9(181.01,115.07) v9(181.27,115.84) v9(181.34,112.53) v9(181.65,115.07) v9(181.67,119.01) v9(181.67,118.37) v9(181.67,117.74) v9(181.67,117.1) v9(181.67,116.47) v9(181.9,115.84) v9(182.31,119.01) v9(182.31,118.37) v9(182.31,117.74) v9(182.31,117.1) v9(182.31,116.47) v9(182.28,115.07) v9(182.54,115.84)
+INV_PWR_SRC:
  vias: v1(72.71,39.2) v1(73.29,39.2) v1(73.87,39.2) v8(78.01,38.64)
+LCDVDD_R: length 23.8
  TOP w0.508: QV30.2 80.46,35.37 79.83,36 v2(65.89,36) 65.06,36 v1(64.73,35.67)
  BOTTOM w0.508: v1(64.73,35.67) 64.96,35.9 RV415.2 64.96,37.68 DV18.1 ; UV12.3 62.63,38.1 62.88,37.85 RV405.1 64.13,37.85 DV18.1 ; DV18.1 DV19.1
+MIC1_VREFO: length 16.2
  TOP w0.203: v1(19.82,43.84) v2(20.53,43.13) 20.7,42.96 20.7,42.7 21.01,42.39 U15.29
  TOP w0.508: RA19.1 17.88,35.59 19.01,35.59 v1(19.1,35.5)
  IN1 w0.508: v1(19.1,35.5) 19.2,35.61 20.52,35.61 21.76,36.84 21.76,39.32 21.12,39.96 21.12,42.54 v1(19.82,43.84)
  BOTTOM w0.508: v1(19.82,43.84) 19.8,43.86 RA20.1
+PCH_USB_DCPSUS3: length 9.6
  TOP w0.102: CH63.1 257.68,40.08 v2(257.4,39.81)
  TOP w0.457: v1(263.99,32.46) 263.94,32.51 CH62.1
  TOP w0.508: CH63.1 RH201.1
  GND1 w0.508: v4(258.38,41.1) v3(257.8,41.1)
  IN2 w0.508: 261.28,35.38 261.82,34.84 261.82,33.71 262.5,33.04 263.41,33.04 v1(263.99,32.46)
  BOTTOM w0.203: v1(263.99,32.46) 263.65,32.79 U7.AJ28
  BOTTOM w0.254: U7.AJ26 263.99,32.38 v1(263.99,32.46)
+PCH_VCC: length 4.9
  TOP w0.102: v3(261.32,41.27) 262.23,41.27 v2(262.43,41.47)
  TOP w0.508: v3(260.22,41.04) 260.19,41.01 LH100.2
  GND1 w0.254: v4(260.92,41.27) v3(261.32,41.27)
  GND1 w0.508: v3(260.22,41.04) 260.68,41.04 v4(260.92,41.27)
  GND3 w0.254: v7(260.97,40.86) 260.97,41.22 v4(260.92,41.27)
  BOTTOM w0.254: U7.AP45 260.97,40.64 v7(260.97,40.86)
+PCH_VCCASW: length 17.7
  TOP w0.102: v2(271.21,27.71) 271.04,27.87 v1(271.04,28.19)
  GND1 w0.508: v3(270.26,21.12) 270.46,21.12 270.7,21.36 v4(270.67,21.36)
  IN2 w0.508: v1(271.04,28.19) 269.34,28.19 v4(269.14,28.4) ; v4(270.67,21.36) 270.99,21.36 272.38,22.75 272.38,25.39 272.93,25.94 273.94,25.94 274.4,26.39 274.4,27.31 274.3,27.41 v4(274.3,27.39)
  IN3 w0.508: v1(271.04,28.19) 271.04,28.05 271.41,27.69 272.21,27.69 272.66,28.13 273.76,28.13 274.3,27.6 v4(274.3,27.39)
  GND3 w0.508: v4(269.14,28.4) 269.24,28.5 v7(269.24,29.2)
  BOTTOM w0.203: U7.R18 268.93,28.9 v7(269.24,29.2)
  BOTTOM w0.254: v1(271.04,28.19) 271.04,28.42 270.8,28.67 U7.L17
+PCH_VCCCFUSE: length 39.9
  TOP w0.102: v2(281.28,22.54) 281.17,22.43 v1(280.67,22.43)
  TOP w0.457: v1(269.88,29.19) 269.88,28.66 CH77.1
  IN1 w0.508: v1(280.67,22.43) 280.29,22.43 279.53,23.19 279.53,25.22 280.03,25.73 281.11,25.73 281.52,26.13 281.52,34.93 281.01,35.44 v1(279.97,35.44)
  IN2 w0.254: 274.22,29.81 274.12,29.71 270.35,29.71 269.88,29.24 v1(269.88,29.19) 269.88,29.04 270.24,28.68 271.43,28.68 271.48,28.73 273.68,28.73 274.28,29.33 274.28,29.34 274.22,29.4
  IN2 w0.508: v4(275.98,32.37) 275.98,32.37 274.22,30.61 274.22,29.4
  GND3 w0.508: v7(276.45,32.77) 276.26,32.77 275.98,32.49 v4(275.98,32.37)
  BOTTOM w0.254: U7.P20 269.59,29.57 269.88,29.28 v1(269.88,29.19) 269.88,29.13 269.59,28.85 U7.P18
  BOTTOM w0.508: R55.1 280.05,22 280.47,22.43 v1(280.67,22.43) ; v7(276.45,32.77) 276.45,32.93 276.54,33.01 276.54,33.08 276.93,33.46 277.22,33.46 277.76,34.01 277.76,34.52 278.38,35.14 R54.1 279.33,35.14 279.64,35.44 v1(279.97,35.44)
+PCH_VCCCLK: length 5.6
  BOTTOM w0.203: U7.AD36 265.36,36.56 265.02,36.21 ; U7.AG30 264.64,33.34 ; v1(266.62,34.1) 266.95,34.43 U7.Y32 ; v1(264.7,34.89) 264.31,34.5 U7.AG32
  BOTTOM w0.254: v1(265.01,36.21) 265.02,36.21 265.25,36.21 265.5,35.96 U7.AD35 ; v1(264.64,33.27) 264.64,33.34 U7.AE30 ; v1(265.01,35.62) 265.01,35.62 265.01,35.56 265.21,35.36 U7.AD34 ; U7.AA30 266.29,33.77 v1(266.62,34.1) 266.29,34.43 U7.AA32 ; v1(264.7,34.89) 264.84,34.75 264.84,34.7 264.97,34.58 U7.AE32
  vias: v2(265.4,38.67)
+PCH_VCCCLK3_3: length 17.6
  TOP w0.508: v1(268.6,34.89) 268.47,35.03 268.47,35.08 268.45,35.1 268.45,35.22 CH109.1
  IN2 w0.508: 269.61,33.21 269.12,33.21 268.6,33.73 v1(268.6,34.89) 267.65,35.84 267.65,36.79 266.71,37.73 266.71,41.36 266.59,41.48 266.59,43.24 267.07,43.73 v4(267.18,43.73)
  GND3 w0.508: v4(267.18,43.73) 267.18,44.16 v7(267.33,44.31)
  BOTTOM w0.203: v1(270.5,32.75) 270.2,33.04 U7.M29 ; v1(271.12,32.75) 271.12,32.9 U7.L29
  BOTTOM w0.254: v1(268.6,34.89) 268.6,34.8 268.29,34.49 U7.U32 268.15,34.36 267.74,34.36 U7.V32 ; v1(271.12,32.75) 271.12,32.55 270.82,32.25 U7.L26 ; v1(270.5,32.75) 270.5,32.55 U7.M26
  vias: v2(270.83,32.33)
+PCH_VCCDSW: length 0.5
  BOTTOM w0.254: v1(268.55,26.76) 268.27,27.04 U7.U14
  vias: v2(269.07,26.73)
+PCH_VCCDSW_R: length 2.5
  TOP w0.102: RH37.1 273.82,26.31 272.79,27.34 v2(272.59,27.34)
  TOP w0.508: RH37.1 CH56.1
+PCH_VPROC: length 12.4
  TOP w0.102: v2(258.7,21.79) 259.23,21.25 CH87.1
  TOP w0.457: CH88.1 263.32,27.05 v1(263.32,27.58)
  TOP w0.508: CH88.1 263.21,25.86 CH89.1
  GND1 w0.508: v3(261.3,21.17) 261.97,21.17 v5(262.05,21.09)
  IN1 w0.457: v5(262.05,21.09) 263.05,22.1 263.05,27.31 v1(263.32,27.58)
  BOTTOM w0.203: U7.AJ14 263.65,27.25 v1(263.32,27.58)
  BOTTOM w0.254: U7.AJ14 263.55,27.07 U7.AJ12
+PEX_PLLVDD: length 16.8
  TOP w0.102: LV3.2 199.94,104.31 199.45,104.8 v2(199.01,104.8)
  TOP w0.508: v1(201.36,102.69) 200.91,103.13 CV612.1 200.4,103.26 LV3.2 ; v1(208.73,98.57) 208.66,98.65 CV610.1 208.84,99.56 209.41,100.13 CV611.1
  IN1 w0.508: v1(201.36,102.69) 201.36,101.23 202.31,100.27 206.18,100.27 207.2,99.26 208.05,99.26 v1(208.73,98.57)
  BOTTOM w0.381: UV1.AG26 208.31,99 v1(208.73,98.57)
+PLLVDD: length 2.1
  BOTTOM w0.254: v1(212.47,85.1) 212.1,85.1 UV1.AD8
  vias: v2(213.47,84.36)
+RTCBATT: length 88.5
  TOP w0.102: v1(253.16,59.3) 252.7,59.3 252.25,58.85 v2(252.25,58.73)
  TOP w0.508: v1(253.16,59.3) RTCR1.2
  IN2 w0.508: v1(253.16,59.3) 256.3,59.3 257.94,57.67 257.94,56.4 260.09,54.24 261.3,54.24 262.74,52.8 262.74,51.02 265.77,47.99 265.77,46.69 266.91,45.55 268.56,45.55 272.04,42.07 277.47,42.07 278.52,41.01 278.52,31.47 278.87,31.13 278.87,27.03 278.94,26.96 278.94,21.94 280.31,20.57 280.31,19.68 277.77,17.14 277.77,13.51 277.23,12.96 276.38,12.96 275.32,11.9 272.56,11.9 271.59,10.93 269.73,10.93 269.09,10.29 261.59,10.29 260.82,11.06 259.52,11.06 259.17,10.71 v1(259.17,10.48)
  BOTTOM w0.203: v1(259.17,10.48) 259.3,10.35 JTB1.60
+RTCVCC: length 343.5
  TOP w0.508: v3(40.52,30.91) 41.46,31.85 41.46,34.77 44.24,37.55 v8(44.56,37.55) 46.54,37.55 47.95,38.96 51.17,38.96 51.75,39.54 57.8,39.54 63.65,33.7 v3(65.06,33.7) ; CH90.1 RH119.1 RH13.1 ; CH90.1 CH92.1 ; CH90.1 RH2.1 277.51,24.6 276.87,23.95 v1(276.79,23.95) 275.22,23.95 CH91.1 ; RTCD1.1 258,59.44 258.7,58.75 CH12.1 259.33,57.73 260.28,56.78 260.28,54.75 261.36,53.67 v1(261.36,52.78)
  GND1 w0.508: v5(39.3,31.1) 40.33,31.1 v3(40.52,30.91) ; v3(65.06,33.7) 65.64,34.29 v5(65.64,34.81)
  IN1 w0.508: v5(39.3,31.1) 33.95,31.1 29.86,27.01 v1(29.86,23.33) ; v5(65.64,34.81) 67.37,36.53 75.01,36.53 75.75,37.27 106.79,37.27 v1(107.07,37.55)
  IN2 w0.508: 260.79,49.98 v1(262.95,47.82) 262.95,48.05 263.33,48.43 263.99,48.43 265.16,47.26 265.16,46.44 266.66,44.95 268.31,44.95 271.79,41.46 276.93,41.46 277.91,40.47 277.91,30.62 278.26,30.28 278.26,26.78 278.33,26.7 278.33,24.87 277.73,24.28 277.12,24.28 v1(276.79,23.95) ; 260.79,49.98 260.79,52.4 261.17,52.78 v1(261.36,52.78) ; 260.79,49.98 260.68,49.87 250.83,49.87 249.67,51.04 240.07,51.04 232.69,43.66 113.18,43.66 v1(107.07,37.55)
  BOTTOM w0.254: v1(276.79,23.95) 276.54,23.95 276.36,24.14 U7.A6
  BOTTOM w0.508: RA43.1 18.62,34.74 23.37,34.74 24.95,33.15 24.95,27.82 24.32,27.19 22.67,27.19 22.03,26.55 22.03,23.38 22.77,22.64 29.48,22.64 29.86,23.02 v1(29.86,23.33) ; RH3.1 RH4.1 262.51,48.27 v1(262.95,47.82)
+V_DDR_REF: length 356.5
  TOP w0.203: PU400.4 124.73,20.11 124.9,20.28 PC411.1
  TOP w0.508: PC411.1 124.33,20.89 124.01,21.2 v1(124.01,24.71) ; v1(148.8,24.72) 148.8,24.69 149.53,23.96 CD16.1 153.47,23.96 153.99,24.48 v1(153.99,24.73) ; v1(223.76,24.71) CD38.1 223.34,26.4 v8(223.3,26.4) v1(223.3,27.57) ; CD24.1 182.73,33.35 v1(181.53,32.14) ; v1(108.27,32.01) 108.52,31.76 CD2.1
  IN1 w0.508: v1(108.27,32.01) 110.81,34.55 110.81,38.42 127.71,55.32 v1(128.78,55.32) ; v1(181.53,32.14) 173.62,32.14 172.15,30.67 172.15,27.55 171.13,26.54 163.31,26.54 162.11,25.34 162.11,24.01 161.54,23.44 156.78,23.44 156.27,23.95 154.62,23.95 153.99,24.58 v1(153.99,24.73)
  IN2 w0.508: v1(128.78,55.32) 129.29,54.81 141.25,54.81 146.48,60.04 188.79,60.04 v1(194.58,65.82) ; v1(223.3,27.57) 222.55,26.82 184.97,26.82 183.02,28.77 183.02,30.83 181.71,32.14 v1(181.53,32.14)
  IN3 w0.508: v1(124.01,24.71) 124.01,25.03 125.31,26.33 132.12,26.33 132.68,25.77 132.68,25.76 132.78,25.66 153.06,25.66 v1(153.99,24.73)
  IN4 w0.508: v1(194.58,65.82) 194.58,56.47 183.01,44.9 183.01,41.63 181.53,40.15 v1(181.53,32.14)
  BOTTOM w0.356: JDIMM1.1 108.9,33.47 108.27,32.84 v1(108.27,32.01) ; JDIMM1.126 v1(148.8,24.72) ; v1(223.76,24.71) 223.3,25.18 JDIMM2.126 ; JDIMM2.1 183.4,32.93 182.61,32.14 v1(181.53,32.14)
  BOTTOM w0.508: v1(128.78,55.32) 128.78,55.31 130.68,53.41 176.76,53.41 182.24,58.9 182.24,67.19 181.23,68.2 QD1.1 ; v1(194.58,65.82) 193.73,66.67 192.15,66.67 189.58,69.24 QD2.1
+V_DDR_REFA_R: length 19.6
  TOP w0.254: 176.4,77.35 176.4,81.01 v1(177.08,81.68)
  TOP w0.508: 176.4,77.35 176.85,76.91 179.26,76.91 179.54,76.62 v8(179.54,73.79) v1(179.54,70.59)
  BOTTOM w0.254: v1(177.08,81.68) 176.73,82.03 U6.AR6
  BOTTOM w0.508: v1(179.54,70.59) 181.39,70.59 183.32,68.66 QD1.3
+V_DDR_REFB_R: length 18.3
  TOP w0.508: v1(181.93,73.86) 181.94,73.86 182.84,74.76 v8(182.84,79.38) 182.84,81.39 181.86,82.37 179.13,82.37
  BOTTOM w0.254: v1(177.08,82.49) 176.73,82.84 U6.AN6
  BOTTOM w0.508: v1(181.93,73.86) 185.58,70.2 QD2.3
+V_SM_VREF: length 12.4
  TOP w0.508: v1(177.1,84.15) 177.1,85.12 177.81,85.83 180.66,85.83 v8(182.47,84.02) 184.83,81.67 RU84.1 RU83.2
  BOTTOM w0.254: U6.AM6 176.73,83.77 v1(177.1,84.15)
+VCHGR: length 0.8
  TOP w0.102: v9(95.95,28.71) v8(96.71,28.71)
  vias: v9(94.04,29.34) v9(94.04,28.71) v9(94.02,28.05) v9(94.02,27.39) v9(94.68,29.34) v9(94.68,28.71) v9(94.65,28.05) v9(94.65,27.39) v9(95,26.83) v9(95.31,29.34) v9(95.31,28.71) v9(95.31,28.07) v9(95.31,27.41) v9(95.63,26.83) v9(95.95,29.34) v9(95.95,28.07) v9(95.95,27.41) v9(100.85,15.31) v9(100.85,14.68) v9(101.48,15.31) v9(101.48,14.68) v9(102.12,15.31) v9(102.12,14.68) v9(102.75,15.31) v9(102.75,14.68) v9(103.39,15.31) v9(103.39,14.68) v9(104.02,15.31) v9(104.02,14.68) v9(104.71,15.3) v9(104.71,14.66) v9(105.34,15.3) v9(105.34,14.66) v9(105.98,15.3) v9(105.98,14.66)
+VDISPLAY_VCC:
  vias: v2(13.63,111.89)
+VGA_B+: length 32.9
  TOP w0.102: v1(136.52,118.12) v8(137.27,118.12)
  IN4 w0.508: v9(152.02,122.56) 147.57,118.12 v1(136.52,118.12)
  BOTTOM w0.508: PR815.1 136,117.6 v1(136.52,118.12)
  BOTTOM w1.016: 168.02,127.58 168.4,127.96 171.81,127.96 v9(172.12,127.65) ; 153.48,127.13 154.24,127.9 161.8,127.9 162.3,127.39
  vias: v9(151.7,123.13) v9(152.33,123.13) v9(152.69,123.69) v9(152.65,122.56) v9(153.45,123.69) v9(154.22,123.69) v9(154.81,123.32) v9(162.6,127.01) v9(163.49,127.01) v9(164.38,127.01) v9(165.27,127.01) v9(166.15,127.01) v9(167.04,127.01) v9(167.93,127.01) v9(172.76,127.65) v9(173.39,127.65) v9(174.03,127.65) v9(174.66,127.65) v9(175.3,127.65) v9(175.93,127.65) v9(176.57,127.65)
+VLDOIN_1.35V: length 1.4
  TOP w0.102: PJP401.2 128.72,17.34 v2(128.84,17.22)
+VSBP: length 252.6
  TOP w1.016: 29.78,22.17 30.71,22.17 31.62,23.08 33.23,23.08 39.65,29.51 39.65,34.19 45.34,39.87 50.86,39.87 51.39,40.41 58.16,40.41 63.81,34.76 66.1,34.76
  IN1 w1.016: 27.6,22.41 27.58,22.4 16.71,22.4 14.21,24.9 ; 117.13,16.92 113.5,16.92 111.86,18.56 111.86,20.58 96.22,36.23 75.93,36.23 75.01,35.31 68.13,35.31
  IN3 w1.016: 117.97,23.55 118.49,23.03 126.56,23.03 127.22,23.69 129.22,23.69 130.09,22.82 137.73,22.82 138.5,23.58 141.16,23.58 142.8,21.95 146.69,21.95 147.38,22.64 148.89,22.64 149.75,21.78 154.21,21.78 154.72,22.28 159.7,22.28 160.31,22.89 166.27,22.89 166.61,23.24 173.02,23.24 174.2,22.06
  IN4 w1.016: 174.26,22.21 175.41,23.37 177.31,23.37 178.67,24.72 181.93,24.72 183.65,26.45 183.65,33.98 185.1,35.42 185.1,39.01 187.77,41.68 205.93,41.68 218.27,54.02 218.27,61.17
  vias: v1(13.32,25.66) v1(13.9,25.84) v1(28.08,21.62) v1(28.69,21.95) v1(66.94,35.06) v1(67.32,34.55) v1(117.51,24.39) v1(118.04,17.78) v1(118.15,24.39) v1(118.68,17.78) v1(173.75,21.14) v1(174.38,21.14) v1(217.99,61.79) v1(218.63,61.79) v8(11.47,25.18)
+VSBP_AMP_AVCC: length 5.1
  IN4 w0.762: 14.11,31.25 14.11,30.39 11.12,27.4
  vias: v1(9.56,27.21) v1(10.22,27.21) v1(14.21,32.11) v1(14.28,32.7) v2(15.1,32.8)
+VSBP_AMP_PVCC:
  vias: v1(5.01,22.8) v1(5.01,22.17) v1(13.78,21.6) v1(14.36,21.63) v2(13.28,22.21)
A52_B52: length 0.7
  BOTTOM w0.305: U6.A52 U6.B52
A53_B53: length 0.7
  BOTTOM w0.305: U6.B53 U6.A53
A_DE0: length 2.2
  TOP w0.102: RI462.1 27.54,56.99 UI5.29
A_DE1: length 3.1
  TOP w0.102: UI5.28 27.14,56.6 RI463.1 26.35,56.55 v2(26.12,56.32)
A_EQ0: length 3.5
  TOP w0.102: RI460.1 30.83,57.12 30.47,57.49 v2(30.19,57.49) 29.39,57.49 28.74,58.14 UI5.32
A_EQ1: length 3.1
  TOP w0.102: RI461.1 29.88,56.79 29.59,57.08 28.86,57.08 v2(28.51,57.43) 28.34,57.6 UI5.31
AC_IN: length 108
  TOP w0.089: UE1.F5 164.28,16.73 v1(164.76,17.21)
  IN2 w0.076: v1(164.76,17.21) 166.18,17.21 166.37,17.41 166.37,17.83 166.03,18.17 166.03,18.3 165.52,18.8 165.03,18.8 164.21,19.63 164.21,21.53 164.02,21.72
  IN2 w0.102: 164.02,21.72 163.39,22.35 160.71,22.35 160.21,21.85 152.51,21.85 151.94,22.43 151.94,23.55 150.07,25.41 134.03,25.41 133.37,26.06 107.58,26.06 99.94,33.7 87.22,33.7 86.19,34.73 v4(83.41,34.73)
  GND3 w0.102: v4(83.41,34.73) 83.41,34.56 83.01,34.16 v7(83.01,34.12)
  BOTTOM w0.076: v1(164.76,17.21) 164.26,16.71 161.54,16.71 160.87,17.38 160.87,18.91 160.65,19.12
  BOTTOM w0.102: 160.65,19.12 160.33,19.44 158.47,19.44 157.96,18.93 v8(157.96,18.35) CE16.1 RE58.1
AC_PRESENT: length 131.2
  TOP w0.089: v1(273.64,23.82) 274.12,23.34 276.83,23.34 276.93,23.25 276.93,23.24 277.14,23.02 ; UE1.E5 163.78,16.73 v1(164.21,17.16)
  TOP w0.102: RH121.2 277.64,22.75 277.4,22.98 277.18,22.98 277.14,23.02
  IN1 w0.102: v4(232.16,20.35) 233.46,19.05 233.46,17.73 234.82,16.38 v4(234.82,15.97)
  IN2 w0.076: 168.78,16.01 168.53,16.01 167.5,17.04 165.28,17.04 165.11,16.87 164.5,16.87 v1(164.21,17.16)
  IN2 w0.089: 273.72,19.66 273.72,20.53 274.08,20.9 274.08,23.38 v1(273.64,23.82)
  IN2 w0.102: 273.72,19.66 273.72,17.61 272.13,16.03 271.59,16.03 270.85,15.29 260.37,15.29 260.11,15.04 252.32,15.04 252.18,14.9 243.94,14.9 243.01,15.83 241.57,15.83 241.39,15.65 237.34,15.65 236.61,16.38 235.22,16.38 v4(234.82,15.97) ; 168.78,16.01 170.18,16.01 171.43,17.26 181.88,17.26 182.92,18.3 192.83,18.3 193.24,18.72 198.33,18.72 200.39,20.79 231.73,20.79 v4(232.16,20.35)
  BOTTOM w0.076: T171.1 164.21,17.15 v1(164.21,17.16)
  BOTTOM w0.089: v1(273.64,23.82) 273.38,24.08 U7.E6
ACDET: length 5.8
  TOP w0.254: PR216.1 82.01,30.77 v1(82.42,30.36)
  BOTTOM w0.102: PR214.2 83.15,31.43 v2(82.71,31.86)
  BOTTOM w0.254: PU200.6 83.13,29.84 PC218.1 83.15,30.74 PR214.2 82.81,30.75 v1(82.42,30.36)
ACDRV: length 17.2
  IN1 w0.254: v1(80.45,32.09) 80.45,31.86 79.95,31.36 72.93,31.36 70.53,28.95 70.24,28.95 69.26,27.98 v1(69.26,27.88)
  BOTTOM w0.102: v2(69.2,28.43) 69.26,28.37 v1(69.26,27.88)
  BOTTOM w0.254: v1(80.45,32.09) 80.45,31.78 80.04,31.37 PU200.4 ; PR208.2 68.01,27.31 68.82,27.31 69.26,27.75 v1(69.26,27.88)
ACN: length 5
  BOTTOM w0.102: v2(77.25,32.17) PC211.1
  BOTTOM w0.254: PC211.1 PR210.2 78.45,32.91 78.45,32.65 78.19,32.4 PC210.2 78.6,31.86 78.6,31.29 78.54,31.23 PU200.1
ACOFF: length 108.3
  TOP w0.089: UE1.A9 161.77,18.65 161.24,18.65
  TOP w0.102: 161.24,18.65 161.17,18.71 v2(160.55,18.71) 160.04,18.71 v1(159.98,18.65)
  TOP w0.254: v1(63.38,28.68) 63.38,27.91 63.65,27.65 PQ202.2
  IN3 w0.102: v1(159.98,18.65) 159.01,19.62 157.85,19.62 157.03,18.79 149.88,18.79 149.24,19.44 148.42,19.44 148.11,19.75 146.64,19.75 146.32,20.07 142.01,20.07 141.16,20.92 129.28,20.92 129.07,21.12 122.41,21.12 121.79,20.51 117.44,20.51 117.02,20.92 106.34,20.92 101.72,25.55 94.1,25.55 90.72,28.93 88.73,28.93 87.44,30.22 83.42,30.22 82.62,31.02 77.3,31.02 77.06,30.78 75.04,30.78 73.87,29.61 64.31,29.61 v1(63.38,28.68)
ACOK: length 20.1
  IN1 w0.254: v1(81.09,32.09) 81.09,31.86 80.23,31 73.08,31 69.96,27.88 v1(69.85,27.88)
  BOTTOM w0.102: v2(71.44,27.21) 71.44,27.26 70.8,27.9 70.8,28 PR212.1
  BOTTOM w0.254: PR212.1 70.17,27.88 v1(69.85,27.88) ; PR220.2 PR217.2 PR223.1 81.09,33.07 v1(81.09,32.09) 81.09,31.66 80.54,31.11 PU200.5
ACP: length 4.1
  BOTTOM w0.254: PU200.2 79.04,31.22 78.96,31.31 78.96,32.12 PC210.1 ; PC210.1 79.29,32.27 79.85,32.83 PC209.2 ; PC210.1 79.11,33.13 PR209.2
AD_BID0: length 5.8
  TOP w0.102: UE1.A12 161.78,20.23 160.98,21.03 160.98,21.76 160.3,22.45 v2(160.3,22.51) 160.3,23.15 RE9.2 RE12.1 CE12.1
ADP_I: length 184.2
  TOP w0.089: 161.66,21.22 162.03,20.84 162.03,20.41 UE1.B12
  TOP w0.102: 161.66,21.22 161.54,21.33 v3(161.54,21.36) ; v1(159.31,13.1) 159.39,13.02 v2(159.39,12.57) 159.39,12.3 159.73,11.96 161.39,11.96 162.12,12.69 PR116.1
  TOP w0.254: v1(82.48,29.21) 82.25,28.97 PC219.2
  GND1 w0.076: v3(161.54,21.36) 161.54,21.41 161.44,21.51 161.34,21.51 v4(161.17,21.67)
  IN1 w0.102: v4(82.78,34.73) 81.98,33.93 81.98,29.71 v1(82.48,29.21)
  IN2 w0.076: v4(161.17,21.67) 161.07,21.57 160.65,21.57
  IN2 w0.102: v4(82.78,34.73) 83.18,34.33 86.31,34.33 87.14,33.5 99.86,33.5 107.5,25.86 133.29,25.86 133.94,25.2 149.99,25.2 151.73,23.46 151.73,22.35 152.51,21.57 160.65,21.57 ; v1(82.48,29.21) 82.65,29.04 84.11,29.04 84.8,29.73 93.19,29.73 93.67,30.21 98.5,30.21 107.96,20.75 116.45,20.75 117.06,20.13 123,20.13 123.4,20.53 127.05,20.53 127.45,20.13 146.58,20.13 147.07,19.64 147.7,19.64 149.56,17.77 153.44,17.77 154.27,16.95 154.27,15.8 156.05,14.02 157.28,14.02 157.83,13.46 158.95,13.46 v1(159.31,13.1)
  BOTTOM w0.254: PU200.7 82.35,29.34 v1(82.48,29.21)
ADPIN: length 8.4
  BOTTOM w0.102: ADP100.3 25.9,95.75 v1(26.25,96.1) ; ADP100.2 24.4,95.58 v1(23.94,96.05)
  vias: v8(22.52,95.84) v8(23.53,93.56) v8(25.21,95.33)
ALERT#: length 5.7
  TOP w0.254: PR701.2 121.03,119.83 v1(121.09,119.77)
  BOTTOM w0.102: PR705.2 120.38,120.66 v2(120.18,120.86)
  BOTTOM w0.203: v1(121.09,119.77) 121.19,119.77 121.79,119.17 121.79,118 122.18,117.62 PU700.32
  BOTTOM w0.254: PR705.2 121.09,119.77 v1(121.09,119.77)
AUD_MUTE: length 197.8
  TOP w0.089: v3(168.09,20.42) 167.83,20.16 UE1.N12
  TOP w0.102: v2(5.67,23.83) v1(4.42,23.83)
  GND1 w0.076: v4(168.56,20.93) 168.09,20.47 v3(168.09,20.42)
  IN3 w0.102: v1(4.42,23.83) 4.42,22.11 5.03,21.5 10.61,21.5 11.42,20.69 14.42,20.69 14.92,21.2 14.92,21.63 15.34,22.04 22.24,22.04 22.58,21.7 22.58,19.83 23.77,18.64 27.94,18.64 28.51,19.21 28.51,21 32.09,24.58 32.09,32.98 37.12,38.01 42.18,38.01 46.17,34.02 50.88,34.02 52.08,32.82 58.04,32.82 59.85,31.02 66.84,31.02 67.15,31.34 68.2,31.34 68.36,31.17 70.49,31.17 71.12,30.54 73.94,30.54 74.78,31.39 76.8,31.39 77.08,31.67 82.84,31.67 83.67,30.83 87.69,30.83 88.99,29.54 90.97,29.54 94.35,26.16 101.97,26.16 106.59,21.53 117.27,21.53 117.69,21.12 121.54,21.12 122.16,21.73 127.06,21.73 127.74,22.42 128.64,22.42 129.51,21.55 141.4,21.55 142.27,20.68 146.57,20.68 146.89,20.36 148.36,20.36 148.67,20.05 149.49,20.05 150.14,19.4 156.75,19.4 157.74,20.38 168.01,20.38 v4(168.56,20.93)
  BOTTOM w0.102: v1(4.42,23.83) 4.09,23.83 3.95,23.97 QA2.2
AUD_SPK_L+: length 24.5
  GND1 w0.508: v4(25.63,36.65) 25.53,36.55 v3(25.53,36.06)
  IN3 w0.508: v1(5.42,30.56) 5.83,30.56 6.39,31.12 14.08,31.12 15.33,32.37 15.33,32.98 18.46,36.11 25.1,36.11 v4(25.63,36.65)
  BOTTOM w0.508: RA45.1 5.57,30.41 v1(5.42,30.56)
AUD_SPK_L+_R: length 1.8
  BOTTOM w0.508: RA49.1 CA53.1 RA45.2
AUD_SPK_L-_R: length 1.9
  BOTTOM w0.102: RA46.2 8.72,32.19 v2(8.93,32.39)
  BOTTOM w0.508: RA46.2 CA58.1
AUD_SPK_R+: length 16
  GND1 w0.508: v4(26.52,36.65) 26.42,36.55 v3(26.42,36.06)
  IN3 w0.508: v4(26.52,36.65) 26.52,35.72 25.54,34.74 18.85,34.74 15.12,31.02 15.12,30.69 v1(15.12,30.69)
  BOTTOM w0.508: RA48.1 14.84,30.41 v1(15.12,30.69)
AUD_SPK_R+_R: length 3.5
  BOTTOM w0.102: RA48.2 15.56,31.33 15.73,31.15 v2(15.73,30.79)
  BOTTOM w0.508: RA48.2 CA59.1 RA52.1
AUD_SPK_R-_R: length 0.9
  BOTTOM w0.508: CA60.1 RA51.2
AUD_SPK_RC_L+_C: length 2
  TOP w0.203: CA25.1 25.53,37.67 25.15,38.05 U15.43
AUD_SPK_RC_R+_C: length 3.3
  TOP w0.102: CA24.1 27.24,36.97 v2(27.42,36.79)
  TOP w0.203: U15.44 25.56,38.81 25.56,38.19 25.96,37.79 25.96,37.43 CA24.1
B3_A3: length 5.6
  BOTTOM w0.089: U6.A3 179.6,104.64 180.88,105.93
  BOTTOM w0.102: v2(182.31,107.78) 182.31,107.35 180.88,105.93
  BOTTOM w0.305: U6.B3 U6.A3
B54_C54: length 0.8
  BOTTOM w0.305: U6.C54 144.27,103.28 144.27,103.84 U6.B54
B+: length 156.6
  TOP w0.508: PQ102.4 118.58,12.38 118.43,12.24 118.43,11.24 118.68,10.99 PR107.1 120.19,12.63 v1(120.2,12.64) 120.9,13.34 PC108.1
  IN1 w0.508: 130.47,22.06 130.46,22.06 130,22.06 129.14,21.2 125.95,21.2 124.75,20 124.75,18.89 123.91,18.05 123.91,14.66 122.34,13.09 120.65,13.09 v1(120.2,12.64)
  BOTTOM w3.048: 116.72,65.51 116.72,57.72 125.65,48.79 225.68,48.79 225.72,48.83 237.94,48.83 238.44,48.33
  vias: v3(131.31,21.86) v3(131.92,21.86) v5(131,21.86) v5(131.61,21.86) v8(102.88,38.62) v9(39.79,26.28) v9(39.92,27.57) v9(39.92,26.94) v9(40.42,26.3) v9(40.42,25.67) v9(40.55,27.57) v9(40.55,26.94) v9(41.19,27.57) v9(41.19,26.94) v9(43.09,27.42) v9(43.09,26.78) v9(43.73,27.57) v9(43.73,26.94) v9(44.21,26.28) v9(44.36,27.57) v9(44.36,26.94) v9(82.87,16.01) v9(82.87,15.12) v9(82.87,14.23) v9(82.87,13.34) v9(82.87,12.45) v9(82.87,11.56) v9(83.75,16.01) v9(83.75,15.12) v9(83.75,14.23) v9(83.75,13.34) v9(83.75,12.45) v9(83.75,11.56) v9(84.64,16.01) v9(84.64,15.12) v9(84.64,14.23) v9(84.64,13.34) v9(84.64,12.45) v9(84.64,11.56) v9(85.53,16.01) v9(85.53,15.12) v9(85.53,14.23) v9(85.53,13.34) v9(85.53,12.45) v9(85.53,11.56) v9(86.63,25.89) v9(86.63,25) v9(86.63,24.11) v9(87.51,25.89) v9(87.51,25) v9(87.51,24.11) v9(88.4,25.89) v9(88.4,25) v9(88.4,24.11) v9(112.51,69.2) v9(113.03,68.65) v9(113.07,113.68) v9(113.07,112.79) v9(113.52,69.2) v9(114.04,68.65) v9(114.08,113.68) v9(114.08,112.79) v9(114.55,69.22) v9(115.1,113.68) v9(115.1,112.79) v9(115.08,68.67) v9(115.61,69.23) v9(116.12,113.68) v9(116.12,112.79) v9(116.12,68.67) v9(116.62,69.23) v9(117.13,68.67) v9(117.64,69.23) v9(118.15,68.67) v9(146.57,126.63) v9(146.57,125.97) v9(147.23,126.61) v9(147.23,125.97) v9(147.56,125.41) v9(147.87,126.63) v9(147.87,126) v9(148.2,125.41) v9(148.5,126.63) v9(148.5,126) v9(149.14,126.63) v9(149.14,126) v9(183.83,127.77) v9(183.83,127.13) v9(183.83,126.5) v9(183.83,125.86) v9(183.83,125.23) v9(240.47,48.67) v9(240.93,48.19) v9(241.46,47.73) v9(241.97,47.28) v9(242.53,46.79) v9(243.01,46.31)
B++: length 4.1
  TOP w0.508: PR338.2 46.9,25.13 47.51,24.52
  vias: v2(38.97,24.35) v9(41.21,23.66) v9(42,23.63) v9(43.24,24.24) v9(43.24,23.58) v9(43.96,24.24) v9(43.96,23.56)
B_DE0: length 2.1
  TOP w0.102: RI467.1 27.54,66.64 UI5.15
B_DE1: length 2.4
  TOP w0.102: UI5.16 v2(27.14,65.76) 27.14,66.15 RI466.1
B_EQ0: length 2.5
  TOP w0.102: UI5.13 28.34,65.39 v2(28.69,65.75) 29.27,66.33 RI464.1
B_EQ1: length 2.3
  TOP w0.102: RI465.1 27.94,66.24 UI5.14
BAT1: length 27.6
  TOP w0.254: v1(4.13,25.92) 3.99,26.05 LED3.2 ; R23.2 22.67,18.11 v2(22.88,18.31) 23.49,18.93 v1(23.49,20.26)
  IN3 w0.254: v1(23.49,20.26) 23.01,20.75 23.01,22.04 21.93,23.12 6.92,23.12 v1(4.13,25.92)
BAT2: length 25.4
  TOP w0.254: v1(4.03,20.82) 3.75,21.09 2.26,21.09 LED7.1
  IN3 w0.254: v1(4.03,20.82) 4.26,21.04 10.23,21.04 11.04,20.23 14.52,20.23 14.74,20.01 18.02,20.01 19.73,18.3 23.5,18.3 v1(23.53,18.27)
  BOTTOM w0.102: v1(23.53,18.27) 23.53,19.26 v2(23.23,19.57)
  BOTTOM w0.254: v1(23.53,18.27) 23.71,18.27 23.91,18.07 R16.2
BAT3: length 19.9
  TOP w0.254: LED8.1 2.8,17.22 v1(3.81,18.23)
  IN3 w0.254: v1(17.08,17.28) 17.08,17.53 16.64,17.98 11.86,17.98 9.81,20.03 5.12,20.03 4.33,19.24 4.33,18.75 v1(3.81,18.23)
  BOTTOM w0.102: v2(16.37,15.5) 16.37,15.73 16.75,16.11 R19.2
  BOTTOM w0.254: v1(17.08,17.28) 17.08,17.23 16.75,16.9 R19.2
BAT4: length 27.4
  TOP w0.254: LED9.1 2.65,13.66 2.91,13.41 v1(3.81,13.41) ; R22.2 24.27,17.2 v1(24.01,16.95)
  IN3 w0.254: v1(3.81,13.41) 4.88,13.41 6.74,11.54 10.27,11.54 15.27,16.54 18.38,16.54 19.12,17.28 22.13,17.28 22.69,16.72 22.69,16.5 22.97,16.23 23.29,16.23 v1(24.01,16.95)
  BOTTOM w0.102: v1(3.81,13.41) 3.71,13.41 v2(3.39,13.72)
BAT5: length 25
  TOP w0.102: v1(16.38,17.36) 15.61,18.13 v2(15.61,18.14)
  TOP w0.254: v1(2.86,9.34) 2.86,9.84 2.65,10.04 LED6.1
  IN3 w0.254: v1(16.38,17.36) 14.98,17.36 9.74,12.11 6.91,12.11 4.43,14.59 3.4,14.59 2.86,14.04 v1(2.86,9.34)
  BOTTOM w0.254: v1(16.38,17.36) 16.38,17.37 16.75,17.74 R10.2
BATBTN#: length 226.4
  TOP w0.089: UE1.G4 165.03,16.41 165.41,16.41 165.53,16.29 165.53,15.97 165.64,15.86 165.64,15.45 165.53,15.35 165.53,14.48
  TOP w0.102: 165.53,14.48 165.62,14.4 165.62,13.93 v3(165.45,13.76) ; v8(4.91,30.92) 4.76,31.07 v1(4.76,32.14) ; v1(174.88,14.54) 174.88,13.68 DE8.1 175.15,13.15 RE47.2 ; SW2.4 SW2.3 1.91,33.82 2.2,33.54 2.2,32.93 v1(2.63,32.49)
  GND1 w0.076: v3(165.45,13.76) 165.45,13.6
  GND1 w0.102: 165.45,13.6 165.45,13.38 165.16,13.09 v4(165.15,13.09)
  IN2 w0.102: v4(65.68,31.57) 65.68,31.24 66.79,30.13 71.43,30.13 72.17,30.87 83.65,30.87 84.39,30.13 93.02,30.13 93.5,30.61 98.67,30.61 108.13,21.15 116.62,21.15 117.23,20.54 122.83,20.54 123.23,20.94 127.22,20.94 127.62,20.54 146.75,20.54 147.23,20.06 147.88,20.06 149.76,18.18 153.61,18.18 154.67,17.12 154.67,15.97 155.39,15.25 156.33,15.25 157.91,13.67 159.32,13.67 159.77,13.22 160.44,13.22 160.72,13.5 160.72,13.69 161,13.97 161.5,13.97 162.91,12.56 164.62,12.56 v4(165.15,13.09)
  IN3 w0.102: v4(65.68,31.57) 65.34,31.22 59.93,31.22 58.13,33.03 52.17,33.03 50.88,34.32 46.16,34.32 42.26,38.21 37.04,38.21 31.89,33.07 31.89,24.67 30.07,22.84 23.23,22.84 22.52,23.55 7.1,23.55 4.58,26.07 4.58,31.96 v1(4.76,32.14)
  IN4 w0.102: v1(174.88,14.54) 174.88,14.52 173.96,13.6 172.17,13.6 171.38,12.81 170.79,12.81 170.15,13.45 167.82,13.45 167.68,13.31 165.37,13.31 v4(165.15,13.09)
  BOTTOM w0.102: v1(4.76,32.14) 5.07,32.44 5.07,33.94 4.89,34.12 3.77,34.12 3.41,34.48 D8.2 3.16,35.26 2.58,34.68 2.58,32.55 v1(2.63,32.49)
BATDRV#: length 15.3
  BOTTOM w0.254: PU200.11 80.54,26.34 80.83,26.04 83.88,26.04 84.29,26.45 84.93,26.45 85.72,27.25 v2(87.39,27.25) 88.34,27.25 92.48,31.39 PR227.1
BATT+: length 0.6
  TOP w0.102: v1(99.07,28.35) v8(99.07,28.91)
BATT++: length 1.3
  GND1 w0.102: v3(109.54,15.83) 109.13,16.24 v4(109.13,16.26)
  GND3 w0.102: v7(109.13,16.95) v4(109.13,16.26)
  vias: v8(107.1,16.62) v8(107.81,14.92) v8(109.13,16.21)
BATT_LED#_LV1: length 165.4
  TOP w0.089: UE1.B10 162.03,18.91 161.21,18.91
  TOP w0.102: v1(17.11,15.76) 17.46,16.11 Q19.2 18.4,16.11 18.58,16.29 R32.2 ; 161.21,18.91 v3(161.06,19.06)
  GND1 w0.076: 160.65,19.25 160.87,19.25 v3(161.06,19.06)
  GND1 w0.102: 160.65,19.25 v4(160.59,19.25)
  IN3 w0.102: v4(160.59,19.25) 159.95,19.25 159.22,19.98 157.9,19.98 156.92,18.99 149.97,18.99 149.32,19.64 148.51,19.64 148.2,19.95 146.72,19.95 146.4,20.27 142.1,20.27 141.25,21.12 129.36,21.12 129.16,21.32 122.32,21.32 121.71,20.71 117.52,20.71 117.1,21.13 106.42,21.13 101.8,25.75 94.18,25.75 90.81,29.13 88.82,29.13 87.52,30.42 83.51,30.42 82.7,31.22 77.21,31.22 76.97,30.99 74.95,30.99 73.78,29.81 68.1,29.81 67.61,30.31 59.7,30.31 57.98,32.03 56.03,32.03 54.45,30.45 49.24,30.45 47.97,29.18 42.9,29.18 42.68,29.4 40.52,29.4 35.84,24.72 33.26,24.72 29.63,21.09 29.63,18.04 27.37,15.78 23.47,15.78 23.46,15.79 21.97,15.79 21.17,16.59 19.39,16.59 18.55,15.76 v1(17.11,15.76)
  BOTTOM w0.102: v1(17.11,15.76) 17.23,15.76 v2(17.64,15.35)
BATT_LED#_LV2: length 162.6
  TOP w0.089: UE1.B9 162.03,18.41 161.45,18.41 161.42,18.45 161.22,18.45
  TOP w0.102: v1(160.41,18.14) 160.72,18.45 161.22,18.45
  IN3 w0.102: v1(26.4,15.37) 27.25,15.37 30,18.12 30,21.03 33.41,24.44 35.85,24.44 40.6,29.2 42.6,29.2 42.82,28.98 48.55,28.98 48.77,29.2 53.48,29.2 56.11,31.83 57.89,31.83 58.28,31.44 58.28,29.02 59.38,27.92 63.5,27.92 64.99,29.41 73.95,29.41 75.12,30.58 77.14,30.58 77.38,30.82 82.54,30.82 83.34,30.02 87.35,30.02 88.65,28.72 90.64,28.72 94.62,24.73 98.44,24.73 98.64,24.94 101.75,24.94 106.17,20.52 116.85,20.52 117.27,20.1 121.96,20.1 122.58,20.71 128.9,20.71 129.11,20.51 140.99,20.51 141.84,19.66 146.15,19.66 147.11,18.7 149.4,18.7 149.72,18.38 157.19,18.38 158.02,19.21 158.84,19.21 159.24,18.81 159.24,17.91 159.62,17.52 160.26,17.52 160.41,17.67 v1(160.41,18.14)
  BOTTOM w0.102: Q17.2 26.5,17.33 26.91,16.92 26.91,15.88 v1(26.4,15.37) 25.74,14.71 25.51,14.71 R17.2 ; v2(160.54,18.65) 160.41,18.52 v1(160.41,18.14)
BATT_LED#_LV3: length 262.6
  TOP w0.076: UE1.N2 167.9,15.16 168.38,14.69 168.78,14.69
  TOP w0.102: 168.78,14.69 169.3,14.69 169.4,14.79 169.7,14.79 169.98,14.51 169.98,13.71 169.74,13.47 v3(169.58,13.47)
  GND1 w0.102: v4(169.33,13.02) 169.33,13.02 169.58,13.27 v3(169.58,13.47)
  IN1 w0.102: v4(119.24,15.19) 119.24,15.41 121.1,17.26 121.1,21.52 v4(120.89,21.72) ; v1(241.82,22.22) 241.82,18.39 v1(241.7,18.27)
  IN2 w0.076: 160.65,14.78 161.44,14.78 161.96,14.26 162.69,14.26 163.19,14.77 163.69,14.77 164.22,14.23 167.04,14.23 167.68,13.6
  IN2 w0.102: v4(169.33,13.02) 168.26,13.02 167.68,13.6 ; v4(119.24,15.19) 118.71,14.66 115.56,14.66 112.2,18.02 107.61,18.02 102.73,22.89 100.04,22.89 98.41,24.52 93.26,24.52 91.16,26.63 86.12,26.63 85.82,26.33 81.81,26.33 81.4,26.73 59.37,26.73 57.69,28.41 42.68,28.41 41.84,29.24 40.07,29.24 39.08,28.25 31.44,28.25 30.67,27.48 30.67,21.08 26.79,17.2 25.13,17.2 v1(22.64,14.71) ; v4(120.89,21.72) 120.99,21.72 122.14,22.88 131.09,22.88 132.62,21.35 147.09,21.35 147.56,20.87 148.22,20.87 150.1,18.99 153.94,18.99 155.48,17.45 155.48,16.31 155.73,16.07 157.58,16.07 158.77,14.88 160.15,14.88 160.25,14.78 160.65,14.78
  IN4 w0.102: v1(241.82,22.22) 210.83,22.22 208.7,20.09 205.33,20.09 202.15,16.91 201.06,16.91 200.22,16.07 197.95,16.07 197.03,15.15 195.27,15.15 193.83,13.7 184.6,13.7 184.29,13.4 172.25,13.4 171.46,12.61 169.74,12.61 169.33,13.02 v4(169.33,13.02)
  BOTTOM w0.102: R20.2 23.1,14.26 v1(22.64,14.71) 22.29,15.07 22.29,15.68 22.54,15.93 Q16.2 ; v1(241.7,18.27) 241.7,18.77 v2(241.54,18.93)
BATT_LED#_LV4: length 159.6
  TOP w0.076: UE1.A2 161.78,15.09 161.19,14.5 160.82,14.5 160.65,14.33
  TOP w0.102: v1(26.45,16.19) 26.45,16.04 25.89,15.48 Q18.2 26.15,14.88 26.15,14.16 25.79,13.8 R26.2 ; v1(160.23,13.63) 160.23,13.91 v2(160.51,14.19) 160.65,14.33
  IN2 w0.102: v1(160.23,13.63) 159.79,14.07 159,14.07 157.41,15.66 155.56,15.66 155.08,16.14 155.08,17.28 153.77,18.59 149.93,18.59 148.05,20.47 147.4,20.47 146.92,20.94 127.79,20.94 127.39,21.34 122.96,21.34 122.56,20.95 117.4,20.95 116.79,21.56 108.3,21.56 98.84,31.02 93.33,31.02 92.85,30.54 84.7,30.54 83.96,31.28 71.82,31.28 71.11,31.99 68.28,31.99 67.91,31.61 v4(67.91,30.93)
  IN3 w0.102: v1(26.45,16.19) 26.88,16.62 27.92,16.62 29.4,18.11 29.4,21.27 33.16,25.03 35.86,25.03 40.43,29.6 42.77,29.6 42.99,29.38 47.89,29.38 49.16,30.65 54.36,30.65 55.94,32.23 58.06,32.23 59.78,30.51 67.49,30.51 v4(67.91,30.93)
BATT_LED#_LV5: length 192.3
  TOP w0.089: 168.34,18.18 167.8,18.18 UE1.N8
  TOP w0.102: v1(172.74,18.26) 172.74,18.36 v2(172.35,18.76) 172.2,18.91 171.38,18.91 170.85,18.37 168.92,18.37 168.73,18.18 168.34,18.18
  IN1 w0.102: v4(119.83,15.13) 119.83,15.7 121.3,17.17 121.3,21.17 121.52,21.39 v4(121.52,21.67)
  IN2 w0.102: v1(17.71,17.33) 20.71,17.33 21.83,16.21 23.85,16.21 25.05,17.41 26.71,17.41 30.41,21.12 30.41,27.51 31.36,28.46 38.99,28.46 39.98,29.45 41.93,29.45 42.77,28.61 57.78,28.61 59.45,26.94 81.49,26.94 81.9,26.53 85.73,26.53 86.03,26.83 91.24,26.83 93.34,24.73 98.49,24.73 100.1,23.12 102.82,23.12 107.7,18.25 112.3,18.25 115.66,14.88 118.32,14.88 119.04,15.6 119.4,15.6 119.83,15.18 v4(119.83,15.13)
  IN3 w0.102: v1(172.74,18.26) 171.78,19.23 171.78,21.29 171.42,21.65 168.41,21.65 167.56,20.79 156.54,20.79 155.62,19.87 152.7,19.87 152.32,20.25 148.76,20.25 148.45,20.56 146.97,20.56 146.66,20.88 142.36,20.88 141.49,21.75 129.61,21.75 128.74,22.62 127.66,22.62 126.97,21.93 121.78,21.93 v4(121.52,21.67)
  BOTTOM w0.102: R11.2 21.47,18.81 20.41,18.81 19.37,17.76 Q15.2 18.58,17.76 18.15,17.33 v1(17.71,17.33)
BATT_LOW: length 3.1
  TOP w0.102: v2(27.04,15.58) 27.18,15.72 Q20.3 26.94,16.71 26.22,17.42 R24.1
BATT_LOW_LED#: length 155.9
  TOP w0.089: UE1.A4 161.54,16.16
  TOP w0.102: Q20.2 28.08,17.36 v1(28.34,17.62) 28.46,17.74 28.46,18.83 R34.2 ; v1(160.03,15.45) 160.27,15.69 161.07,15.69 161.54,16.16
  IN2 w0.102: v1(160.03,15.45) 159.66,15.08 158.85,15.08 156.24,17.7 155.53,17.7 154.03,19.2 150.19,19.2 148.31,21.08 147.65,21.08 147.02,21.7 132.55,21.7 131.18,23.08 122.01,23.08 121.37,22.44 119.98,22.44 118.91,21.37 117.55,21.37 116.94,21.98 108.46,21.98 99.01,31.43 84.21,31.43 84,31.64 79.7,31.64 79.01,32.32 68.01,32.32 67.32,31.63 v4(67.32,30.93)
  IN3 w0.102: v1(28.34,17.62) 28.62,17.9 28.62,18.61 29.04,19.03 29.04,21.24 33.06,25.26 35.8,25.26 40.35,29.81 42.85,29.81 43.07,29.59 47.8,29.59 49.07,30.86 54.28,30.86 55.86,32.44 58.14,32.44 59.76,30.82 67.21,30.82 v4(67.32,30.93)
  BOTTOM w0.102: v2(159.9,16.34) 160.03,16.21 v1(160.03,15.45)
BATT_LOW_LED#_D: length 31
  TOP w0.254: LED3.3 2.52,24.55 v1(3.41,23.66) ; R24.2 v2(24.19,18.12) 24.17,18.12 23.96,17.91 23.96,17.64 v1(23.33,17)
  IN3 w0.254: v1(23.33,17) 23.23,17 22.44,17.79 18.18,17.79 17.49,18.49 12.07,18.49 10.02,20.54 4.84,20.54 4.25,19.95 2.4,19.95 2.12,20.22 2.12,22.01 3.41,23.3 v1(3.41,23.66)
BATT_PRS: length 9.6
  TOP w0.254: PD104.2 98.65,20.75 v1(98.65,15.95)
  BOTTOM w0.254: v1(98.65,15.95) 99.42,16.71 BAT100.7
  vias: v8(97.52,22.99)
BBS_BIT0: length 7.7
  BOTTOM w0.089: U7.AU2 260.14,20.84
  BOTTOM w0.102: 260.14,20.84 260.14,20.16 259.54,19.56 257.87,19.56 257.06,18.75 256.46,18.75 RH29.1 RH245.2
BBS_BIT1: length 4.9
  TOP w0.089: RH244.2 275.16,25.27 274.89,25.53 273.88,25.53 v3(273.77,25.43) 273.46,25.43 273.18,25.14 273.18,24.35 v2(273.06,24.24)
  GND1 w0.089: v3(273.77,25.43) 273.62,25.28 v4(273.42,25.28)
  GND3 w0.089: v4(273.42,25.28) 273.81,25.68 v7(273.81,25.68)
  BOTTOM w0.089: v7(273.81,25.68) U7.C10
BE1_BD1: length 4
  BOTTOM w0.089: U6.BD1 U6.BE1 182.31,74.75
  BOTTOM w0.102: 182.31,74.75 v2(183.51,74.75)
BE2_BF2: length 4.1
  BOTTOM w0.089: 179.49,71.38 179.5,71.4 U6.BF2 179.5,74.06 U6.BE2
  BOTTOM w0.102: 179.49,71.38 v2(179,70.9)
BE3_BF3: length 4.8
  BOTTOM w0.089: U6.BE3 178.8,74.1 U6.BF3 178.75,71.97 178.17,71.38
  BOTTOM w0.102: 178.17,71.38 v2(177.35,70.57)
BE52_BF52: length 6.5
  BOTTOM w0.089: U6.BE52 145.74,74.72 U6.BF52 145.74,73.62 145.38,73.26 143.04,73.26 142.17,72.4
  BOTTOM w0.102: 142.17,72.4 v2(141.24,71.46)
BE53_BF53: length 5
  BOTTOM w0.089: 142.17,74.06 U6.BF53 145.07,74.09 U6.BE53
  BOTTOM w0.102: v2(140.93,73.59) 141.4,74.06 142.17,74.06
BE54_BD54: length 4.4
  BOTTOM w0.089: U6.BD54 U6.BE54 142.17,74.67
  BOTTOM w0.102: v2(141.01,75.55) 141.89,74.67 142.17,74.67
BEEP#: length 157
  TOP w0.089: 168.34,17.91 168.32,17.9 167.89,17.9 167.88,17.91 167.68,17.91 167.43,18.16 UE1.M8
  TOP w0.102: v2(32.7,37.85) 32.4,38.16 v1(32.09,38.16) 32.09,37.88 31.53,37.32 RA9.2 ; 168.34,17.91 168.39,17.97 169.14,17.97 v3(169.19,18.02)
  GND1 w0.102: v3(169.19,18.02) 169.15,17.98 v4(168.78,17.98)
  IN2 w0.076: v4(168.78,17.98) 168.57,18.19 167.6,18.19 167.07,17.66 166.75,17.66 166.23,18.18 166.23,18.56 165.54,19.25 164.91,19.25 164.53,19.63 164.53,21.72
  IN2 w0.102: 164.53,21.72 164.53,21.93 163.9,22.56 160.61,22.56 160.11,22.06 152.6,22.06 152.14,22.51 152.14,23.63 150.16,25.61 134.11,25.61 133.46,26.26 107.71,26.26 100.07,33.9 90.45,33.9 88.78,35.58 76.83,35.58 76.4,35.15 69.44,35.15 68.58,36.01 66.12,36.01 65.16,36.96 61.04,36.96 60.63,37.37 54.93,37.37 53.99,38.31 51.22,38.31 49.95,39.58 47.71,39.58 46.65,40.65 45.91,40.65 v4(45.63,40.37)
  IN3 w0.102: v4(45.63,40.37) 44.85,41.15 36.37,41.15 36.1,40.88 34.89,40.88 34.55,40.54 34.55,39.33 33.38,38.16 v1(32.09,38.16)
BKOFF#: length 87.5
  TOP w0.089: v3(163.72,14.25) 163.72,14.6 UE1.E1
  GND1 w0.076: v3(163.72,14.25) 163.46,14.25 163.31,14.4 v4(163.31,14.4)
  IN2 w0.076: v4(163.31,14.4) 162.97,14.05 161.94,14.05 161.41,14.58 160.65,14.58
  IN2 w0.102: 160.65,14.58 160.17,14.58 160.07,14.68 158.85,14.68 158.69,14.68 157.5,15.86 155.64,15.86 155.28,16.22 155.28,17.37 153.86,18.79 150.02,18.79 148.14,20.67 147.48,20.67 147.01,21.15 127.88,21.15 127.47,21.55 122.88,21.55 122.48,21.15 117.48,21.15 116.87,21.76 108.39,21.76 98.92,31.22 90.23,31.22 v4(90,31)
  GND3 w0.102: v4(90,31) 90.23,30.77 v7(90.66,30.77)
  BOTTOM w0.102: RV12.1 88.51,29.2 v2(88.8,29.2) 89,29.2 89.74,29.93 DV13.2 90.32,30.43 v7(90.66,30.77)
