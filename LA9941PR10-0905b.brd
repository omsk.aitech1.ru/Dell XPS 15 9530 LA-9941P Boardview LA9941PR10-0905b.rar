# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_D18: length 32.3
  IN1 w0.089: 230.88,87.4 230.74,87.4 230.73,87.41 230.15,87.41 228.77,86.03 228.77,83.26 228.33,82.82 228.33,79.81 v1(227.96,79.45)
  IN1 w0.094: 230.88,87.4 234.66,87.4 238.07,90.81 242.33,90.81 243.17,91.65 247.48,91.65 248.16,92.33 249.67,92.33 v1(250.19,92.85)
  BOTTOM w0.089: v1(227.96,79.45) 227.61,79.8 UV1.D3
  BOTTOM w0.102: v1(250.19,92.85) UV9.T11
FBB_D19: length 38.5
  IN1 w0.089: 230.88,88.54 230.6,88.54 230.59,88.53 230.12,88.53 227.59,85.99 227.59,82.88 227.58,82.87 227.58,80.71 227.42,80.55 227.42,79.16 227.93,78.65 v1(228.03,78.65)
  IN1 w0.094: v1(252.59,92.85) 252.59,93.15 251.5,94.24 248.68,94.24 248.11,94.8 241.75,94.8 238.92,91.98 237.64,91.98 234.19,88.54 230.88,88.54
  BOTTOM w0.089: UV1.C1 228.03,78.57 v1(228.03,78.65)
  BOTTOM w0.102: v1(252.59,92.85) UV9.T13
FBB_D20: length 32.5
  IN1 w0.089: 230.88,79.58 230.52,79.94 230.27,79.94 229.24,80.96 229.24,82.5 229.98,83.24 229.98,84.64 231,85.66
  IN1 w0.094: v1(250.14,90.45) 249.98,90.45 249.17,89.65 247.92,89.65 247.08,88.81 246.01,88.81 245.65,88.44 242.82,88.44 242.15,89.11 240.04,89.11 236.59,85.66 231,85.66 ; v1(231.07,79.38) 230.88,79.58
  BOTTOM w0.089: 230.88,79.58 230.33,80.12 229.52,80.12 UV1.B3
  BOTTOM w0.102: v1(250.14,90.45) 250.18,90.45 UV9.N11
  BOTTOM w0.127: 230.88,79.58 v1(231.07,79.38)
FBB_D21: length 35
  IN1 w0.094: v1(231.58,80.97) 231.8,81.19 233.37,81.19 233.47,81.28 233.47,82.1 233.56,82.19 233.75,82.19 233.84,82.1 233.84,81.28 233.94,81.19 234.13,81.19 234.22,81.28 234.22,82.1 234.31,82.19 234.5,82.19 234.6,82.1 234.6,81.28 234.69,81.19 234.88,81.19 234.97,81.28 234.97,82.1 235.07,82.19 235.25,82.19 235.35,82.1 235.35,81.28 235.44,81.19 235.63,81.19 235.72,81.28 235.72,82.1 235.82,82.19 236.61,82.19 240.51,86.09 243.52,86.09 243.57,86.04 244.87,86.04 244.91,86.08 245.57,86.08 246.07,86.57 248.27,86.57 248.93,87.23 250.29,87.23 250.71,87.65 251.15,87.65 252.17,88.67 252.17,89.23 v1(252.59,89.65)
  BOTTOM w0.089: 230.88,80.34 229.42,80.34 229.3,80.21 228.84,80.21 UV1.C4
  BOTTOM w0.102: v1(252.59,89.65) UV9.N13
  BOTTOM w0.127: v1(231.58,80.97) 230.95,80.34 230.88,80.34
FBB_D22: length 33.4
  IN1 w0.094: v1(230.92,80.95) 230.92,82.42 231.15,82.64 231.8,82.64 231.9,82.55 231.9,81.67 231.99,81.58 232.18,81.58 232.27,81.67 232.27,82.55 232.37,82.64 232.56,82.64 232.65,82.55 232.65,81.67 232.74,81.58 232.93,81.58 233.03,81.67 233.03,82.55 233.12,82.64 236.36,82.64 236.66,82.95 236.66,83.08 236.19,83.56 236.19,83.69 236.32,83.83 236.45,83.83 236.93,83.35 237.06,83.35 237.2,83.48 237.2,83.61 236.72,84.09 236.72,84.23 236.85,84.36 236.98,84.36 237.46,83.88 237.6,83.88 240.56,86.85 242.59,86.85 245.57,86.85 246.14,87.41 248.47,87.41 249.17,88.11 249.32,88.11 249.81,88.6 249.81,89.2 v1(250.2,89.59)
  BOTTOM w0.089: UV9.M11 250.54,89.25 v1(250.2,89.59)
  BOTTOM w0.102: v1(230.92,80.95) 230.78,81.1 229.6,81.1 UV1.B5
FBB_D23: length 32.6
  IN1 w0.094: v1(229.6,81.87) 231.91,84.17 236.12,84.17 237.55,85.6 237.68,85.6 238.19,85.1 238.32,85.1 238.45,85.23 238.45,85.36 237.95,85.87 237.95,86 238.08,86.13 238.21,86.13 238.72,85.63 238.85,85.63 238.98,85.76 238.98,85.89 238.48,86.4 238.48,86.53 238.61,86.66 238.74,86.66 239.25,86.16 239.38,86.16 239.52,86.29 239.52,86.43 239.01,86.93 239.01,87.06 239.58,87.64 245.53,87.64 245.85,87.96 245.85,88.25 246.1,88.5 247.69,88.5 248.44,89.25 249.22,89.25 250.02,90.05 251.39,90.05 v1(251.79,89.65)
  BOTTOM w0.102: v1(229.6,81.87) 228.74,81.87 228.4,81.52 UV1.C5 ; v1(251.79,89.65) UV9.M13
FBB_D24: length 22
  IN4 w0.094: v1(245.4,93.63) 244.62,94.4 242.06,94.4 241.89,94.24 239.45,94.24 236.63,91.42 231.63,91.42 230.79,90.58 230.79,86.59 v1(230.57,86.37)
  BOTTOM w0.089: UV9.U4 245.02,93.25 v1(245.4,93.63) ; v1(230.57,86.37) 230.43,86.5 UV1.A11
FBB_D25: length 22.7
  IN4 w0.094: v1(242.97,93.67) 242.85,93.54 239.74,93.54 236.92,90.73 231.92,90.73 231.49,90.29 231.49,85.07 v1(231.59,84.97)
  BOTTOM w0.089: 230.88,85.4 230.69,85.4 230.38,85.71 230.08,85.71 229.8,85.99 228.91,85.99 UV1.C11 ; v1(242.97,93.67) 243.39,93.25 UV9.U2
  BOTTOM w0.127: 230.88,85.4 231.16,85.4 v1(231.59,84.97)
FBB_D26: length 26.4
  IN4 w0.094: v1(244.56,92.82) 244.56,93.65 244.16,94.06 242.53,94.06 242.36,93.89 239.59,93.89 236.78,91.07 231.78,91.07 231.14,90.43 231.14,85.09 v1(231,84.95)
  BOTTOM w0.089: v1(244.56,92.82) 244.93,92.45 UV9.T4 ; 230.88,84.95 230.77,84.95 230.4,85.33 228.24,85.33 228.03,85.54 228.03,86.07 UV1.D11
  BOTTOM w0.127: 230.88,84.95 v1(231,84.95)
FBB_D27: length 23
  IN4 w0.094: v1(243.79,92.85) 243.59,92.85 243.18,93.25 241.9,93.25 241.67,93.02 239.71,93.02 237.07,90.38 232.07,90.38 231.83,90.15 231.83,85.35 v1(232.22,84.97)
  BOTTOM w0.089: 230.88,85.89 230.15,85.89 229.54,86.5 UV1.B11 ; v1(243.79,92.85) UV9.T2
  BOTTOM w0.127: 230.88,85.89 231.3,85.89 v1(232.22,84.97)
FBB_D28: length 22.3
  IN4 w0.094: v1(233.97,83.11) 233.97,83.92 240.69,90.63 242.5,90.63 242.73,90.86 244.17,90.86 v1(244.57,90.45)
  BOTTOM w0.089: v1(244.57,90.45) 244.98,90.05 UV9.N4 ; UV1.D8 228.13,83.47 229.33,83.47 230.29,82.52 230.88,82.52
  BOTTOM w0.127: v1(233.97,83.11) 233.37,82.52 230.88,82.52
FBB_D29: length 18.8
  IN4 w0.094: v1(243.79,89.64) 243.39,89.24 242.71,89.24 242.66,89.29 240.82,89.29 235.93,84.4 v1(235.93,83.12)
  BOTTOM w0.089: UV9.N2 243.39,90.04 v1(243.79,89.64) ; 230.88,83.66 230.67,83.66 230.33,84 UV1.A8
  BOTTOM w0.127: v1(235.93,83.12) 234.75,84.29 233.35,84.29 232.72,83.66 230.88,83.66
FBB_D30: length 22
  IN4 w0.094: v1(245.39,89.65) 244.98,90.05 240.59,90.05 234.59,84.05 v1(234.59,83.13)
  BOTTOM w0.089: 230.88,82.9 230.16,82.9 229.41,83.65 228.75,83.65 UV1.C8 ; v1(245.39,89.65) UV9.M4
  BOTTOM w0.127: v1(234.59,83.13) 234.19,83.53 233.67,83.53 233.03,82.9 230.88,82.9
FBB_D31: length 18.6
  IN4 w0.094: v1(242.98,89.66) 240.69,89.66 235.29,84.26 v1(235.29,83.13)
  BOTTOM w0.089: UV9.M2 243.39,89.25 v1(242.98,89.66) ; 230.88,83.28 230.1,83.28 229.38,84 UV1.B8
  BOTTOM w0.127: 230.88,83.28 232.87,83.28 233.51,83.91 234.51,83.91 v1(235.29,83.13)
FBB_D32: length 23.6
  IN4 w0.094: v1(225.54,96.88) 225.65,96.77 227.53,96.77 228.27,96.03 230.11,96.03 230.76,96.68 235.56,96.68 238.36,99.48 v1(240.18,99.48)
  BOTTOM w0.089: UV1.F24 225.95,97.3 v1(225.54,96.88)
  BOTTOM w0.127: UV10.A4 244.99,98.22 244.39,97.62 241.16,97.62 240.18,98.6 v2(240.18,98.89) v1(240.18,99.48)
FBB_D33: length 22.6
  IN4 w0.094: v1(224.7,96.88) 225.07,97.25 225.69,97.25 225.9,97.04 227.77,97.04 228.4,96.41 229.97,96.41 230.61,97.06 235.22,97.06 238.15,99.98 240.35,99.98 v1(240.75,100.39)
  BOTTOM w0.089: UV1.G23 225.08,96.5 v1(224.7,96.88)
  BOTTOM w0.127: v1(240.75,100.39) 240.75,100.12 241.34,99.54 241.34,99.03 241.53,98.84 243.03,98.84 UV10.A2
FBB_D34: length 23.7
  IN4 w0.094: v1(226.38,97.69) 226.38,97.42 226.51,97.29 228.05,97.29 228.54,96.8 229.82,96.8 230.46,97.44 235.03,97.44 237.98,100.39 v1(240.14,100.39)
  BOTTOM w0.089: UV1.E24 226.41,97.69 v1(226.38,97.69)
  BOTTOM w0.127: UV10.B4 244.61,98.91 244.61,98.39 244.22,98 241.32,98 240.96,98.36 240.96,99.35 240.14,100.16 v1(240.14,100.39)
FBB_D35: length 21.6
  IN4 w0.094: v1(241.27,100.74) 241.1,100.92 237.76,100.92 234.66,97.82 230.3,97.82 229.69,97.21 228.56,97.21 227.62,98.15 226.02,98.15 v1(225.56,97.7)
  BOTTOM w0.089: UV1.G24 225.1,97.31 225.17,97.31 v1(225.56,97.7)
  BOTTOM w0.127: v1(241.27,100.74) 241.27,100.17 241.8,99.65 243.02,99.65 UV10.B2
FBB_D36: length 27.6
  IN4 w0.094: v1(227.19,95.18) 227.48,95.18 228.14,94.52 230.78,94.52 231.31,95.05 236.48,95.05 239.17,97.74 v1(240.31,97.74)
  BOTTOM w0.102: v1(227.19,95.18) 227.57,94.8 UV1.D21
  BOTTOM w0.127: v1(240.31,97.74) v2(240.73,97.32) 240.81,97.24 246.6,97.24 246.65,97.29 246.65,101.16 246.52,101.29 245.38,101.29 UV10.E4
FBB_D37: length 24.2
  IN4 w0.094: v1(242.99,102.08) 243.38,101.68 243.38,101.08 243.67,100.79 243.67,99.51 241.99,97.83 241.1,97.83 240.63,98.31 239.13,98.31 236.3,95.48 231.2,95.48 230.61,94.89 228.18,94.89 227.53,95.54 226.47,95.54 v1(226.3,95.38)
  BOTTOM w0.089: 226.41,95.27 226.8,94.88 226.8,94.84
  BOTTOM w0.102: v1(242.99,102.08) UV10.E2 ; UV1.E21 226.8,94.84 ; 226.41,95.27 v1(226.3,95.38)
FBB_D38: length 27.2
  IN4 w0.094: v1(244.59,102.08) 244.58,102.08 244.18,101.68 244.18,99.47 244.46,99.19 244.46,98.95 242.74,97.23 239.37,97.23 236.69,94.55 231.35,94.55 230.92,94.12 227.66,94.12 226.79,94.99 226.09,94.99 225.89,95.19 225.89,95.33 225.61,95.61 225.03,95.61 v1(224.7,95.28)
  BOTTOM w0.089: v1(224.7,95.28) 225.1,94.88 UV1.G21
  BOTTOM w0.102: v1(244.59,102.08) UV10.F4
FBB_D39: length 28.4
  IN4 w0.094: v1(225.49,95.18) 225.49,95.06 225.75,94.8 226.58,94.8 227.66,93.72 231.05,93.72 231.51,94.17 236.85,94.17 239.56,96.88 242.99,96.88 244.79,98.68 244.79,99 244.99,99.21 244.99,102.3 244.81,102.49 244.18,102.49 v1(243.79,102.88)
  BOTTOM w0.089: UV1.F21 225.87,94.8 v1(225.49,95.18)
  BOTTOM w0.102: v1(243.79,102.88) UV10.F2
FBB_D40: length 33.1
  IN1 w0.094: v1(225.54,100.28) 226,99.83 226,99.8 227.05,99.8 228.37,98.48 228.37,97.54 228.6,97.31 233.75,97.31 238.74,102.31 242.57,102.31 242.75,102.48 245.43,102.48 245.73,102.18 246.54,102.18 247.41,101.31 247.41,100.05 248.86,98.6 249.56,98.6 249.85,98.89 v1(250.98,98.89)
  BOTTOM w0.089: UV10.A11 250.59,98.5 v1(250.98,98.89) ; v1(225.54,100.28) 225.18,99.93 225.18,99.8 UV1.G27
FBB_D41: length 31.7
  IN1 w0.094: v1(252.6,98.87) 252.2,99.28 249.86,99.28 249.49,98.91 249.01,98.91 247.79,100.13 247.79,101.71 246.51,102.99 246.04,102.99 245.74,103.28 242.59,103.28 242.43,103.11 240.96,103.11 240.5,102.66 238.4,102.66 233.55,97.81 230.43,97.81 229.29,98.94 228.44,98.94 v1(227.98,99.41)
  BOTTOM w0.089: v1(252.6,98.87) 252.21,98.48 UV10.A13 ; UV1.D27 227.6,99.78 v1(227.98,99.41)
FBB_D42: length 33.2
  IN1 w0.094: v1(250.19,98.01) 249.49,97.31 248.65,97.31 246.7,99.27 246.7,100.69 246.41,100.97 244.98,100.97 244.89,100.88 244,100.88 242.78,99.65 241.59,99.65 241.27,99.97 237.88,99.97 234.43,96.51 228.88,96.51 228,97.39 228,98.33 227.33,99 225.93,99 v1(225.54,99.39)
  BOTTOM w0.089: UV1.G26 225.14,99 v1(225.54,99.39) ; v1(250.19,98.01) 250.19,98.01 250.19,98.94 250.53,99.28 UV10.B11
FBB_D43: length 33.2
  IN1 w0.094: v1(226.38,99.39) 227.2,99.39 228.19,98.41 228.19,97.47 228.69,96.97 234.24,96.97 237.69,100.42 239.56,100.42 240.39,101.25 242.28,101.25 242.71,101.68 245.64,101.68 246.01,101.31 246.68,101.31 247.05,100.94 247.05,99.47 248.83,97.69 249.36,97.69 249.77,98.1 249.77,98.38 249.85,98.45 251.37,98.45 v1(251.8,98.89)
  BOTTOM w0.089: v1(251.8,98.89) 252.19,99.27 UV10.B13 ; v1(226.38,99.39) 226.78,99.8 UV1.E27
FBB_D44: length 32.2
  IN1 w0.094: v1(227.13,101.08) 227.35,101.08 227.96,100.46 229.29,100.46 230.75,99.01 233.05,99.01 237.9,103.86 240.17,103.86 241.59,105.29 243.93,105.29 244.32,105.68 246.48,105.68 247.71,104.45 247.71,103.66 248.96,102.42 248.96,101.02 249.19,100.79 250.24,100.79 250.72,101.27 v1(251.01,101.27)
  BOTTOM w0.089: v1(251.01,101.27) 250.61,101.68 UV10.E11 ; UV1.E29 226.8,101.41 226.9,101.31 226.9,101.31 v1(227.13,101.08)
FBB_D45: length 34.4
  IN1 w0.094: v1(226.38,101.12) 226.81,101.55 227.32,101.55 228.18,100.69 229.39,100.69 230.7,99.38 232.9,99.38 238.56,105.04 239.94,105.04 241.01,106.1 243.24,106.1 243.62,106.48 245.63,106.48 245.92,106.19 246.48,106.19 248.09,104.58 248.09,103.79 249.28,102.61 249.53,102.61 249.77,102.37 249.77,101.81 249.9,101.68 252.2,101.68 v1(252.6,101.27)
  BOTTOM w0.089: v1(252.6,101.27) 252.2,101.68 UV10.E13 ; 225.97,101.53 225.97,101.52 v1(226.38,101.12)
  BOTTOM w0.102: UV1.F29 225.97,101.53
FBB_D46: length 29.9
  IN1 w0.094: v1(227.14,101.96) 227.16,101.93 227.19,101.93 228.16,100.97 233.36,100.97 238.82,106.43 240.28,106.43 240.79,106.94 242.45,106.94 242.79,107.28 245.34,107.28 245.99,106.63 246.62,106.63 250.18,103.08 v1(250.18,102.09)
  BOTTOM w0.089: v1(227.14,101.96) 226.8,102.3 226.8,102.4 ; UV10.F11 250.57,102.48 v1(250.18,102.09)
  BOTTOM w0.102: UV1.E30 226.8,102.4
FBB_D47: length 32.3
  IN1 w0.094: v1(251.79,102.89) 251.2,102.89 250.58,103.5 250.58,104.64 250.35,104.87 249.14,104.87 246.46,107.56 246.11,107.56 245.59,108.08 242.9,108.08 242.54,107.73 240.37,107.73 239.65,107.01 238.75,107.01 233.17,101.43 229.48,101.43 229.3,101.25 228.14,101.25 227.65,101.74 227.65,102.31 v1(228.03,102.69)
  BOTTOM w0.089: v1(228.03,102.69) 227.76,102.42 227.72,102.42 UV1.D30 ; v1(251.79,102.89) 252.19,102.49 UV10.F13
FBB_D48: length 25.1
  IN1 w0.094: v1(250.2,111.65) 247.11,111.65 245.89,112.87 239,112.87 230.96,104.83 v1(230.54,104.83)
  BOTTOM w0.089: UV1.A32 230,104.24 230.54,104.78 v1(230.54,104.83)
  BOTTOM w0.102: UV10.U11 250.22,111.65 v1(250.2,111.65)
FBB_D49: length 30.9
  IN1 w0.094: v1(228.03,103.56) 228.36,103.89 228.36,104.44 228.65,104.74 229.63,104.74 230.44,105.54 230.62,105.54 238.69,113.62 246.13,113.62 247.28,112.46 248.9,112.46 250.86,112.46 251.79,111.54 v1(251.79,110.88)
  BOTTOM w0.089: 228.4,103.19 v1(228.03,103.56)
  BOTTOM w0.102: v1(251.79,110.88) UV10.U13 ; UV1.C31 228.4,103.19
FBB_D50: length 28.3
  IN1 w0.094: v1(250.99,110.88) 250.61,111.26 250.61,111.85 250.38,112.08 249.06,112.08 247.17,112.08 246,113.25 238.85,113.25 230.79,105.19 230.36,105.19 229.54,104.37 v1(228.8,104.37)
  BOTTOM w0.089: UV1.C32 228.43,104 v1(228.8,104.37)
  BOTTOM w0.102: v1(250.99,110.88) UV10.T11
FBB_D51: length 30.6
  IN1 w0.094: v1(252.59,110.94) 252.59,111.53 251.27,112.84 247.39,112.84 246.21,114.02 238.52,114.02 230.62,106.13 v1(229.93,106.13)
  BOTTOM w0.102: v1(229.93,106.13) 229.57,105.77 229.57,104.37 UV1.B32 ; v1(252.59,110.94) 252.19,110.54 UV10.T13
FBB_D52: length 27.4
  IN1 w0.094: v1(250.19,107.68) 247.29,107.68 246.09,108.88 243.78,108.88 243.39,108.49 240.12,108.49 239.14,107.51 238.62,107.51 232.98,101.87 v1(228.84,101.87)
  BOTTOM w0.089: UV1.D29 227.62,101.5 228.02,101.11 228.65,101.11 228.84,101.3 228.84,101.87 v1(228.84,101.87)
  BOTTOM w0.102: v1(250.19,107.68) UV10.N11
FBB_D53: length 29.6
  IN1 w0.094: v1(251.79,107.68) 251.39,108.08 250.83,108.08 250.58,108.33 250.58,108.64 250.34,108.88 247.73,108.88 246.14,110.47 242.68,110.47 242.28,110.07 238.45,110.07 233.61,105.23 233.61,103.84 232.59,102.81 230.91,102.81 230.35,103.37 v1(230.35,103.37)
  BOTTOM w0.102: v1(230.35,103.37) 230.35,103.37 230.4,103.32 230.4,101.97 230,101.57 UV1.A29 ; v1(251.79,107.68) UV10.N13
FBB_D54: length 29
  IN1 w0.094: v1(228.03,101.93) 228.27,101.93 228.66,102.31 229.17,102.31 229.25,102.39 232.77,102.39 234.12,103.75 234.12,105.16 238.24,109.28 242.97,109.28 243.37,109.68 245.72,109.68 246.13,109.27 246.32,109.27 247.51,108.08 250.34,108.08 250.74,107.68 v1(250.99,107.68)
  BOTTOM w0.089: v1(228.03,101.93) 228.4,101.55 UV1.C29
  BOTTOM w0.102: v1(250.99,107.68) UV10.M11
FBB_D55: length 31.7
  IN1 w0.094: v1(252.59,107.68) 252.2,108.07 252.2,108.68 252,108.88 250.83,108.88 250.58,109.13 250.58,109.44 250.34,109.68 247.56,109.68 245.96,111.28 239.16,111.28 233.17,105.29 233.17,103.88 232.86,103.58 230.86,103.58 230.69,103.74 230.19,103.74 229.97,103.52 229.97,102.93 v1(229.98,102.92)
  BOTTOM w0.102: v1(229.98,102.92) 229.98,102.85 229.64,102.51 229.64,101.94 UV1.B29 ; v1(252.59,107.68) UV10.M13
FBB_D56: length 29.1
  IN4 w0.094: v1(232.06,104.02) 232.06,106.88 237.64,112.46 243.85,112.46 244.61,111.7 244.61,111.69 v1(244.63,111.67)
  BOTTOM w0.089: v1(244.63,111.67) 244.99,111.32 UV10.U4
  BOTTOM w0.127: UV1.B21 229.38,94.8 230.41,95.83 230.42,95.83 232.06,97.48 v1(232.06,104.02)
FBB_D57: length 25.5
  IN4 w0.094: v1(242.97,111.67) 237.83,111.67 233.17,107.01 233.17,103.81 229.52,100.15 228.84,100.15 228.37,99.69 228.37,98.08 v1(228.78,97.68)
  BOTTOM w0.089: v1(242.97,111.67) 243.37,111.28 UV10.U2
  BOTTOM w0.102: UV1.C23 228.78,96.88 v1(228.78,97.68)
FBB_D58: length 28.7
  IN4 w0.094: v1(244.59,110.88) 244.18,111.28 243.52,111.28 243.37,111.43 243.37,111.93 243.18,112.11 237.78,112.11 232.64,106.98 v1(232.64,104.02)
  BOTTOM w0.089: UV10.T4 244.98,110.48 v1(244.59,110.88)
  BOTTOM w0.127: UV1.A21 230.28,95.08 230.28,95.15 232.64,97.52 v1(232.64,104.02)
FBB_D59: length 27.2
  IN4 w0.094: v1(231.64,100.21) 231.64,100.47 234.2,103.03 234.2,106.61 237.66,110.07 242.35,110.07 242.79,109.63 243.22,109.63 243.39,109.81 243.39,110.44 243.79,110.83 v1(243.79,110.88)
  BOTTOM w0.089: UV10.T2 v1(243.79,110.88)
  BOTTOM w0.127: v1(231.64,100.21) v2(231.64,99.22) 231.64,97.6 229.29,95.25 228.82,95.25 228.4,94.84 UV1.C21
FBB_D60: length 21.5
  IN4 w0.094: v1(229.54,97.74) 230,98.2 233.77,98.2 238.59,103.02 239.17,103.02 240.8,104.65 241.59,104.65 243.41,106.47 243.98,106.47 244.19,106.68 244.19,108.09 v1(244.59,108.48)
  BOTTOM w0.089: v1(229.54,97.74) 229.2,97.4 UV1.B24 ; UV10.N4 v1(244.59,108.48)
FBB_D61: length 22.8
  IN4 w0.094: v1(228.78,98.57) 229.22,99.01 230.24,99.01 230.67,98.58 233.41,98.58 234.61,99.78 234.61,100.35 236.71,102.45 236.71,104.27 238.16,105.72 240.57,105.72 241.76,106.91 242.96,106.91 v1(242.99,106.89)
  BOTTOM w0.089: v1(242.99,106.89) 242.99,107.68 UV10.N2 ; 228.4,97.42 228.02,97.81 228.02,98.25 228.33,98.57 v1(228.78,98.57)
  BOTTOM w0.102: UV1.C24 228.4,97.42
FBB_D62: length 25.3
  IN4 w0.094: v1(245.39,107.68) 244.98,108.08 244.98,108.69 244.79,108.88 244.12,108.88 243.73,108.49 241.77,108.49 240.11,106.83 237.7,106.83 235.61,104.73 235.61,102.91 233.51,100.82 233.51,100.03 232.8,99.31 231,99.31 230.34,99.98 230.34,100.36 v1(230.52,100.54)
  BOTTOM w0.089: v1(230.52,100.54) 230.32,100.34 230.32,99.6 230.09,99.36 229.86,99.36 229.5,99 UV1.B26 ; UV10.M4 v1(245.39,107.68)
FBB_D63: length 21.7
  IN4 w0.094: v1(243.79,106.88) 242.94,107.73 241.88,107.73 240.36,106.21 237.96,106.21 236.23,104.48 236.23,102.66 234.07,100.5 234.07,99.98 233.06,98.96 230.86,98.96 230.43,99.39 v1(228.79,99.39)
  BOTTOM w0.089: UV10.M2 v1(243.79,106.88) ; UV1.C26 228.4,99 v1(228.79,99.39)
FBB_DBI0: length 20.4
  IN4 w0.089: 230.88,82.15 227.14,85.89 v1(227.14,86.05)
  IN4 w0.094: 230.88,82.15 230.95,82.07 232.1,82.07 233.06,81.11 238.62,81.11 241.12,83.61 v1(241.22,83.61)
  BOTTOM w0.089: v1(227.14,86.05) 226.76,86.43 226.76,86.46 UV1.E11 ; UV9.D2 243.01,83.22 241.74,83.22 241.7,83.26
  BOTTOM w0.127: 241.7,83.26 241.58,83.26 v1(241.22,83.61)
FBB_DBI1: length 36
  IN1 w0.089: v1(227.14,80.97) 226.75,80.58 225.35,80.58 225.11,80.34 225.11,78.95
  IN1 w0.094: v1(251.78,82.45) 251.6,82.45 251.17,82.03 242.78,82.03 242.38,82.43 240.79,82.43 237.05,78.68 234.57,78.68 232.5,76.61 227.45,76.61 225.11,78.95
  BOTTOM w0.089: v1(227.14,80.97) 227.14,80.27 226.7,79.83 UV1.E3 ; UV9.D13 252.17,82.84 v1(251.78,82.45)
FBB_DBI2: length 33.1
  IN1 w0.089: v1(230.44,79.38) 228.98,80.84 228.98,82.6 229.51,83.13 229.51,84.64 230.88,86.01
  IN1 w0.094: 230.88,86.01 236.44,86.01 239.9,89.46 242.02,89.46 242.61,90.05 247.03,90.05 247.82,90.85 252.19,90.85 v1(252.59,91.25)
  BOTTOM w0.089: v1(252.59,91.25) UV9.P13 ; v1(230.44,79.38) 230.02,79.8 UV1.A3
FBB_DBI3: length 21.3
  IN4 w0.094: v1(233.49,84.97) 233.58,85.06 233.58,87.37 234.83,88.63 236.41,88.63 239.82,92.04 241.51,92.04 241.9,91.65 243.38,91.65 v1(243.79,91.25)
  BOTTOM w0.089: v1(243.79,91.25) UV9.P2 ; UV1.C9 228.8,84.4 230.31,84.4 230.67,84.04 230.88,84.04
  BOTTOM w0.127: 230.88,84.04 232.56,84.04 v1(233.49,84.97)
FBB_DBI4: length 22.8
  IN4 w0.094: v1(242.99,101.28) 242.99,101.05 243.38,100.65 243.38,99.95 242.29,98.86 241.37,98.86 241.17,98.66 238.87,98.66 236.12,95.91 231.1,95.91 230.5,95.32 228.15,95.32 227.73,95.74 225.82,95.74 v1(225.49,96.08)
  BOTTOM w0.089: v1(225.49,96.08) 225.91,96.5 UV1.F23
  BOTTOM w0.102: v1(242.99,101.28) UV10.D2
FBB_DBI5: length 33.8
  IN1 w0.094: v1(226.36,100.22) 226.78,100.64 227.28,100.64 227.71,100.21 229.04,100.21 230.64,98.61 233.22,98.61 238.07,103.46 240.26,103.46 241.69,104.89 244.2,104.89 244.21,104.88 245.65,104.88 246.09,104.44 246.47,104.44 248.6,102.3 248.6,100.46 249.06,100 249.92,100 250.8,100.88 251.38,100.88 v1(251.79,101.29)
  BOTTOM w0.089: UV10.D13 252.19,100.89 v1(251.79,101.29) ; UV1.F27 225.95,99.8 v1(226.36,100.22)
FBB_DBI6: length 30.7
  IN1 w0.094: v1(252.59,109.28) 251.39,110.47 250.7,110.47 250.62,110.39 247.88,110.39 245.78,112.49 239.16,112.49 231.1,104.43 229.89,104.43 229.25,103.78 229.25,103.15 v1(228.84,102.75)
  BOTTOM w0.089: v1(228.84,102.75) 228.4,102.31 UV1.C30
  BOTTOM w0.102: v1(252.59,109.28) UV10.P13
FBB_DBI7: length 23.9
  IN4 w0.094: v1(243,110.06) 243,110.08 242.18,110.9 237.55,110.9 233.61,106.96 233.61,103.76 231.14,101.28 v1(231.14,100.54)
  BOTTOM w0.089: UV10.P2 243,109.27 v1(243,110.06)
  BOTTOM w0.127: UV1.A24 230.57,97.87 230.57,99.97 v1(231.14,100.54)
FBB_EDC0: length 23.3
  IN4 w0.089: 230.88,81.72 230.77,81.72 227.32,85.17 v1(227.16,85.17)
  IN4 w0.094: 230.88,81.72 231.96,81.72 232.98,80.7 236.02,80.7 236.18,80.54 236.18,80.07 v1(235.44,79.33)
  BOTTOM w0.089: v1(227.16,85.17) 227.16,85.21 UV1.D10
  BOTTOM w0.127: UV9.C2 243.02,82.41 241.38,82.41 241.11,82.68 237.78,82.68 235.44,80.35 v1(235.44,79.33)
FBB_EDC1: length 38.7
  IN1 w0.089: 224.77,78.8 224.77,80.51 225.15,80.88 226.23,80.88 v1(227.22,81.87)
  IN1 w0.094: 224.77,78.8 224.77,78.4 227.37,75.8 232.57,75.8 233.41,76.64 235.62,76.64 240.6,81.62 241.86,81.62 241.86,81.62 243.22,81.62 243.59,81.25 248.14,81.25 248.54,81.65 250.42,81.65 250.79,81.28 250.8,81.28 250.83,81.26 251.9,81.26 252.16,81.51 252.16,82.07 v1(252.53,82.44)
  BOTTOM w0.089: UV1.D5 227.23,81.87 v1(227.22,81.87) ; UV9.C13 252.19,82.1 v1(252.53,82.44)
FBB_EDC2: length 33.2
  IN1 w0.089: 230.88,87.05 230.6,87.05 230.59,87.06 230.06,87.06 228.94,85.95 228.94,83.18 228.79,83.03 v1(228.79,79.45)
  IN1 w0.094: v1(251.79,91.25) 251.39,91.65 248.03,91.65 247.23,90.84 243.59,90.84 243.44,90.99 242.95,90.99 242.42,90.46 238.22,90.46 234.81,87.05 230.88,87.05
  BOTTOM w0.089: v1(228.79,79.45) 228.75,79.45 UV1.C3 ; v1(251.79,91.25) UV9.R13
FBB_EDC3: length 19.6
  IN4 w0.094: v1(243,92.05) 242.64,92.41 239.69,92.41 236.39,89.11 234.81,89.11 233.22,87.52 233.22,85.34 v1(232.85,84.97)
  BOTTOM w0.089: UV9.R2 243.39,91.67 v1(243,92.05) ; 230.88,84.42 230.84,84.42 230.11,85.15 229.55,85.15 229.2,84.8 UV1.B9
  BOTTOM w0.127: 230.88,84.42 232.3,84.42 v1(232.85,84.97)
FBB_EDC4: length 20.5
  IN4 w0.094: v1(226.38,96.15) 226.72,96.49 227.38,96.49 228.19,95.67 230.31,95.67 230.94,96.3 235.85,96.3 238.56,99 240.76,99 241.41,99.65 242.58,99.65 242.99,100.06 v1(242.99,100.48)
  BOTTOM w0.089: UV1.E23 226.73,96.5 v1(226.38,96.15)
  BOTTOM w0.102: v1(242.99,100.48) UV10.C2
FBB_EDC5: length 33
  IN1 w0.094: v1(227.13,100.21) 227.5,99.83 228.91,99.83 230.49,98.25 233.36,98.25 238.21,103.1 240.39,103.1 240.77,103.47 242.29,103.47 242.89,104.07 246.31,104.07 248.2,102.19 248.2,100.38 248.86,99.72 250.2,99.72 250.56,100.08 252.23,100.08 v1(252.6,100.45)
  BOTTOM w0.089: UV1.E28 226.8,100.61 227.13,100.28 v1(227.13,100.21) ; v1(252.6,100.45) 252.23,100.08 UV10.C13
FBB_EDC6: length 29
  IN1 w0.094: v1(251.79,109.28) 251.39,109.68 250.83,109.68 250.52,109.99 247.72,109.99 245.59,112.11 239.35,112.11 231.32,104.08 229.86,104.08 229.61,103.83 v1(229.61,103.46)
  BOTTOM w0.089: v1(229.61,103.46) 229.6,103.45 229.6,103.01 229.2,102.61 UV1.B30
  BOTTOM w0.102: v1(251.79,109.28) UV10.R13
FBB_EDC7: length 22.9
  IN4 w0.094: v1(231.13,99.93) 231.4,99.66 232.6,99.66 232.9,99.96 232.9,101.06 235.01,103.16 235.01,104.98 237.45,107.43 239.86,107.43 241.71,109.29 243.78,109.29 v1(243.79,109.28)
  BOTTOM w0.089: UV10.R2 v1(243.79,109.28)
  BOTTOM w0.127: UV1.A23 230.7,97.2 230.7,97.21 231.13,97.63 v1(231.13,99.93)
FBB_SEN0: length 2.8
  TOP w0.089: v1(249.26,86.75) 249.26,86.85 v2(249.87,87.46) 250.45,88.04 RV379.2
  BOTTOM w0.089: UV9.J10 249.35,86.85 v1(249.26,86.75)
FBB_SEN2: length 2.2
  TOP w0.089: RV392.2 250.87,105.21 v1(250.15,104.49) v2(249.63,104.49)
  BOTTOM w0.132: v1(250.15,104.49) 249.79,104.86 UV10.J10
FBB_WCK01: length 33.9
  IN4 w0.107: v1(245.4,83.22) 245.53,83.09 246.18,83.09 246.8,82.47 246.8,80.85 245.74,79.79 239.75,79.79 237.29,77.33 227.33,77.33 226.48,78.18 226.48,78.98 226.93,79.43 226.93,80.2 227.8,81.06 227.8,81.91 226.72,82.99 226.04,82.99 225.72,83.31 225.72,83.45 v1(225.55,83.62)
  BOTTOM w0.089: v1(225.55,83.62) 225.93,84 UV1.F8 ; v1(245.4,83.22) 245.03,82.84 UV9.D4
FBB_WCK01#: length 33.8
  IN4 w0.107: v1(226.39,83.62) 226.22,83.8 226.05,83.8 225.94,83.7 225.94,83.4 226.13,83.21 226.81,83.21 228.03,82 228.03,80.97 227.16,80.1 227.16,79.34 226.7,78.88 226.7,78.27 227.42,77.55 237.2,77.55 239.66,80.02 245.64,80.02 246.57,80.94 246.57,82.38 246.09,82.86 245.58,82.86 245.4,82.68 v1(245.4,82.46)
  BOTTOM w0.089: v1(245.4,82.46) 245.4,82.7 245.54,82.84 UV9.D5 ; v1(226.39,83.62) 226.39,83.81 226.59,84 UV1.E8
FBB_WCK23: length 35.8
  BOTTOM w0.089: UV9.P4 245.47,91.33 246.38,91.33 246.67,91.04
  BOTTOM w0.114: 246.67,91.04 246.99,90.72 246.99,79.8 246.09,78.9 240.55,78.9 238.02,76.37 237.25,76.37 237.22,76.35 236.66,76.35 236.64,76.37 v9(234.91,76.37) 233.91,76.37 232.19,78.09 232.19,81.1 231.71,81.58 230.08,81.58 UV1.A5
FBB_WCK23#: length 35.7
  BOTTOM w0.089: 246.52,90.89 246.24,91.16 245.56,91.16 245.41,91.02 245.41,90.9 245.51,90.81 245.75,90.81 UV9.P5
  BOTTOM w0.114: 246.52,90.89 246.77,90.63 246.77,90.29 246.67,90.19 246.67,89.85 246.77,89.75 246.77,89.4 246.67,89.3 246.67,88.96 246.77,88.86 246.77,88.51 246.67,88.41 246.67,88.07 246.77,87.97 246.77,79.89 246,79.12 240.46,79.12 237.93,76.59 v9(236.94,76.59) 235.21,76.59 235.19,76.61 234.63,76.61 234.61,76.59 234,76.59 232.41,78.18 232.41,81.19 231.8,81.8 230.17,81.8 230,81.96 UV1.A6
FBB_WCK45: length 26.1
  IN1 w0.107: v1(227.19,97.77) 227.19,98 227.29,98.1 227.52,98.1 227.62,98 227.62,97.48 227.52,97.38 227.43,97.38 227.35,97.3 227.35,97.1 228.46,95.99 234.96,95.99 236.29,97.33 245.14,97.33 245.85,98.03 245.85,100.62 245.75,100.72 245.49,100.72 245.39,100.62 v1(245.39,100.45)
  BOTTOM w0.089: v1(227.19,97.77) 227.6,97.36 UV1.D24
  BOTTOM w0.102: UV10.D4 244.99,100.85 v1(245.39,100.45)
FBB_WCK45#: length 26
  IN1 w0.107: v1(246.24,100.45) 246.08,100.29 246.08,97.94 245.24,97.1 236.39,97.1 235.05,95.77 228.37,95.77 227.13,97.01 227.13,97.21 226.78,97.56 226.78,98.16 v1(227.19,98.57)
  BOTTOM w0.089: UV1.D25 227.57,98.18 227.57,98.19 v1(227.19,98.57)
  BOTTOM w0.102: UV10.D5 245.81,100.88 v1(246.24,100.45)
FBB_WCK67: length 30.8
  TOP w0.114: v1(245.39,109.28) 245.39,109.01 245.5,108.9 246.7,108.9 246.99,109.19 246.99,110.53 245.34,112.17 242.54,112.17 240.98,110.61 240.98,109.67 239.83,108.53 239.28,108.53 v1(238.84,108.08)
  BOTTOM w0.114: v1(245.39,109.28) UV10.P4 ; v1(238.84,108.08) 238.39,108.53 235.61,108.53 231.39,104.31 231.39,102.02 230.47,101.1 229.63,100.26 229.63,99.56 229.44,99.37 229.27,99.37 229.18,99.46 229.18,99.78 UV1.B27
FBB_WCK67#: length 30.8
  TOP w0.114: v1(238.84,108.74) 239.74,108.74 240.77,109.76 240.77,110.7 242.45,112.39 245.43,112.39 247.2,110.62 247.2,109.1 246.79,108.68 245.59,108.68 v1(245.39,108.48)
  BOTTOM w0.114: v1(238.84,108.74) 235.52,108.74 231.18,104.4 231.18,102.11 230.25,101.19 229.37,100.3 229.35,100.3 229.34,100.3 228.9,100.3 UV1.C27 ; UV10.P5 v1(245.39,108.48)
FBVREF_ALTV: length 134
  TOP w0.089: v1(213.6,126.53) 213.94,126.87 213.94,126.96
  TOP w0.102: QV22.2 229.88,118.09 v1(230.39,117.58) ; QV25.2 254.11,94.26 254.25,94.11 v1(254.82,94.11) ; QV23.2 213.94,126.96 ; QV24.2 v1(251.14,78.61)
  IN2 w0.089: 253.88,79.77 253.86,79.76
  IN2 w0.102: 253.86,79.76 253.43,79.32 251.9,79.32 251.19,78.61 v1(251.14,78.61) 251.14,76.08 249.32,74.26 237.26,74.26 235.93,72.93 232.83,72.93 231,74.76 223.19,74.76 222.87,74.44 221.08,74.44 v1(220.84,74.68) ; v1(254.82,94.11) 254.82,80.72 253.88,79.77
  IN4 w0.089: 214.03,126.96 v1(213.6,126.53)
  IN4 w0.102: v1(254.82,94.11) 254.82,97.14 254.9,97.21 254.9,103.9 253.91,104.88 253.91,111.09 253.62,111.39 252.39,111.39 250.91,112.86 247.81,112.86 246.72,113.95 231.48,113.95 230.39,115.04 v1(230.39,117.58) 230.39,118.37 229.63,119.13 229.63,125.56 228.16,127.03 217.9,127.03 217.9,127.03 214.11,127.03 214.03,126.96
  BOTTOM w0.089: UV1.L1 221.7,77.32
  BOTTOM w0.102: v8(230.34,116.72) 230.39,116.77 v1(230.39,117.58) ; 221.7,77.32 221.7,76.99 220.84,76.13 v1(220.84,74.68) RPH33.4
FDI_CSYNC: length 136.3
  TOP w0.089: v1(173.67,96.59) 174.47,96.59 174.66,96.79 v2(174.66,98.43) 174.66,99.58 172.75,101.49 v1(171.86,101.49)
  IN3 w0.089: 180.96,84.34 180.96,85.09 180.73,85.33 175.91,85.33 174.73,86.52 174.73,96.15 174.28,96.59 v1(173.67,96.59)
  IN3 w0.102: v1(262.02,37.4) 261.45,37.97 261.45,39.23 261.07,39.61 259.9,39.61 259.14,40.37 257.86,40.37 256.18,42.04 226.12,42.04 202.86,65.31 197.4,65.31 196.01,66.7 186.49,66.7 182.54,70.65 182.54,82.77 180.96,84.34
  BOTTOM w0.089: U6.F11 172.85,101.14 172.5,101.49 v1(171.86,101.49) ; U7.AL39 262.37,37.75 v1(262.02,37.4)
FDI_INT: length 132.1
  IN3 w0.089: 181.89,84.12 181.29,84.72 181.29,85.05 180.81,85.53 177.58,85.53 176.97,86.15 175.36,86.15 174.92,86.59 174.92,96.62 173.7,97.83 173.6,97.83 172.02,99.41 v1(172.02,100.69)
  IN3 w0.13: v1(262.02,37.98) 262.02,39.55 261.68,39.89 260.03,39.89 259.27,40.64 258.29,40.64 258.22,40.7 258.22,40.7 257.98,40.94 257.98,40.94 256.39,42.54 226.33,42.54 203.07,65.8 197.61,65.8 196.22,67.19 186.69,67.19 183.03,70.85 183.03,82.98 181.89,84.12
  BOTTOM w0.089: U6.F12 172.23,100.91 v1(172.02,100.69) ; v1(262.02,37.98) 262.27,38.24 262.46,38.24 U7.AL40
FFS_INT1: length 83.9
  TOP w0.102: UN2.11 231.02,63 RN33.2 232.27,62.57 v8(233.03,61.81) 233.46,61.38 233.46,49.44 237.3,45.6 237.3,35.89 238.12,35.06 238.12,30.17 238.44,29.85 v1(238.44,27.69)
  IN3 w0.089: v4(272.9,27.29) 271.75,27.29 271.22,26.76 269.28,26.76 269.02,26.5 269.02,23.49 267.71,22.17 260.87,22.17 260.64,22.41 258.46,22.41 257.16,23.72 257.16,25.05 255.33,26.87 254.47,26.87
  IN3 w0.102: v1(238.44,27.69) 239.26,26.87 254.47,26.87
  GND3 w0.089: v4(272.9,27.29) 272.91,27.29 272.81,27.39 v7(272.81,28.09)
  BOTTOM w0.102: U7.G17 272.81,28.49 v7(272.81,28.09)
FFS_INT2: length 81.2
  TOP w0.102: v1(234.71,20.41) 234.71,20.68 235.04,21.01 235.04,26.32 235.98,27.27 235.98,45.2 230.76,50.43 v8(230.76,52.03) 230.76,55.63 v1(230.04,56.35) 230.04,56.38 231.01,57.35 231.01,58.05 230.82,58.24 QN2.2 ; UN2.9 v1(230.06,62)
  IN4 w0.089: 254.47,25.46 255.2,25.46 255.37,25.29 255.37,24.97 255.5,24.84 256.27,24.84 257.3,23.81 258.35,23.81 258.96,23.2 258.96,22.89 259.24,22.61 259.69,22.61 259.97,22.9 261.4,22.9 v6(261.62,23.11)
  IN4 w0.102: v1(230.04,56.35) 230.04,61.98 v1(230.06,62) ; 254.47,25.46 250.13,25.46 245.07,20.41 241.29,20.41 240.63,19.74 235.37,19.74 v1(234.71,20.41)
  GND3 w0.089: v6(261.62,23.11) 261.62,22.65 v7(261.74,22.53)
  BOTTOM w0.089: U7.AN4 v7(261.74,22.53)
FFS_INT2_Q: length 282.4
  TOP w0.102: v3(234.57,12.59) 234.57,14.37 235.72,15.53 235.72,20.55 237.74,22.57 v2(237.74,25.45) 237.74,34.55 237.09,35.2 237.09,45.52 232.09,50.52 232.09,57.54 232.34,57.79 232.34,58.19 RN23.2 231.64,58.89 QN2.3
  GND1 w0.102: v4(234.99,12.24) 234.64,12.59 v3(234.57,12.59)
  IN2 w0.102: v4(234.99,12.24) 234.77,12.24 233.97,11.44 221.39,11.44 217,15.83 213.98,15.83 209.96,11.81 190.72,11.81 190.49,12.03 184.7,12.03 183.48,10.82 155.75,10.82 155.08,11.49 155.08,12.4 152.2,15.27 149.82,15.27 148.22,13.67 144.44,13.67 144.21,13.91 144.21,14.64 140.8,18.05 129.01,18.05 128.81,17.84 127.27,17.84 124.11,14.69 120.89,14.69 119.67,15.91 118.78,15.91 117.96,15.09 115.74,15.09 112.38,18.45 107.78,18.45 100.69,25.55 97.64,25.55 97.34,25.26 93.1,25.26 91.02,27.34 83.34,27.34 83.14,27.14 59.53,27.14 57.86,28.81 42.85,28.81 42.01,29.65 39.9,29.65 38.91,28.66 31.27,28.66 30.01,27.4 30.01,24.8 v1(29.13,23.92)
  BOTTOM w0.102: v1(29.13,23.92) 28.69,24.36 JHDD.18
GATEA20: length 126.5
  TOP w0.076: 168.39,14.45 168.41,14.43 168.78,14.43
  TOP w0.089: v1(261.1,25.08) 261.1,25.33 259.41,27.02 v2(258.53,27.02) 257.45,27.02 257.03,27.44 RH159.1 ; UE1.M2 167.53,14.91 167.93,14.91 168.39,14.45
  TOP w0.102: v3(169.1,14.28) 168.95,14.43 168.78,14.43
  GND1 w0.102: v4(169.14,13.86) 169.14,14.24 v3(169.1,14.28)
  IN1 w0.102: v4(230.23,24.65) 230.23,19.67 229.23,18.67 229.23,16.94 231.22,14.95 v4(231.22,13.88)
  IN2 w0.089: 254.47,22.65 254.52,22.61 255.43,22.61 255.51,22.69 257.22,22.69 257.26,22.64 260.09,22.64 260.5,23.06 260.5,24.48 v1(261.1,25.08)
  IN2 w0.102: 254.47,22.65 253.78,23.35 253.78,23.47 253.52,23.73 251.83,23.73 250.76,24.8 247.43,24.8 245.45,22.82 237.71,22.82 235.47,25.06 232.75,25.06 232.06,24.37 230.51,24.37 v4(230.23,24.65) ; v4(231.22,13.88) 230.59,14.51 227.76,14.51 226.74,13.49 225.67,13.49 224.88,14.28 224.52,14.28 220.26,18.55 213.83,18.55 210.93,15.65 208.21,15.65 207.8,16.07 205.28,16.07 204.98,16.37 203.41,16.37 202.6,15.57 201.8,15.57 201.48,15.88 199.39,15.88 199.21,15.7 187.76,15.7 187.5,15.44 185.4,15.44 183.64,13.68 172.23,13.68 171.44,12.9 170.65,12.9 169.7,13.86 v4(169.14,13.86)
  BOTTOM w0.102: U7.AN10 261.4,25.38 v1(261.1,25.08)
GPU_COMP: length 7.6
  TOP w0.254: v1(139.83,125.1) 140.04,124.88 PC825.2
  BOTTOM w0.102: PC824.2 138.29,126.1 138.47,126.27 138.75,126.27 138.95,126.47 138.95,127.8 v2(138.85,127.9)
  BOTTOM w0.254: PU800.12 139.84,123.69 139.57,123.96 139.57,124.85 v1(139.83,125.1) 139.06,125.87 PC824.2
GPU_EN: length 4.4
  TOP w0.102: v1(142.51,119.29) 142.51,118.93 v2(141.9,118.32)
  TOP w0.254: PC812.1 142.37,119.43 v1(142.51,119.29)
  BOTTOM w0.254: PU800.3 142.53,119.31 v1(142.51,119.29) 142.51,118.4 PR841.1
GPU_FB: length 124.4
  TOP w0.229: PR823.2 219.3,76.33 217.75,76.33 v1(217.28,76.8)
  TOP w0.254: PR825.2 v1(172.66,108.36)
  IN2 w0.254: v1(217.28,76.8) 215.72,76.8 213.14,79.37 197.88,79.37 192.99,84.26 192.99,89 190.03,91.96 184.33,91.96 182.69,93.6 182.69,102.16 177,107.86 173.16,107.86 v1(172.66,108.36) 172.65,108.37 148.71,108.37 144.95,112.12 140.2,112.12 139.25,113.07 139.25,115.85 139.53,116.13 139.53,117.27 136.72,120.08 136.72,122.8 v1(136.56,122.95)
  BOTTOM w0.254: PU800.11 139.57,123.19 138.79,123.96 PC821.2 137.39,124.86 PR824.1 135.66,124.86 135.1,124.31 135.1,123.44 135.6,122.95 v1(136.56,122.95)
GPU_FBRTN: length 118.3
  TOP w0.229: 217.6,77.38 218.21,76.77 v2(218.65,76.77) PR818.2
  TOP w0.254: v1(173.57,108.39) 173.57,109.15 PR819.2 ; v1(217.31,77.38) 217.6,77.38
  IN2 w0.254: v1(217.31,77.38) 217.03,77.38 216.9,77.25 215.76,77.25 213.29,79.73 198.03,79.73 193.34,84.41 193.34,89.15 190.09,92.41 184.39,92.41 183.1,93.7 183.1,102.37 177.07,108.39 v1(173.57,108.39) 173.09,108.87 148.71,108.87 145.1,112.48 140.35,112.48 139.61,113.22 139.61,115.7 139.89,115.98 139.89,117.41 137.1,120.21 137.1,122.87 v1(137.2,122.97)
  BOTTOM w0.254: v1(137.2,122.97) 137.43,122.74 138.91,122.74 138.96,122.69 PU800.10
GPU_GPIO2: length 4
  TOP w0.089: RPH12.1 220.5,79.63 220.85,79.98 220.85,80.85 v3(221.04,81.03) 221.25,81.03 v2(221.5,80.78)
  GND1 w0.089: v3(221.04,81.03) v4(221.35,81.34)
  GND3 w0.089: v4(221.35,81.34) v7(221.35,81.8)
  BOTTOM w0.089: v7(221.35,81.8) 221.35,81.9 UV1.L6
GPU_GPIO3: length 2.6
  TOP w0.089: RPH12.2 220.08,79.43 v2(220.08,80.67) 220.08,80.84 219.89,81.03 v1(219.64,81.03)
  BOTTOM w0.089: UV1.P5 219.57,81.03 v1(219.64,81.03)
GPU_GPIO4: length 4.7
  TOP w0.089: v3(219.27,82.18) 218.91,81.81 v2(218.91,81.21) 218.91,80.82 219.5,80.23 RPH12.3
  GND1 w0.089: v3(219.27,82.18) 219.27,82.55 v4(219.24,82.58)
  GND3 w0.089: v4(219.24,82.58) 219.51,82.58 v7(219.63,82.7)
  BOTTOM w0.089: v7(219.63,82.7) 219.23,83.1 UV1.P7
GPU_GPIO7: length 6.9
  TOP w0.089: v3(218.79,82.15) 218.76,82.17 217.97,82.17 v2(217.87,82.08) 217.87,81.23 219,80.1 RPH12.4
  GND1 w0.089: v3(218.79,82.15) v4(218.79,82.91)
  GND3 w0.089: v4(218.79,82.91) 218.82,82.95 v7(218.82,83.52)
  BOTTOM w0.089: UV1.N8 219.67,83.52 v7(218.82,83.52)
GPU_GPIO13: length 16.2
  TOP w0.102: v1(221.27,73.22) 221.68,72.81 221.68,71.45 220.65,70.43 v2(217.24,70.43) 216.1,70.43 RV10.1
  IN1 w0.102: v1(220.47,80.21) 220.47,75.69 221.37,74.78 221.37,73.32 v1(221.27,73.22)
  BOTTOM w0.102: v1(220.47,80.21) 220.86,80.6 220.9,80.6 UV1.M4
GPU_HOT#: length 103
  TOP w0.102: v1(152.04,16.34) 151.8,16.1 v2(151.41,16.1) 150.27,16.1 149.83,16.53 149.83,18.13 149.79,18.17 149.4,18.17 149.29,18.05 UE36.2 ; v1(213.68,52.46) 214.56,53.35 216.53,53.35 217.55,54.36 217.55,57.35 218.12,57.92 219.2,57.92 219.38,57.74 QV42.6
  IN4 w0.102: v1(153.15,22.64) 154.63,24.12 177.14,24.12 182.79,29.78 182.79,38.82 186.97,43 201.83,43 211.29,52.46 v1(213.68,52.46)
  BOTTOM w0.102: v1(153.15,22.64) 151.19,20.68 150.6,20.68 149.92,20.01 149.92,17.98 151.56,16.34 v1(152.04,16.34)
GPU_HOT#_R: length 37.6
  TOP w0.102: v1(220.03,56.33) 219.38,55.68 QV42.1 v2(219.38,54.31)
  IN2 w0.102: v1(220.03,56.33) 220.03,57.79 227.9,65.67 227.9,68.27 227.46,68.71 226.12,68.71 224.79,70.05 224.15,70.05 221.55,72.65 219.9,72.65 v1(218.93,71.69)
  BOTTOM w0.102: v1(218.93,71.69) 218.93,73.16 219.34,73.57 RPH33.1 219.34,75.01 219.42,75.09 219.42,76.23 220.15,76.97 220.15,78.56 220.51,78.91 220.51,79.34 UV1.N3
GPU_JTAG_TCK: length 4.9
  BOTTOM w0.102: UV1.AM10 204.2,85.33 203.82,84.95 203.82,84.62 203.59,84.4 202.41,84.4 201.39,83.38 T174.1
GPU_JTAG_TDI: length 7.6
  BOTTOM w0.102: T11.1 199.35,82.54 199.35,83.32 199.78,83.75 201.07,83.75 202.51,85.2 203.59,85.2 203.82,85.42 203.82,86.12 UV1.AM11
GPU_JTAG_TDO: length 5.1
  BOTTOM w0.102: T12.1 199.45,84.56 200.82,84.56 202.18,85.92 202.18,86.58 202.6,87 UV1.AP12
GPU_JTAG_TMS: length 6.9
  BOTTOM w0.102: T13.1 198.61,84.79 199.05,84.36 201.03,84.36 202.39,85.72 202.39,86.29 UV1.AP11
GPU_JTAG_TRST#: length 8.2
  BOTTOM w0.102: v8(197.62,81.82) 197.62,81.87 198.89,83.14 RV324.1 199.27,84.08 201.07,84.08 202.6,85.61 202.6,85.87 203.23,86.5 UV1.AN11
GPU_PGOOD: length 2.3
  BOTTOM w0.254: PU800.16 142.53,126.68 PR842.1
GPU_PSI: length 107.8
  TOP w0.102: v1(214.88,69.29) 215.31,69.72 RV10.2
  IN1 w0.102: v1(214.88,69.29) 213.84,70.33 208.06,70.33 205.61,72.78 205.61,74.94 203.8,76.75 203.8,80.45 203.26,80.98 199.59,80.98 197.95,82.62 197.79,82.62 193.08,87.33 193.08,88.73 191.85,89.95 187.65,89.95 186.55,91.06 186.55,101.88 179.58,108.86 176.65,108.86 174.14,111.37 151.74,111.37 144.78,118.32 142.44,118.32 v1(141.82,118.94)
  BOTTOM w0.254: PR803.2 v1(141.82,118.94) 141.82,119.44 142.03,119.65 PU800.4
GPU_PVCC: length 3.1
  BOTTOM w0.102: v2(149.06,124.29) 148.42,124.93 147.15,124.93 146.53,124.31 PR821.1
GPU_REFADJ: length 4.2
  BOTTOM w0.102: PR809.2 139.81,118.2 139.41,118.6 139.41,119.21 v2(139.33,119.29)
  BOTTOM w0.254: PR809.2 140.02,119.06 141.03,120.07 PU800.6
GPU_REFIN: length 5.5
  TOP w0.102: v2(140.21,118.87) 140.07,119.01 PR812.1
  TOP w0.254: PC810.1 PR812.1 139.76,120.02 v1(139.27,120.52)
  BOTTOM w0.254: PU800.7 139.94,121.19 v1(139.27,120.52) 139.11,120.36 PR807.1
GPU_TESTMODE: length 14.2
  BOTTOM w0.102: v8(199.02,78.14) RV320.2 RV323.1 199.57,80.21 200.42,81.06 204.43,81.06 204.61,81.24 204.61,83.51 204.74,83.64 205.1,83.64 205.38,83.92 205.38,86.29 205.6,86.5 UV1.AK11
GPU_TON: length 2.3
  BOTTOM w0.254: PU800.9 v2(139.05,122.19) 138.29,122.19 PR817.2
GPU_VDD_SENSE: length 6.1
  TOP w0.254: v1(222.18,80.21) 222.15,80.17 v2(222.15,78.09) 221.82,77.75 221.82,76.2 221.45,75.83 PR823.1
  BOTTOM w0.254: UV1.L4 221.79,80.6 v1(222.18,80.21)
GPU_VID: length 2.5
  BOTTOM w0.254: PR836.2 v2(140.91,119.18) 140.91,119.39 141.53,120.01 PU800.5
GPU_VID_0: length 108.1
  IN2 w0.102: v4(220.34,81.41) 220.01,81.75 218.98,81.75 218.58,81.34 207.99,81.34 207.78,81.54 198.69,81.54 194.52,85.71 194.52,89.34 190.7,93.17 186.02,93.17 184.06,95.13 184.06,103.82 178.35,109.54 150.85,109.54 146.1,114.28 142.19,114.28 v1(141.54,114.93)
  GND3 w0.089: v4(220.34,81.41) 220.6,81.67 v7(220.6,81.89)
  BOTTOM w0.102: v2(137.27,116.77) 137.45,116.59 140.19,116.59 140.88,117.28 PR836.1 ; v7(220.6,81.89) 220.9,81.59 UV1.M5
  BOTTOM w0.254: PR836.1 140.91,115.56 v1(141.54,114.93)
GPU_VREF: length 4.1
  TOP w0.102: v2(138.43,121.48) 138.49,121.42 v1(139.25,121.42)
  TOP w0.508: PC807.1 139.89,122.06 v1(139.25,121.42)
  BOTTOM w0.254: PU800.8 139.52,121.69 v1(139.25,121.42) 139.13,121.3 PR804.1
GPU_VSS_SENSE: length 5.4
  TOP w0.254: v1(222.1,81) 222.1,80.81 221.69,80.4 v2(221.69,79.36) 221.69,78.86 221.35,78.52 221.35,77.38 220.74,76.77 PR818.1
  BOTTOM w0.254: UV1.L5 221.7,81.4 v1(222.1,81)
H_CPU_SVIDALRT#: length 4.5
  BOTTOM w0.089: 143.53,99.86 143.43,99.96 142.17,99.96
  BOTTOM w0.102: U6.J53 144.58,99.19 144.2,99.19 143.53,99.86 ; RU93.2 v2(141.97,99.96) 142.17,99.96
H_CPUPWRGD: length 205.2
  TOP w0.089: v8(147.27,100.12) 147.48,100.34 147.48,101.11 v1(147.1,101.5)
  TOP w0.102: RU7.1 144.29,110.65 v1(144.51,110.88)
  IN1 w0.076: v4(259.59,21.34) 257.11,23.82 254.63,23.82 254.34,24.11 252.09,24.11 248.58,27.63 248.58,28.35 247.23,29.69 247.23,30.7 247.89,31.37 247.89,39.45 235.9,51.45 235.9,51.89 v4(235.01,52.78) ; v1(141.91,101.84) 142.82,102.75 144.31,102.75 144.92,102.14 146.37,102.14 147.01,101.5 v1(147.1,101.5)
  IN3 w0.13: v1(147.1,101.5) 146.71,101.89 144.87,101.89 143.27,103.49 143.27,105.2 143.65,105.58 143.65,110.02 v1(144.51,110.88) 153.89,110.88 156.86,107.91 159.29,107.91 159.55,108.17 163.65,108.17 164.11,107.71 176.88,107.71 180.86,103.73 180.86,100.24 183.57,97.52 183.57,88.35 186.86,85.06 186.86,72.44 188.28,71.02 205.94,71.02 213.88,63.08 213.88,62.42 219.33,56.97 219.99,56.97 223.78,53.17 233.78,53.17 233.89,53.07 234.72,53.07 v4(235.01,52.78)
  GND3 w0.089: v7(259.29,21.72) 259.59,21.43 v4(259.59,21.34)
  BOTTOM w0.089: U6.F50 147.45,101.14 v1(147.1,101.5) ; U7.AV3 259.71,22.08 259.35,21.72 v7(259.29,21.72)
  BOTTOM w0.102: v1(141.91,101.84) 141.49,101.84 140.89,102.43 136.19,102.43 RU33.2
H_CPUPWRGD_XDP: length 5.2
  TOP w0.102: JXDP.39 141.61,107.55 141.81,107.74 141.81,108.44 142.35,108.99 v2(142.35,109.51) 142.74,109.89 RU7.2
H_DRAMRST#: length 8.1
  BOTTOM w0.089: 146.09,71.38 146.09,74.37 U6.BE51
  BOTTOM w0.102: 146.09,71.38 v2(146.09,70.34) 146.09,70.04 145.39,69.34 RU74.1 144.54,69.51 QU3.3
H_PECI: length 126.9
  GND1 w0.102: v3(164.78,11.68) 165.05,11.68 v5(165.14,11.77)
  IN1 w0.076: v5(165.14,11.77) 158.71,11.77 157.52,12.97 157.29,12.97 155.66,14.6 155.66,15.49 153.14,18.02 149.27,18.02 147.51,19.77 146.8,19.77 145.85,20.72 145.85,23.56 143.19,26.22 143.19,31.43 142.74,31.88 139.05,31.88 137.26,33.67 137.26,44.49 133.91,47.85 133.91,67.62 132.43,69.11 132.43,70.73 134.67,72.97 134.67,80.12 135.27,80.72 135.27,84.68 134.24,85.71 134.24,92.4 139.57,97.73 139.57,100.78 138.48,101.87 v1(138.03,101.87)
  BOTTOM w0.089: U6.G51 146.32,100.73 144.16,100.73 143.95,100.53 142.99,100.53
  BOTTOM w0.102: v1(138.03,101.87) v2(139.48,101.87) 140.66,101.87 141.26,101.28 142.24,101.28 142.99,100.53
H_PM_SYNC: length 179.5
  IN1 w0.076: v4(234.3,52.51) 247.03,39.78 247.03,37.06 247.51,36.57 247.51,31.53 246.85,30.86 246.85,29.54 247.58,28.8 247.58,28.08 251.95,23.72 254.19,23.72 254.54,23.38 257.11,23.38 258.76,21.72 v4(258.76,21.33)
  IN3 w0.13: v1(144.46,104.73) 145.07,105.34 145.07,106.28 146.19,107.4 159.5,107.4 159.76,107.66 163.44,107.66 163.9,107.2 175.18,107.2 177.38,104.99 178.88,104.99 180.25,103.62 180.25,98.05 183.06,95.24 183.06,88.14 186.35,84.85 186.35,72.23 188.07,70.51 205.73,70.51 213.33,62.9 213.33,62.25 222.92,52.66 233.57,52.66 233.73,52.51 v4(234.3,52.51)
  GND3 w0.089: v4(258.76,21.33) 258.76,21.95 v7(258.89,22.08)
  BOTTOM w0.089: U7.AY3 258.9,22.09 v7(258.89,22.08) ; v1(144.46,104.73) 144.82,105.09 145.29,105.09 145.48,104.9 145.48,102.89 145.87,102.49 U6.D52
H_PROCHOT#: length 277.9
  TOP w0.102: PR726.2 124.73,122.67 v1(124.2,123.2)
  IN1 w0.076: v1(138.05,103.7) 139.13,103.7 141.16,101.67 141.16,95.82 136.54,91.2 v1(136.54,85.86) 136.54,85.78 136.94,85.38 136.94,65.08 136.55,64.69 136.55,54.97 147.9,43.62 147.9,26.85 149.19,25.56 149.19,24.33 150.7,22.82 150.7,21.73 151.59,20.85 154.91,20.85 v1(155.08,20.68)
  IN2 w0.102: v1(136.54,85.86) 134.9,87.5 134.9,88.31 134.18,89.03 134.18,93.28 132.6,94.86 132.6,98.2 131.86,98.94 131.86,106.51 132.22,106.87 132.22,108.81 132.12,108.92 132.12,111.82 131.34,112.6 131.34,113.76 131.8,114.22 131.8,119.39 129.33,121.86 125.47,121.86
  IN2 w0.13: v1(124.2,123.2) 125.21,122.2 125.21,122.13 125.47,121.86
  IN4 w0.076: v1(59.01,32.86) 59.43,33.28 59.88,33.28 60.76,32.41 74.69,32.41 75.4,31.69 86.39,31.69 87.37,32.67 92.24,32.67 93.01,31.9 100.29,31.9 110.97,21.21 117.79,21.21 118.15,20.86 122.12,20.86 122.61,21.35 128.39,21.35 128.78,20.96 148.56,20.96 149.04,20.47 154.86,20.47 v1(155.08,20.68)
  BOTTOM w0.102: PQ231.3 49.36,36.11 50.62,37.37 50.62,38.48 51.51,39.37 53.27,39.37 53.78,38.86 53.78,38.08 55.78,36.09 PQ230.1 58,35.24 57.82,35.06 56.81,35.06 56.65,34.91 56.65,33.56 57.57,32.65 58.79,32.65 v1(59.01,32.86) ; RU32.1 138.05,103.21 v1(138.05,103.7) 136.7,103.7 RU30.2 ; UE2.4 154.64,19.01 154.81,19.18 154.81,19.64 CE21.1 154.38,20.67 154.55,20.85 154.91,20.85 v1(155.08,20.68) ; v1(124.2,123.2) 124.78,122.62 PC710.1 PR722.1
H_PROCHOT#_EC: length 118.4
  TOP w0.089: 163.53,14.49 163.53,14.91 UE1.E2
  TOP w0.102: 163.53,14.49 163.44,14.4 163.44,13.33 v1(163.47,13.29)
  IN4 w0.076: v1(59.6,32.86) 60.44,32.02 71.71,32.02 72.42,31.31 86.55,31.31 87.53,32.29 92.08,32.29 92.86,31.52 100.13,31.52 110.81,20.83 117.57,20.83 117.92,20.48 122.28,20.48 122.76,20.97 128.23,20.97 128.62,20.57 148.4,20.57 149.16,19.81 v1(150.46,19.81)
  BOTTOM w0.102: PR290.1 59.88,33.14 v1(59.6,32.86) ; v1(163.47,13.29) 163.09,12.91 162.39,12.91 161.17,14.13 159.93,14.13 159.33,13.53 157.53,13.53 157.11,13.95 157.11,14.84 156.41,15.53 154.72,15.53 153.29,16.96 153.29,17.98 152.91,18.36 UE2.2 152,18.36 151.93,18.28 RE42.1 150.46,18.95 v1(150.46,19.81)
H_PROCHOT#_R: length 9.2
  BOTTOM w0.089: U6.E50 147.45,101.84 147.16,102.13 144.19,102.13 143.32,103 142.21,103
  BOTTOM w0.102: 142.21,103 142.18,102.98 v2(140.4,102.98) 138.78,102.98 RU32.2
H_THERMTRIP#: length 177.1
  IN1 w0.076: v4(234.31,51.89) 234.38,51.89 246.65,39.63 246.65,36.9 247.13,36.41 247.13,31.84 246.36,31.07 246.36,29.49 247.2,28.64 247.2,23.91 251.98,19.14 251.98,18.8 253.07,17.72 v4(253.21,17.72)
  IN3 w0.13: v1(143.67,103.67) 143.99,104 144.99,104 145.63,104.63 145.63,106.12 146.4,106.89 159.72,106.89 159.97,107.15 163.23,107.15 163.69,106.69 174.96,106.69 177.44,104.22 178.93,104.22 179.64,103.51 179.64,94.85 182.48,92.01 182.48,87.99 185.84,84.64 185.84,72.02 187.86,70 197.88,70 199.2,68.68 201.19,68.68 202.12,69.6 205.91,69.6 212.82,62.69 212.82,62.04 222.71,52.15 233.16,52.15 233.42,51.89 v4(234.31,51.89)
  GND3 w0.102: v7(253.36,17.39) 253.21,17.54 v4(253.21,17.72)
  BOTTOM w0.089: v1(143.67,103.67) 143.67,103.35 144.19,102.83 144.73,102.83 U6.D53
H_THERMTRIP#_C: length 8.5
  BOTTOM w0.089: 259.77,21.03 259.77,21.6 U7.AV1
  BOTTOM w0.102: 259.77,21.03 259.77,20.5 v2(259.54,20.26) 259.31,20.04 257.67,20.04 256.86,19.23 255.17,19.23 RU45.2 RH162.1
HDA_BIT_CLK: length 5.4
  TOP w0.089: v1(277.02,34.09) 277.14,33.97
  TOP w0.102: RH5.2 CH1.2 277.27,33.85 277.14,33.97
  BOTTOM w0.089: U7.B25 274.77,31.9 275.24,31.9 275.76,32.43 275.76,32.8 276.15,33.19 276.15,33.21 276.17,33.23 276.17,33.45 276.82,34.09 v1(277.02,34.09)
HDA_BITCLK_5505: length 30
  TOP w0.102: U12.23 16.67,30.12 16.8,30.25 16.8,30.51 17.32,31.03 v1(17.44,31.03) 17.44,31.49 RA67.2 17.18,32.14 17.18,33.08 RA76.1 ; RA26.1 31.28,39.91 31.28,38.17 v1(31.54,37.91)
  IN3 w0.102: v1(31.54,37.91) 31.54,37.33 31.43,37.23 30.64,37.23 30.54,37.13 30.54,36.93 30.64,36.82 31.43,36.82 31.54,36.72 31.54,36.44 31.13,36.03 30.98,36.03 30.63,36.38 30.49,36.38 30.35,36.23 30.35,36.09 30.7,35.74 30.7,35.6 29.02,33.92 26.79,33.92 24.49,31.63 20.76,31.63 19.11,29.98 17.16,29.98 16.98,30.16 16.98,30.57 v1(17.44,31.03)
HDA_BITCLK_5505_R: length 11.5
  GND1 w0.102: v3(17.64,32.6) v5(17.64,32.19) ; v3(25.28,25.66) 24.83,25.66 v5(24.8,25.69)
  IN1 w0.102: v5(17.64,32.19) 18.5,31.33 20.28,31.33 20.64,30.97 20.64,30.16 23.81,26.98 23.94,26.98 24.8,26.12 v5(24.8,25.69)
HDA_BITCLK_AUDIO: length 311.2
  TOP w0.102: U12.6 22.95,25.73 v1(23.53,26.31) 23.73,26.31 RA50.1 24.37,25.23 24.93,24.67 v2(25.08,24.67) 25.26,24.67 26.38,25.79 RA89.1 ; v3(279.56,34.76) RH5.1
  GND1 w0.102: v4(279.65,34.27) 279.65,34.7 279.59,34.76 v3(279.56,34.76)
  IN3 w0.13: v4(279.65,34.27) 280.26,34.27 280.45,34.46 280.96,34.46 281.2,34.22 281.2,33.22 280.96,32.98 280.64,32.98 280.48,32.81 280.48,32 281.9,30.58 281.9,17.73 280.13,15.97 271.5,15.97 270.3,14.76 266.86,14.76 266.05,13.95 264.26,13.95 263.45,14.76 260.26,14.76 260.01,15.01 259.07,15.01 258.78,15.3 246.06,15.3 245.1,16.25 241.75,16.25 240.56,17.45 236.64,17.45 235.92,16.72 228.42,16.72 227.76,17.39 222.22,17.39 221.26,18.34 219.39,18.34 218.85,18.88 214.34,18.88 212.36,16.91 207.92,16.91 207.19,17.63 203.67,17.63 203.33,17.3 197.89,17.3 193.88,21.3 193.88,22.02 193.5,22.4 193.16,22.4 192.2,23.36 190.37,23.36 189.97,22.95 188.6,22.95 187.8,23.74 184.39,23.74 183.8,24.34 180.15,24.34 175.48,29 173.01,29 168.01,34 166.06,34 164.94,35.12 111.21,35.12 110.01,33.92 106.36,33.92 105.41,32.97 77.32,32.97 76.4,32.04 74.51,32.04 73.96,31.49 71.94,31.49 71.44,31.99 66.32,31.99 65.93,32.38 61.15,32.38 59.85,33.68 52.43,33.68 50.95,35.17 46.41,35.17 42.08,39.5 37.35,39.5 30.24,32.39 30.24,27.94 29.5,27.19 24.42,27.19 v1(23.53,26.31)
HDA_BITCLK_R: length 3.6
  TOP w0.102: RA26.2 CA39.2 30.3,41.17 v2(29.65,41.17) 29.63,41.19 U15.5
HDA_RST#: length 4.2
  TOP w0.089: 277.14,32.84 v1(277.13,32.84)
  TOP w0.102: 277.14,32.84 277.79,32.84 RH6.2
  BOTTOM w0.089: v1(277.13,32.84) 277.13,32.8 v2(276.58,32.25) 275.96,31.64 275.28,31.64 275.24,31.67 274.99,31.67 274.69,31.37 U7.C24
HDA_RST_5505: length 28.7
  TOP w0.102: U15.6 28.6,41.59 28.77,41.42 29.36,41.42 29.47,41.53 29.47,41.83 29.59,41.96 29.99,41.96 30.11,41.83 v1(30.11,41.72) ; RA66.2 19.67,31 19.25,31 v1(19.17,30.92) U12.18
  IN3 w0.102: v1(30.11,41.72) 30.47,41.36 30.47,40.84 30.57,40.74 30.97,40.74 31.08,40.64 31.08,40.44 30.97,40.34 30.57,40.34 30.47,40.23 30.47,40.03 30.57,39.93 30.97,39.93 31.08,39.83 31.08,39.63 30.97,39.52 30.57,39.52 30.47,39.42 30.47,39.22 30.57,39.12 30.97,39.12 31.08,39.02 31.08,38.81 30.97,38.71 30.57,38.71 30.47,38.61 30.47,37.98 29.93,37.44 29.93,35.4 28.85,34.33 26.62,34.33 24.33,32.04 20.38,32.04 19.26,30.92 v1(19.17,30.92)
  BOTTOM w0.102: v2(30.77,41.44) 30.49,41.72 v1(30.11,41.72)
