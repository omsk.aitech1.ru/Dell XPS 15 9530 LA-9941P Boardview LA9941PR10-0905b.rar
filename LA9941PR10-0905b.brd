# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA12: length 100.9
  IN3 w0.089: 157.41,71.25 157.61,71.45 157.61,75.92 158.25,76.56 158.25,77.72 157.67,78.3 157.67,78.89 v1(158.06,79.28)
  IN3 w0.196: v1(208.59,30.59) 209.24,31.24 209.24,32.86 206.26,35.85 206.26,38.87 205.96,39.17 205.68,39.17 205.37,38.86 205.1,38.86 204.82,39.13 204.82,39.41 205.13,39.72 205.13,40 204.85,40.28 204.58,40.28 203.93,39.63 203.66,39.63 203.38,39.91 203.38,40.18 204.03,40.83 204.03,41.11 203.75,41.38 203.47,41.38 202.83,40.74 202.55,40.74 202.27,41.01 202.27,41.29 202.92,41.94 202.92,42.21 202.64,42.49 202.37,42.49 201.72,41.84 201.44,41.84 200.44,42.85 179.65,42.85 172.36,50.13 164.48,50.13 156.54,58.07 156.54,69.55 157.37,70.38 157.37,71.2 157.41,71.25
  BOTTOM w0.089: U6.AW35 157.74,78.96 v1(158.06,79.28)
  BOTTOM w0.16: v1(208.59,30.59) 209.88,31.88 209.88,32.98 210.4,33.5 JDIMM2.83
DDR_B_MA13: length 102.6
  IN3 w0.089: v1(167.46,80.68) 167.84,80.31 167.84,79.43 167.7,79.29 167.2,79.29 166.9,78.99 166.9,77.49 167.13,77.25 167.9,77.25 168.03,77.13 168.5,77.13 169.25,76.38 169.75,76.38 170.43,75.7 170.57,75.7
  IN3 w0.196: v1(222.2,38.04) 222.66,38.49 222.66,39.1 202.38,59.37 195.84,59.37 195.65,59.57 195.65,60.44 195.45,60.64 195.06,60.64 194.86,60.44 194.86,59.57 194.67,59.37 194.27,59.37 194.07,59.57 194.07,61.3 193.88,61.49 193.49,61.49 193.29,61.3 193.29,59.57 193.1,59.37 192.7,59.37 192.51,59.57 192.51,61.3 192.31,61.49 191.92,61.49 191.73,61.3 191.73,59.57 191.53,59.37 191.14,59.37 190.94,59.57 190.94,61.3 190.75,61.49 190.36,61.49 190.16,61.3 190.16,59.57 189.97,59.37 189.58,59.37 189.38,59.57 189.38,61.3 189.18,61.49 188.79,61.49 188.6,61.3 188.6,59.57 188.4,59.37 188.01,59.37 187.82,59.57 187.82,61.3 187.62,61.49 180.11,61.49 171.54,70.05 171.54,72.46 171.38,72.62 171.38,74.89 170.57,75.7
  BOTTOM w0.089: U6.AU20 167.14,80.36 v1(167.46,80.68)
  BOTTOM w0.16: JDIMM2.119 221.2,37.04 v1(222.2,38.04)
DDR_B_MA14: length 101.7
  IN3 w0.089: 156.02,73.03 156.02,75.04 157.82,76.84 157.82,77.48 157.24,78.06 157.06,78.06 156.72,78.41 156.72,78.87 v1(157.12,79.28)
  IN3 w0.196: v1(208.59,29.06) 207.32,30.33 207.32,32.86 206.39,33.79 205.67,33.79 202.96,36.5 202.96,38.48 199.9,41.54 179.11,41.54 171.82,48.83 163.94,48.83 149.12,63.65 149.12,66.35 151.25,68.49 153.63,68.49 155.81,70.67 155.81,72.83 156.02,73.03
  BOTTOM w0.089: U6.AW36 156.8,78.96 v1(157.12,79.28)
  BOTTOM w0.16: v1(208.59,29.06) 209.5,28.15 JDIMM2.80
DDR_B_MA15: length 99.4
  IN3 w0.089: 155.08,75.78 155.7,75.78 v1(157.18,77.26)
  IN3 w0.196: 155.08,75.78 154.39,75.09 154.39,71.09 153.09,69.79 150.71,69.79 147.81,66.89 147.81,63.11 163.39,47.52 171.28,47.52 178.57,40.24 198.64,40.24 201.12,37.75 201.12,35.53 206.06,30.59 v1(206.66,30.59)
  BOTTOM w0.089: U6.BA35 157.48,77.56 v1(157.18,77.26)
  BOTTOM w0.16: v1(206.66,30.59) 207.61,29.64 207.61,28.23 208.9,26.94 JDIMM2.78
DDR_B_RAS#: length 105
  IN3 w0.089: 166.83,74.9 166.83,75.97 165.02,77.78 165.02,79.68 165.38,80.04 v1(165.58,80.04)
  IN3 w0.196: 166.83,74.9 166.83,74.11 167.4,73.54 167.4,66.52 167.66,66.25 168.16,66.25 168.39,66.48 168.39,67.8 168.62,68.03 168.95,68.03 169.46,67.52 169.46,67.25 169.24,67.03 169.24,66.75 169.52,66.47 169.79,66.47 170.01,66.69 170.29,66.69 170.56,66.42 170.56,66.14 170.35,65.92 170.35,65.64 170.62,65.37 170.9,65.37 171.12,65.59 171.39,65.59 171.67,65.31 171.67,65.03 171.45,64.81 171.45,64.54 171.73,64.26 172,64.26 172.22,64.48 172.5,64.48 172.78,64.2 172.78,63.93 172.56,63.71 172.56,63.43 172.84,63.15 173.11,63.15 173.33,63.37 173.61,63.37 173.88,63.1 173.88,62.82 173.66,62.6 173.66,62.32 180.53,55.46 180.53,54.28 181.51,53.3 203.83,53.3 216.75,40.39 216.75,36.92 217.72,35.95 217.72,35.05 217.92,34.85 220.16,34.85 220.36,34.66 220.36,34.23 220.16,34.03 219.26,34.03 219.07,33.84 219.07,33.17 219.26,32.98 219.41,32.98 219.61,32.78 219.61,32.39 219.41,32.19 219.16,32.19 218.96,32 218.96,31.61 219.16,31.41 219.68,31.41 219.88,31.22 219.88,30.83 219.68,30.63 219.28,30.63 219.08,30.43 219.08,30.04 219.28,29.85 219.44,29.85 219.63,29.65 219.63,29.26 219.44,29.06 v1(218.45,29.06)
  BOTTOM w0.089: U6.AV23 165.19,79.66 v1(165.58,80.04)
  BOTTOM w0.16: JDIMM2.110 218.5,27.7 218.91,28.11 218.91,28.6 v1(218.45,29.06)
DDR_B_WE#: length 103
  IN3 w0.089: v1(165.58,79.28) 165.96,78.91 165.96,77.71 167.5,76.17 168.16,76.17 169.07,75.26 169.07,74.28 169.66,73.69
  IN3 w0.196: v1(220.18,38.04) 220.64,38.49 220.64,39.27 204.65,55.26 202.73,55.26 202.53,55.45 202.53,55.98 202.34,56.18 201.95,56.18 201.75,55.98 201.75,55.45 201.55,55.26 201.16,55.26 200.97,55.45 200.97,57.87 200.77,58.06 200.38,58.06 200.19,57.87 200.19,55.45 199.99,55.26 199.55,55.26 199.35,55.45 199.35,57.87 199.15,58.06 198.76,58.06 198.57,57.87 198.57,55.45 198.37,55.26 197.98,55.26 197.79,55.45 197.79,57.87 197.59,58.06 197.2,58.06 197,57.87 197,55.45 196.81,55.26 196.42,55.26 196.22,55.45 196.22,57.87 196.03,58.06 195.63,58.06 195.44,57.87 195.44,56.29 195.24,56.1 194.85,56.1 194.66,56.29 194.66,57.87 194.46,58.06 181.69,58.06 170.21,69.54 170.21,72.32 169.66,72.87 169.66,73.69
  BOTTOM w0.089: U6.AW23 165.26,78.96 v1(165.58,79.28)
  BOTTOM w0.16: v1(220.18,38.04) 219.24,37.1 219.24,35.3 219.4,35.14 JDIMM2.113
DDR_CKE0_DIMMA: length 61.3
  IN4 w0.117: v1(157.1,73.08) 154.45,70.44 150.87,70.44 147.51,67.07 147.51,58.69 133.71,44.89 133.71,33.27 133.59,33.14 132.59,33.14 132.46,33.27 132.46,36.54 132.36,36.64 v1(132.04,36.64)
  BOTTOM w0.089: U6.BE34 157.35,74.42 157.35,73.33 v1(157.1,73.08)
  BOTTOM w0.16: v1(132.04,36.64) 132.9,35.79 JDIMM1.73
DDR_CKE1_DIMMA: length 61.1
  IN4 w0.117: v1(133.72,28.25) 133.16,28.81 133.16,30.55 134.13,31.53 134.13,44.72 147.93,58.52 147.93,66.9 151.05,70.02 155.43,70.02 v1(157.1,71.68)
  BOTTOM w0.089: v1(157.1,71.68) 157.69,72.28 U6.BF34
  BOTTOM w0.16: v1(133.72,28.25) 133.2,27.72 JDIMM1.74
DDR_CKE2_DIMMB: length 98.6
  IN3 w0.089: v1(157.14,80) 156.53,79.4 156.53,78.33 157.12,77.73 157.26,77.73 157.59,77.4 157.59,77.05 155.08,74.53
  IN3 w0.196: 155.08,74.53 155.08,70.86 153.36,69.14 150.98,69.14 148.46,66.62 148.46,63.38 163.67,48.18 171.55,48.18 178.84,40.89 199.63,40.89 202.31,38.21 202.31,35.27 205.46,32.11 v1(206.66,32.11)
  BOTTOM w0.089: v1(157.14,80) 156.78,80.36 U6.AU36
  BOTTOM w0.16: v1(206.66,32.11) 207.4,32.85 JDIMM2.73
DDR_CKE3_DIMMB: length 101.8
  IN3 w0.089: 155.64,77.48 155.64,79.19 v1(157.12,80.68)
  IN3 w0.196: v1(206.66,29.06) 200.47,35.26 200.47,37.48 198.37,39.58 178.3,39.58 171.01,46.87 163.12,46.87 147.16,62.84 147.16,67.16 150.44,70.44 152.14,70.44 153.71,72.01 153.71,75.55 155.64,77.48
  BOTTOM w0.089: v1(157.12,80.68) 157.45,80.36 U6.AU35
  BOTTOM w0.16: JDIMM2.74 207.7,27.34 207.14,27.9 207.14,28.59 v1(206.66,29.06)
DDR_CS0_DIMMA#: length 64.1
  IN4 w0.117: v1(169.49,74.42) 170.14,75.06 170.31,75.06 170.43,74.94 170.43,74.76 169.49,73.82 169.49,72.46 169.81,72.15 169.81,64.03 169.59,63.81 169.59,63.65 169.81,63.43 169.81,63.25 169.66,63.1 169.48,63.1 169.26,63.32 169.1,63.32 168.93,63.15 168.93,62.99 169.16,62.76 169.16,62.58 169.01,62.43 168.83,62.43 168.6,62.65 168.44,62.65 168.28,62.5 168.28,62.33 168.51,62.09 168.51,61.93 148.69,42.11 148.69,35.64 147.42,34.37 147.42,29.53 147.29,29.4 147.08,29.4 146.96,29.53 v1(146.96,29.77)
  BOTTOM w0.089: v1(169.49,74.42) 169.83,74.76 U6.BE16
  BOTTOM w0.16: JDIMM1.114 145.2,28.01 v1(146.96,29.77)
DDR_CS1_DIMMA#: length 63.8
  IN4 w0.117: v1(169.49,75.81) 169.49,76.65 169.37,76.78 169.15,76.78 169.02,76.65 169.02,72.35 169.39,71.98 169.39,64.2 167.67,62.49 167.67,62.32 167.91,62.09 167.91,61.92 167.74,61.76 167.58,61.76 167.34,61.99 167.18,61.99 167.01,61.83 167.01,61.66 167.25,61.43 167.25,61.26 167.08,61.1 166.92,61.1 166.68,61.33 166.52,61.33 166.35,61.17 166.35,61 166.59,60.77 166.59,60.6 166.42,60.43 166.26,60.43 166.02,60.67 165.86,60.67 165.69,60.5 165.69,60.34 165.93,60.1 165.93,59.94 165.76,59.77 165.59,59.77 165.36,60.01 165.19,60.01 165.03,59.84 165.03,59.68 165.26,59.44 165.26,59.28 165.1,59.11 164.93,59.11 164.7,59.35 164.53,59.35 164.37,59.18 164.37,59.02 164.6,58.78 164.6,58.62 164.44,58.45 164.27,58.45 164.04,58.69 163.87,58.69 163.71,58.52 163.71,58.36 163.94,58.12 163.94,57.95 163.78,57.79 163.61,57.79 163.37,58.02 163.21,58.02 163.04,57.86 163.04,57.69 163.28,57.46 163.28,57.29 163.11,57.13 162.95,57.13 162.71,57.36 162.55,57.36 162.27,57.09 162.27,56.29 148.27,42.28 148.27,35.82 146.96,34.5 v1(146.96,32.82)
  BOTTOM w0.089: v1(169.49,75.81) 169.15,76.16 U6.BC17
  BOTTOM w0.16: JDIMM1.121 147.3,33.16 v1(146.96,32.82)
DDR_CS2_DIMMB#: length 101.9
  IN3 w0.089: 173.38,71.38 173.38,72.51 173.11,72.78 173.11,76.69 172.76,77.05 169.12,77.05 168.66,77.51 168.19,77.51 167.82,77.88 v1(167.46,77.88)
  IN3 w0.196: v1(220.26,29.82) 221.21,30.78 221.21,31.05 220.3,31.97 220.3,32.25 220.58,32.52 220.85,32.52 221.77,31.61 222.04,31.61 223.96,33.53 223.96,39.64 202.92,60.68 201.9,60.68 201.7,60.87 201.7,61.9 201.51,62.09 201.11,62.09 200.92,61.9 200.92,60.87 200.72,60.68 200.31,60.68 200.12,60.87 200.12,62.6 199.92,62.8 183.68,62.8 183.49,62.99 183.49,63.73 183.29,63.93 182.9,63.93 182.7,63.73 182.7,62.99 182.51,62.8 182.12,62.8 181.92,62.99 181.92,63.73 181.73,63.93 181.33,63.93 181.14,63.73 181.14,62.99 180.94,62.8 180.65,62.8 173.38,70.06 173.38,71.38
  BOTTOM w0.089: U6.BA20 167.14,77.56 v1(167.46,77.88)
  BOTTOM w0.16: JDIMM2.114 219.7,29.26 v1(220.26,29.82)
DDR_CS3_DIMMB#: length 104.6
  IN3 w0.089: v1(168.34,78.64) 167.88,79.1 167.28,79.1 167.09,78.91 167.09,77.57 167.21,77.44 167.98,77.44 168.11,77.32 168.58,77.32 169.04,76.86 171.65,76.86 172.43,76.08 172.43,72.87
  IN3 w0.196: 172.43,72.87 172.2,72.64 172.2,70.32 180.38,62.14 194.61,62.14 194.81,61.95 194.81,61.49 195.01,61.29 195.4,61.29 195.59,61.49 195.59,61.95 195.79,62.14 196.18,62.14 196.37,61.95 196.37,60.22 196.57,60.02 196.92,60.02 197.12,60.22 197.12,61.95 197.31,62.14 197.71,62.14 197.9,61.95 197.9,60.22 198.1,60.02 198.49,60.02 198.68,60.22 198.68,61.95 198.88,62.14 199.27,62.14 199.47,61.95 199.47,60.22 199.66,60.02 202.65,60.02 223.31,39.37 223.31,33.8 222.81,33.29 221.12,33.29 220.93,33.49 220.93,33.91 221.12,34.11 222.46,34.11 222.66,34.3 222.66,36.32 222.46,36.51 v1(222.2,36.51)
  BOTTOM w0.089: U6.AY19 167.95,78.26 v1(168.34,78.64)
  BOTTOM w0.16: v1(222.2,36.51) 222.12,36.51 221.74,36.14 221.74,35.33 221.8,35.27 JDIMM2.121
DDR_VREF_IN: length 11.2
  TOP w0.102: CA77.2 20.76,18.82 20.76,17.34 20.52,17.1 18.9,17.1 RA62.1 17.25,17.98 v2(17.05,18.17) 17.05,18.42 17.51,18.88 RA59.2 CA65.1 17.26,20.53 17.26,21.37 17.67,21.78 U12.40
DEW2: length 8
  BOTTOM w0.102: RN19.1 38.83,32.47 37.88,32.47 37.68,32.27 37.68,31.58 v2(37.83,31.43) 38.69,31.43 RN21.1
  BOTTOM w0.254: UN1.6 36.28,32.5 36.45,32.33 36.65,32.33 37.27,32.95 38.97,32.95 RN19.1
DGPU_FB_EN: length 133.6
  TOP w0.102: v1(220.34,65.86) 220.15,65.67 220.15,63.63 220.79,63 220.79,61.22 v2(217.77,58.21) 217.1,57.54 217.1,55.19 216.39,54.48 QZ19.2 ; RZ9.2 243.91,56.08 DZ2.1 RZ485.1 v1(247.95,56.83)
  IN1 w0.102: v1(247.95,56.83) 245.62,59.16 243.08,59.16 240.62,61.62 240.62,61.92 238.36,64.18 232.86,64.18 228.33,68.7 220.9,68.7 220.09,67.89 220.09,66.11 v1(220.34,65.86) 217.3,65.86 216.66,66.49 216.66,70.24 214.83,72.07 207.11,72.07 206.72,72.46 206.72,74.93 205.17,76.48 205.17,79.87 203.46,81.57 199.88,81.57 198.74,82.71 198.74,83.85 197.95,84.64 197.95,109.26 192.93,114.29 v1(192.93,121.67)
  BOTTOM w0.203: v1(192.93,121.67) 192.92,121.68 192.92,123.5 192.52,123.9 PU600.28
DGPU_HOLD_RST#: length 67.5
  TOP w0.102: UH4.2 245.15,43.32 245.98,44.16 v2(245.98,44.51) 245.98,48.66 v1(247.69,50.37)
  IN2 w0.089: 277.14,27.77 276.97,27.77 276.92,27.83 273.83,27.83 273.54,27.54 v4(273.54,27.37) ; 277.14,37.38 274.43,40.09 271.06,40.09 269.3,41.85 269.3,42.2
  IN2 w0.102: v1(247.69,50.37) 249.75,50.37 250.65,49.47 258.36,49.47 258.89,48.93 258.89,45.66 260.54,44.01 261.32,44.01 261.71,43.62 264.02,43.62 264.94,44.54 268.07,44.54 269.3,43.32 269.3,42.2 ; 277.14,27.77 277.56,27.77 277.85,28.07 277.85,29.74 277.51,30.09 277.51,37.01 277.14,37.38
  IN4 w0.089: v4(273.54,27.37) 273.77,27.37 274.21,26.94 274.73,26.94 275.24,26.42 v6(275.74,26.42)
  GND3 w0.089: v7(276.03,26.5) 275.81,26.5 v6(275.74,26.42)
  BOTTOM w0.089: 277.14,26.8 276.84,26.5 v7(276.03,26.5) U7.A12
  BOTTOM w0.102: RPH2.3 277.4,27.05 277.14,26.8
DGPU_PWR_EN: length 178.3
  TOP w0.102: QZ2.2 215.45,61.48 215.58,61.35 215.58,61.03 215.65,60.96 218.49,60.96 v1(219.33,61.79) ; v1(200.21,77.6) 200.21,70.81 RV289.2 ; v1(251.33,48.84) 251.74,49.25 v2(251.74,49.78) QZ18.2 251.74,51.85 253.57,53.68 CH99.1 RH247.1 255.08,54.06 254.67,54.47 QH6.1 257.52,56.14 257.96,55.7 258.9,55.7 RH416.1
  IN1 w0.102: v1(142.71,116.44) 144.22,116.44 150.51,110.15 173.54,110.15 176.97,106.71 179.59,106.71 184.36,101.95 184.36,91.54 191.09,84.81 192.2,84.81 199.4,77.6 v1(200.21,77.6) 200.21,73.45 203.31,70.35 205.07,70.35 209.6,65.82 211.89,65.82 216.32,61.39 218.92,61.39 v1(219.33,61.79) 222.5,61.79 222.82,62.11 222.82,63.91 224.06,65.16 228.75,65.16 232.11,61.79 237.45,61.79 242.68,56.57 244.09,56.57 248.98,51.68 248.98,50.92 251.06,48.84 v1(251.33,48.84)
  BOTTOM w0.102: v1(142.71,116.44) PR841.2
DGPU_PWR_EN#: length 55.2
  TOP w0.102: RH416.2 256.78,55.2 QH6.2 256.36,54.78 RH164.2 256.82,53.75 257.02,53.55 257.8,53.55 258.24,53.11 258.24,49.26 258.31,49.19 v2(258.31,49.03) 258.31,48.63 v1(258.19,48.51)
  IN1 w0.076: 269.33,42.2 269.33,40.37 269.66,40.04 269.66,38.82 268.97,38.13 268.97,35.97 268.16,35.16 268.16,34.58 268.96,33.78 268.96,31.49 269.23,31.22 269.75,31.22 269.81,31.15 271.43,31.15 272.52,30.06 272.52,30.01 272.82,29.72 273.5,29.72 273.91,29.3 273.91,27.17 274.09,26.99 274.09,26.53 273.59,26.02 273.5,26.02 273.04,25.57 v4(273.04,24.74)
  IN1 w0.102: v1(258.19,48.51) 259.05,49.37 264.04,49.37 266.25,47.16 266.25,46.16 269.33,43.09 269.33,42.2
  IN4 w0.089: v6(275.78,26.02) 274.87,26.02 274.57,26.31 272.83,26.31 272.62,26.1 272.62,25.15 v4(273.04,24.74)
  GND3 w0.089: v7(275.46,26.07) 275.73,26.07 v6(275.78,26.02)
  BOTTOM w0.089: v7(275.46,26.07) 275.15,26.07 274.78,26.43 274.45,26.43 274.39,26.5 U7.C12
DGPU_PWROK: length 231.9
  TOP w0.102: v3(252.74,24.54) 252.74,25.03 252.48,25.29 RPH8.6 ; v2(143.98,128.34) 143.44,127.81 v1(143.19,127.81)
  TOP w0.508: DZ2.2 243.77,56.73 RZ9.1 243.71,58.48 v1(243.79,58.55)
  GND1 w0.102: v3(252.74,24.54) v4(252.33,24.54)
  IN1 w0.203: 187.77,90.23 186.83,91.17 186.83,91.4
  IN1 w0.254: v1(143.19,127.81) 143.85,127.14 143.85,118.83 144.04,118.64 144.85,118.64 151.85,111.65 174.26,111.65 176.67,109.23 179.64,109.23 186.83,102.04 186.83,91.4 ; 187.77,90.23 191.97,90.23 198.46,83.74 198.46,82.53 199.7,81.29 203.34,81.29 204.6,80.04 204.6,76.65 206.44,74.81 206.44,72.35 208.18,70.61 214.21,70.61 214.9,69.92 215.16,69.92 216.09,68.99 216.09,66.24 216.95,65.37 222,65.37 223.49,66.86 223.49,67.95 223.96,68.42 228.22,68.42 232.74,63.9 238.24,63.9 240.34,61.81 240.34,61.52 243.3,58.55 v1(243.79,58.55) 244.89,58.55 252.39,51.06 252.39,50.62 v4(254.17,48.84)
  IN2 w0.102: v4(254.17,48.84) 250.58,45.26 250.58,29.93 252.41,28.1 252.41,24.62 v4(252.33,24.54)
  IN4 w0.089: 254.47,22.61 255.14,22.61 255.27,22.74 256.77,22.74 256.94,22.58 256.94,21.69 257.86,20.77 259.81,20.77 260.81,21.77 262.44,21.77 263.43,22.76 263.43,26.32 264.17,27.05 265.4,27.05 266.31,27.97 270.37,27.97 270.73,27.61 271.91,27.61 272.09,27.79 274.59,27.79 274.97,27.41 274.97,26.96 275.14,26.79 275.57,26.79 v6(275.58,26.8)
  IN4 w0.102: 254.47,22.61 254.38,22.61 254,22.99 254,23.27 253.44,23.83 253.05,23.83 v4(252.33,24.54)
  GND3 w0.089: v7(276.1,27.3) 276.1,27.19 275.71,26.8 v6(275.58,26.8)
  BOTTOM w0.089: U7.C14 274.67,27.31 274.98,27.62 275.78,27.62 v7(276.1,27.3)
  BOTTOM w0.254: PR842.2 142.75,127.81 v1(143.19,127.81)
DH_1.35V: length 5.1
  IN1 w1.016: 129.43,17.54 130.91,19.02 133.94,19.02
  vias: v2(135.55,17.48) v3(127.57,16.83) v3(127.57,16.52) v3(128.18,16.83) v3(128.18,16.52) v3(135.19,18.15) v3(135.19,17.84) v3(135.8,18.15) v3(135.8,17.84) v5(127.88,16.83) v5(127.88,16.52) v5(128.49,16.83) v5(128.49,16.52) v5(135.5,18.15) v5(135.5,17.84) v5(136.11,18.15) v5(136.11,17.84)
DISP_A0N_R: length 24.2
  TOP w0.102: v1(16.16,90.08) 15.94,89.86 15.76,89.86 15.58,90.03 DV2.5 DV2.6 13.8,90.03 13.64,89.87 12.92,89.87 12.57,90.21 JMDP.5
  IN4 w0.089: v6(30.81,84.46) 30.92,84.35 30.92,83.8 30.16,83.04 23.86,83.04 17.15,89.75 16.48,89.75 v1(16.16,90.08)
  GND3 w0.102: v6(30.81,84.46) 30.61,84.26 v7(30.61,84.16)
DISP_A0P_R: length 24.2
  TOP w0.102: v1(16.16,89.49) 16.04,89.61 15.76,89.61 15.68,89.53 DV2.4 DV2.7 13.8,89.53 13.72,89.61 JMDP.3
  IN4 w0.089: v6(31.24,84.46) 31.16,84.38 31.16,83.7 30.26,82.8 23.76,82.8 17.05,89.51 16.17,89.51 v1(16.16,89.49)
  GND3 w0.102: v7(31.5,84.16) 31.5,84.21 v6(31.24,84.46)
DISP_A1N_R: length 24.2
  TOP w0.102: JMDP.11 12.57,92.01 12.74,91.84 13.08,91.84 13.13,91.89 13.77,91.89 13.9,92.03 DV3.4 DV3.7 15.61,92.03 15.86,91.78 16.22,91.78 v1(16.57,92.13)
  IN4 w0.089: v1(16.57,92.13) 16.57,92.13 16.92,91.79 17.71,91.79 23.31,86.19 23.31,85.89 23.12,85.71 23.12,85.58 23.31,85.39 23.44,85.39 23.58,85.54 23.96,85.54 24.41,85.09 24.41,84.71 24.1,84.4 24.1,84.28 24.29,84.09 24.42,84.09 24.74,84.41 25.09,84.41 25.47,84.03 29.01,84.03 29.15,84.17 29.15,84.39 v6(29.06,84.47)
  GND3 w0.102: v7(28.83,84.16) 29.06,84.39 v6(29.06,84.47)
DISP_A1P_R: length 24.2
  TOP w0.102: JMDP.9 12.57,91.41 12.74,91.59 13.19,91.59 13.24,91.64 13.84,91.64 13.95,91.53 DV3.5 DV3.6 16.55,91.53 v1(16.57,91.55)
  IN4 w0.089: v1(16.57,91.55) 17,91.55 17,91.55 17.61,91.55 23.07,86.09 23.07,86 22.88,85.81 22.88,85.48 23.21,85.15 23.54,85.15 23.68,85.3 23.86,85.3 24.17,84.99 24.17,84.81 23.86,84.5 23.86,84.18 24.19,83.84 24.52,83.84 24.84,84.17 24.99,84.17 25.37,83.79 29.11,83.79 29.39,84.07 29.39,84.37 v6(29.49,84.47)
  GND3 w0.102: v6(29.49,84.47) 29.49,84.39 v7(29.72,84.16)
DISP_A2N_R: length 22.6
  TOP w0.102: JMDP.17 12.57,93.81 12.74,93.64 13.15,93.64 13.39,93.4 13.68,93.4 13.8,93.53 DV3.1 DV3.9 15.49,93.53 15.66,93.36 15.79,93.36 15.91,93.48 v1(15.91,93.74)
  BOTTOM w0.102: C57.1 21.65,84.37 21.11,84.37 20.55,84.93 20.55,87.45 20.1,87.9 v9(19.04,87.9) 17.35,87.9 16.99,88.25 16.99,89.06 17.24,89.32 18.76,89.32 18.87,89.42 18.87,89.72 18.76,89.82 17.3,89.82 16.99,90.13 16.99,92.34 16.27,93.07 16.27,93.39 v1(15.91,93.74)
DISP_A2P_R: length 22.6
  TOP w0.102: JMDP.15 12.57,93.21 12.74,93.39 13.04,93.39 13.28,93.15 13.68,93.15 13.8,93.03 DV3.2 DV3.8 15.46,93.03 15.53,93.1 15.91,93.1 v1(16.55,93.74)
  BOTTOM w0.102: C59.1 21.65,84.63 21.21,84.63 20.8,85.04 20.8,87.55 20.21,88.15 17.45,88.15 17.25,88.35 17.25,88.96 17.35,89.06 18.87,89.06 19.12,89.31 19.12,89.83 18.87,90.08 17.41,90.08 17.25,90.24 17.25,92.45 16.52,93.17 16.52,93.71 v1(16.55,93.74)
DISP_A3N_R: length 22.6
  TOP w0.102: JMDP.12 8.36,91.97 9.38,91.97 10.16,91.19 10.16,88.78 10.33,88.61 14.22,88.61 DV2.8 DV2.2 16.24,88.53 v1(16.28,88.58)
  IN3 w0.127: v4(21.59,82.33) 21.64,82.38 22.22,82.38 22.72,82.88 22.72,84.34 18.72,88.33 16.52,88.33 v1(16.28,88.58)
  GND3 w0.102: v4(21.59,82.33) 21.59,82.33 21.85,82.33 v7(22,82.18)
DISP_A3P_R: length 22.6
  TOP w0.102: v1(16.28,87.99) 16,88.27 15.66,88.27 15.61,88.22 15.61,88.14 15.5,88.03 DV2.1 DV2.9 13.8,88.03 13.48,88.36 10.22,88.36 9.9,88.68 9.9,91.09 9.28,91.71 8.61,91.71 JMDP.10
  IN3 w0.127: v1(16.28,87.99) 16.37,88.08 18.61,88.08 22.46,84.23 22.46,82.99 22.15,82.68 21.83,82.68 v4(21.59,82.92)
  GND3 w0.102: v7(22,83.07) 22.03,83.03 22.03,82.81 21.92,82.7 21.81,82.7 v4(21.59,82.92)
DISP_C_A0N: length 1.7
  BOTTOM w0.102: U11.39 30.55,74.27 30.61,74.22 30.61,73.81 CV780.1
DISP_C_A0P: length 1.6
  BOTTOM w0.102: CV779.1 30.86,73.55 30.86,73.99 31.05,74.18 U11.38
DISP_C_A1N: length 1.8
  BOTTOM w0.102: CV782.1 28.89,73.87 28.89,74 29.05,74.17 U11.42
DISP_C_A1P: length 1.7
  BOTTOM w0.102: U11.41 29.55,74.31 29.14,73.9 29.14,73.48 CV781.1
DISP_C_A2N: length 2.1
  BOTTOM w0.102: CV784.1 26.7,73.36 26.96,73.62 26.96,73.95 27.15,74.14 27.5,74.14 27.57,74.2 27.57,74.28 27.55,74.29 U11.45
DISP_C_A2P: length 2.1
  BOTTOM w0.102: CV783.1 27.21,73.64 27.21,73.84 27.26,73.88 27.61,73.88 27.82,74.1 27.82,74.19 28.05,74.42 U11.44
DISP_C_A3N: length 2.5
  BOTTOM w0.102: CV786.1 24.8,73.36 25.17,73.73 25.17,73.85 25.42,74.1 26.12,74.1 26.18,74.16 26.18,74.2 26.05,74.32 U11.48
DISP_C_A3P: length 2.5
  BOTTOM w0.102: CV785.1 25.71,73.36 25.42,73.64 25.42,73.74 25.53,73.85 26.22,73.85 26.43,74.05 26.43,74.18 26.55,74.3 U11.47
DISP_CEC: length 4.2
  BOTTOM w0.102: RV456.1 11.17,90.06 v2(10.4,89.29) 10.08,88.97 9.08,88.97 8.63,89.42 8.63,89.59 JMDP.6
DISP_CLK_AUXP_CONN: length 50.5
  IN1 w0.089: v1(19.22,95.96) 19.22,95.48 18.9,95.16 18.9,94.84 18.68,94.63 17.84,94.63 17.13,95.33 10.93,95.33 10.25,94.65 8.97,94.65 8.69,94.37 8.69,94.17 8.11,93.6 JMDP.16
  IN4 w0.089: v1(31.12,79.36) 33.19,79.36 34.11,80.29 34.11,93.77 32.8,95.08 23.07,95.08 21.38,96.77 19.61,96.77 19.31,96.48 19.31,96.06 v1(19.22,95.96)
  BOTTOM w0.102: v1(31.12,79.36) 31.24,79.49 31.7,79.49 31.77,79.56 U11.28 ; RV490.1 19.98,94.58 19.98,95.1 19.48,95.59 19.48,95.7 v1(19.22,95.96)
DISP_DAT_AUXN_CONN: length 51.1
  TOP w0.102: v1(19.87,95.96) v2(20.33,95.51)
  IN1 w0.089: v1(19.87,95.96) 19.78,95.96 19.46,95.64 19.46,95.38 19.14,95.06 19.14,94.74 18.78,94.39 17.74,94.39 17.03,95.09 11.03,95.09 10.35,94.41 9.07,94.41 8.93,94.27 8.93,93.86 9.03,93.76 9.25,93.76 JMDP.18
  IN4 w0.089: v1(31.12,80.13) 31.02,80.03 31.02,79.87 31.13,79.76 31.42,79.76 31.58,79.6 33.09,79.6 33.87,80.39 33.87,93.67 32.7,94.84 22.97,94.84 21.28,96.53 19.71,96.53 19.56,96.38 19.56,96.17 19.77,95.96 v1(19.87,95.96)
  BOTTOM w0.102: U11.27 31.73,80.06 31.68,80.02 31.68,79.83 31.6,79.74 31.14,79.74 30.97,79.91 30.97,79.99 31.11,80.13 v1(31.12,80.13) ; v1(19.87,95.96) 19.73,95.82 19.73,95.7 20.23,95.2 20.23,94.58 RV491.1
DISPOFF#: length 15.5
  BOTTOM w0.102: DV13.1 89.09,32.34 RV403.1 87.82,33.71 87.26,34.27 86.93,34.27 v2(86.63,34.58) 86.48,34.72 86.48,35.04 83.94,37.58 79.79,37.58 78.55,38.83 JEDP1.28
DL_1.35V: length 5.9
  IN1 w1.016: 129.98,11.31 127.02,11.31 126.43,11.9 126.43,13.98
  vias: v2(126.52,14.6) v9(125.97,14.77) v9(126.45,15.37) v9(131.36,11.06) v9(131.99,11.06)
DMI_CRX_PTX_N0: length 112.6
  IN1 w0.089: v1(179.86,90.64) 180.31,90.18 181.47,90.18 194.57,77.09 194.57,74.97 210.96,58.58 214.71,58.58 215.48,57.81 230.7,57.81 231.46,58.58 236.63,58.58 253.07,42.14 253.07,34.66 253.39,34.35 253.39,32.1 253.03,31.75 253.03,31.4 v4(252.82,31.19)
  GND3 w0.102: v7(252.88,30.71) 252.94,30.77 252.94,31.06 v4(252.82,31.19)
  BOTTOM w0.089: v1(179.86,90.64) 179.53,90.3 U6.AB2 ; U7.BD21 257,30.13 257.1,30.03 257.1,29.93 257,29.83 256.82,29.83 256.6,30.05 256.37,30.05 256.27,29.96 254.49,29.96
  BOTTOM w0.102: v7(252.88,30.71) 253.63,29.96 253.92,29.96 253.94,29.94 254.47,29.94 254.49,29.96
DMI_CRX_PTX_N1: length 116.7
  IN1 w0.089: v4(252.82,29.57) 253.23,29.99 253.23,30.42 253.88,31.07 253.88,31.25 254.01,31.38 254.01,34.73 253.72,35.01 253.72,42.39 236.95,59.16 229.65,59.16 229.55,59.25 211.1,59.25 195.15,75.21 195.15,77.45 180.73,91.86 179.57,91.86 179.49,91.86 179.15,91.52 179.15,91.24 v1(178.48,90.57)
  GND3 w0.102: v4(252.82,29.57) 252.82,29.08 v7(252.64,28.9)
  BOTTOM w0.089: v1(178.48,90.57) 178.48,90.57 178.48,90.55 178.5,90.55 U6.AB3 ; 254.59,29.35 254.6,29.35 254.61,29.34 255.37,29.34 255.68,29.64 256.39,29.64 U7.BE20
  BOTTOM w0.102: v7(252.64,28.9) 252.72,28.83 252.95,28.83 253.05,28.93 253.05,29.02 253.29,29.26 253.57,29.26 253.66,29.35 254.59,29.35
DMI_CRX_PTX_N2: length 121.4
  IN1 w0.089: v4(256.53,28.09) 256.62,28.09 256.8,27.91 256.8,27.77 256.71,27.69 256.16,27.69 255.84,28.01 251.99,28.01 251.26,28.74 251.26,31.29 250.58,31.97 250.58,42.45 236.56,56.47 231.54,56.47 230.04,54.96 215.17,54.96 215.08,55.05 214.81,55.05 214.72,54.96 214.45,54.96 214.36,55.05 214.09,55.05 214,54.96 213.73,54.96 213.64,55.05 213.37,55.05 213.28,54.96 213.01,54.96 212.92,55.05 212.65,55.05 212.55,54.96 212.29,54.96 212.19,55.05 211.93,55.05 211.83,54.96 211.57,54.96 196,70.53 189.83,70.53 185.64,74.72 185.64,83.73 181.92,87.44 181.36,87.44 179.39,89.42 178.31,89.42 178.24,89.48 178.24,89.62 v1(178.48,89.86)
  GND3 w0.089: v4(256.53,28.09) 256.43,28.19 v7(256.43,28.52)
  BOTTOM w0.089: U7.BD17 256.93,28.52 v7(256.43,28.52) ; U6.AC3 178.62,89.4 178.48,89.54 v1(178.48,89.86)
DMI_CRX_PTX_N3: length 118.9
  IN1 w0.089: v1(180.56,89.81) 180.25,89.5 180.25,89.38 180.38,89.26 181.78,89.26 186.79,84.25 186.79,83.98 186.89,83.88 186.89,83.62 186.79,83.51 186.79,83.25 186.89,83.15 186.89,82.88 186.79,82.78 186.79,82.51 186.89,82.41 186.89,82.14 186.79,82.04 186.79,81.77 186.89,81.67 186.89,81.41 186.79,81.3 186.79,81.04 186.89,80.94 186.89,80.67 186.79,80.57 186.79,80.3 186.89,80.2 186.89,79.93 186.79,79.83 186.79,79.56 186.89,79.46 186.89,79.2 186.79,79.1 186.79,78.83 186.89,78.73 186.89,78.46 186.79,78.36 186.79,75.2 190.3,71.69 196.53,71.69 211.23,56.99 230.43,56.99 231.63,58.19 236.47,58.19 252.36,42.3 252.36,33.93 251.74,33.32 251.74,32.53 252.41,31.86 252.41,29.41 252.66,29.16 256.29,29.16 256.42,29.29 256.42,29.45 v4(256.27,29.6)
  GND3 w0.089: v4(256.27,29.6) 256.4,29.47 256.4,29.3 v7(256.03,28.94)
  BOTTOM w0.089: U6.AC1 180.23,89.47 v1(180.56,89.81) ; v7(256.03,28.94) U7.BE18
DMI_CRX_PTX_P0: length 112.7
  IN1 w0.089: v1(180.68,90.59) 180.68,90.54 180.85,90.37 181.55,90.37 194.75,77.16 194.75,75.05 211.03,58.77 214.78,58.77 215.56,57.99 215.72,57.99 215.82,58.09 216.09,58.09 216.19,57.99 216.46,57.99 216.56,58.09 216.83,58.09 216.93,57.99 217.2,57.99 217.3,58.09 217.56,58.09 217.67,57.99 217.93,57.99 218.03,58.09 218.3,58.09 218.4,57.99 218.67,57.99 218.77,58.09 219.04,58.09 219.14,57.99 219.41,57.99 219.51,58.09 219.77,58.09 219.88,57.99 220.14,57.99 220.24,58.09 220.51,58.09 220.61,57.99 230.62,57.99 231.39,58.76 236.71,58.76 253.26,42.21 253.26,34.73 253.57,34.42 253.57,32.03 253.21,31.67 253.21,31.4 v4(253.43,31.19)
  GND3 w0.102: v4(253.43,31.19) 253.29,31.05 253.29,30.79 v7(253.34,30.74)
  BOTTOM w0.089: U6.AB1 180.61,90.59 v1(180.68,90.59) ; U7.BB21 257.37,30.15 257.09,30.43 256.8,30.43 256.62,30.25 256.29,30.25 256.21,30.17 254.59,30.17
  BOTTOM w0.102: 254.59,30.17 v9(254.21,30.17) 253.72,30.17 253.34,30.55 v7(253.34,30.74)
DMI_CRX_PTX_P1: length 117.7
  IN1 w0.089: v4(253.41,29.56) 253.41,30.35 254.06,31 254.06,31.18 254.19,31.31 254.19,34.8 253.9,35.09 253.9,42.46 237.03,59.34 229.72,59.34 229.63,59.44 211.18,59.44 195.33,75.29 195.33,77.52 180.81,92.04 179.64,92.04 179.42,92.04 178.96,91.59 178.96,91.31 178.65,91 178.21,91 v1(177.8,90.6)
  GND3 w0.102: v4(253.41,29.56) 253.34,29.48 253.34,28.95 v7(253.46,28.83)
  BOTTOM w0.089: 254.59,29.14 v9(255,29.14) 255.45,29.14 255.76,29.45 256.63,29.45 256.82,29.64 257.3,29.64 257.4,29.74 U7.BC20 ; U6.AB4 178.13,90.28 177.81,90.6 v1(177.8,90.6)
  BOTTOM w0.102: 254.59,29.14 253.77,29.14 253.46,28.83 v7(253.46,28.83)
DMI_CRX_PTX_P2: length 121.4
  IN1 w0.089: v4(257.14,28.08) 256.98,27.92 256.98,27.7 256.79,27.51 256.08,27.51 255.76,27.82 251.92,27.82 251.08,28.67 251.08,31.21 250.39,31.9 250.39,42.37 236.48,56.28 231.62,56.28 230.11,54.78 211.49,54.78 195.92,70.35 189.75,70.35 185.45,74.65 185.45,83.65 181.85,87.26 181.29,87.26 179.31,89.23 178.23,89.23 178.06,89.4 178.06,89.53 177.79,89.81 v1(177.78,89.81)
  GND3 w0.089: v7(257.39,28.53) 257.39,28.33 v4(257.14,28.08)
  BOTTOM w0.089: v1(177.78,89.81) 177.78,89.75 U6.AC4 ; U7.BB17 257.71,28.65 257.51,28.65 v7(257.39,28.53)
DMI_CRX_PTX_P3: length 118.9
  IN1 w0.089: v1(179.86,89.81) 180.07,89.6 180.07,89.3 180.3,89.07 181.71,89.07 186.61,84.18 186.61,75.12 190.23,71.5 196.46,71.5 211.15,56.81 230.51,56.81 231.7,58 236.39,58 252.17,42.22 252.17,34.01 251.56,33.4 251.56,32.45 252.23,31.78 252.23,29.34 252.59,28.98 256.36,28.98 256.6,29.22 256.6,29.37 v4(256.83,29.6)
  GND3 w0.089: v7(256.94,28.94) 256.61,29.26 256.61,29.38 v4(256.83,29.6)
  BOTTOM w0.089: v1(179.86,89.81) 179.53,89.47 U6.AC2 ; v7(256.94,28.94) U7.BC18
DMI_CTX_PRX_N0: length 120.5
  IN1 w0.089: v1(258.9,30.17) 258.75,30.01 258.75,29.74 258.57,29.56 257.94,29.56 256.88,28.5 255.33,28.5 255.23,28.4 252.35,28.4 251.65,29.1 251.65,31.45 250.97,32.14 250.97,33.66 251.54,34.24 251.54,42.04 236.72,56.86 231.38,56.86 230.18,55.66 211.42,55.66 196.16,70.93 189.99,70.93 186.03,74.88 186.03,83.89 182.21,87.71 181.54,87.71 181.35,87.89 181.35,88.22 v1(181.2,88.37)
  BOTTOM w0.089: v1(258.9,30.17) 258.9,30.54 U7.AW22 ; U6.AF2 179.72,87.78 180.03,88.09 181.15,88.09 181.2,88.15 181.2,88.37 v1(181.2,88.37)
DMI_CTX_PRX_N1: length 131.1
  IN1 w0.089: v1(260.63,29.22) 260.73,29.22 261.03,28.93 261.03,28.85 261.53,28.36 261.53,27.73 259.59,25.8 258.37,25.8 258.32,25.74 257.29,25.74 256.79,26.23 251.32,26.23 249.53,28.02 249.53,30.57 248.85,31.26 248.85,41.02 248.65,41.21 248.65,41.35 248.46,41.54 248.32,41.54 248.13,41.73 248.13,41.88 247.94,42.07 247.8,42.07 247.6,42.26 247.6,42.4 247.41,42.59 247.27,42.59 247.08,42.79 247.08,42.93 246.89,43.12 246.74,43.12 246.55,43.31 246.55,43.45 246.36,43.64 246.22,43.64 246.03,43.84 246.03,43.98 245.84,44.17 245.69,44.17 245.5,44.36 245.5,44.5 245.31,44.7 245.17,44.7 244.98,44.89 244.98,45.03 244.79,45.22 244.64,45.22 243.95,45.91 243.95,46.62 235.84,54.74 232.59,54.74 230.98,53.13 210.95,53.13 195.28,68.8 189.11,68.8 183.91,74 183.91,83.01 181.05,85.86 178.88,85.86 177.89,86.85 177.89,88.43 178.12,88.65 178.69,88.65 178.82,88.53 178.82,88.27 178.72,88.16 178.53,88.16 v1(178.47,88.22)
  BOTTOM w0.089: v1(260.63,29.22) 260.85,29.44 260.85,29.65 U7.AR20 ; U6.AF4 178.13,87.87 v1(178.47,88.22)
DMI_CTX_PRX_N2: length 124.1
  IN1 w0.089: v1(261.11,28.21) 260.99,28.08 260.99,27.72 259.93,26.67 251.44,26.67 249.92,28.19 249.92,30.74 249.24,31.42 249.24,41.89 236,55.13 232.1,55.13 230.59,53.62 211.01,53.62 195.44,69.2 189.27,69.2 184.3,74.17 184.3,83.17 181.35,86.12 179.3,86.12 178.66,86.76 178.66,87.14 v1(178.45,87.34)
  BOTTOM w0.089: v1(178.45,87.34) 178.13,87.02 U6.AG4
  BOTTOM w0.102: U7.AP17 261.11,28.41 v1(261.11,28.21)
DMI_CTX_PRX_N3: length 121.1
  IN1 w0.089: v1(259.45,29.19) 259.25,28.99 259.25,28.83 258.98,28.56 258.02,28.56 257.71,28.26 257.71,27.73 257.09,27.11 255.84,27.11 255.7,27.25 251.68,27.25 250.5,28.43 250.5,30.97 249.82,31.66 249.82,42.13 236.24,55.71 231.86,55.71 230.35,54.2 211.25,54.2 195.68,69.77 189.51,69.77 184.88,74.41 184.88,83.41 181.54,86.75 180.28,86.75 180.06,86.97 180.06,87.15 v1(179.87,87.34)
  BOTTOM w0.089: v1(179.87,87.34) 179.53,86.99 U6.AG2
  BOTTOM w0.102: U7.AV20 259.45,29.51 v1(259.45,29.19)
DMI_CTX_PRX_P0: length 120.6
  IN1 w0.089: v1(181.82,88.34) 181.69,88.34 181.54,88.18 181.54,87.97 181.61,87.89 182.29,87.89 186.21,83.97 186.21,74.96 190.06,71.11 196.23,71.11 211.5,55.85 211.76,55.85 211.86,55.95 212.13,55.95 212.23,55.85 212.5,55.85 212.6,55.95 212.87,55.95 212.97,55.85 213.24,55.85 213.34,55.95 213.6,55.95 213.71,55.85 213.97,55.85 214.07,55.95 214.34,55.95 214.44,55.85 214.71,55.85 214.81,55.95 215.08,55.95 215.18,55.85 215.45,55.85 215.55,55.95 215.81,55.95 215.92,55.85 230.11,55.85 231.3,57.04 236.79,57.04 251.73,42.11 251.73,34.16 251.15,33.59 251.15,32.21 251.84,31.53 251.84,29.17 252.42,28.58 255.15,28.58 255.25,28.69 256.8,28.69 257.86,29.75 258.5,29.75 258.57,29.81 258.57,29.98 258.38,30.16 v1(258.32,30.16)
  BOTTOM w0.089: U7.AY22 258.55,30.66 258.61,30.61 258.61,30.4 258.37,30.16 v1(258.32,30.16) ; v1(181.82,88.34) 181.72,88.34 181.42,88.04 181.38,88.04 181.23,87.89 180.34,87.89 U6.AF1
DMI_CTX_PRX_P1: length 131.1
  IN1 w0.089: v1(261.27,29.22) 261.27,28.87 261.71,28.43 261.71,27.65 259.67,25.61 258.45,25.61 258.39,25.55 257.21,25.55 256.72,26.05 251.24,26.05 249.35,27.95 249.35,30.5 248.66,31.18 248.66,40.94 243.77,45.83 243.77,46.55 235.76,54.55 232.66,54.55 231.05,52.95 210.87,52.95 195.2,68.62 189.03,68.62 183.72,73.93 183.72,82.93 180.98,85.68 178.81,85.68 177.71,86.78 177.71,88.5 178.04,88.84 178.77,88.84 179,88.6 179,88.4 v1(179.2,88.21)
  BOTTOM w0.089: v1(179.2,88.21) 178.83,87.84 U6.AF3 ; U7.AP20 261.41,29.36 v1(261.27,29.22)
DMI_CTX_PRX_P2: length 124
  IN1 w0.089: v1(260.52,28.21) 260.8,27.93 260.8,27.8 259.85,26.85 259.59,26.85 259.48,26.95 259.22,26.95 259.12,26.85 258.85,26.85 258.75,26.95 258.48,26.95 258.38,26.85 258.11,26.85 258.01,26.95 257.74,26.95 257.64,26.85 251.52,26.85 250.11,28.26 250.11,30.81 249.42,31.5 249.42,41.97 236.08,55.31 232.02,55.31 230.51,53.81 211.09,53.81 195.52,69.38 189.35,69.38 184.48,74.24 184.48,83.25 181.43,86.3 179.38,86.3 178.84,86.84 178.84,87.21 178.97,87.34 v1(179.18,87.34)
  BOTTOM w0.089: U6.AG3 178.83,86.99 v1(179.18,87.34)
  BOTTOM w0.102: v1(260.52,28.21) 260.52,28.41 U7.AR17
DMI_CTX_PRX_P3: length 121.3
  IN1 w0.089: v1(258.65,29.19) 258.97,29.19 259.07,29.1 259.07,28.91 258.9,28.74 257.94,28.74 257.53,28.33 257.53,27.81 257.02,27.29 255.91,27.29 255.78,27.43 251.76,27.43 250.68,28.5 250.68,31.05 250,31.74 250,42.21 236.32,55.89 231.78,55.89 230.27,54.38 211.33,54.38 195.76,69.96 189.59,69.96 185.06,74.48 185.06,83.49 181.61,86.93 180.36,86.93 180.24,87.05 180.24,87.28 180.38,87.42 180.56,87.42 v1(180.63,87.34)
  BOTTOM w0.089: U6.AG1 180.26,86.96 v1(180.63,87.34)
  BOTTOM w0.102: U7.AW20 259.03,29.43 258.79,29.19 v1(258.65,29.19)
DMI_RCOMP: length 4.4
  TOP w0.089: RH99.2 255.9,29.6 v2(256.37,29.6) 256.73,29.6 v1(258.16,28.17)
  BOTTOM w0.089: v1(258.16,28.17) 258.43,28.44 U7.AY17
DMIC0: length 7.7
  TOP w0.102: RV424.1 37.36,44.2 34.11,44.2 33.77,44.55 32.26,44.55 CA23.1 RA97.2
DMIC0_R: length 266.2
  TOP w0.102: v1(68.32,38.72) 68.32,39.04 66.31,41.05 59.14,41.05 56.67,43.52 v2(51.89,43.52) 48.82,43.52 48.14,44.19 41.2,44.19 CV753.1 40.23,44.24 39.23,44.24 RV424.2 ; v1(238.54,13.11) 238.19,13.11 236.33,14.97 236.33,19.13 237.35,20.15 v1(237.35,20.43)
  IN3 w0.102: v1(237.35,20.43) 236.73,21.05 220.49,21.05 220.14,21.4 210.06,21.4 209.17,20.52 198.32,20.52 197.9,20.93 197.9,21.85 193.57,26.19 180.92,26.19 174.64,32.47 173.26,32.47 171.89,33.84 171.89,36.78 168.32,40.35 159.76,40.35 159.05,41.06 112.23,41.06 112.16,41.13 109.59,41.13 108.24,39.78 108.24,37.78 107.2,36.74 105.4,36.74 v1(105.07,36.41)
  BOTTOM w0.102: JTB1.34 264.5,10.57 263.68,11.39 261.65,11.39 261.39,11.13 256.97,11.13 256.68,11.42 251.27,11.42 250.8,10.96 239.97,10.96 238.54,12.39 v1(238.54,13.11) ; v1(105.07,36.41) 104.68,36.41 102.62,34.35 92.24,34.35 89.15,31.25 85.26,31.25 84.67,31.84 84.67,35.12 83.12,36.67 79.41,36.67 78.03,38.05 75.1,38.05 74.47,37.42 74.47,35.21 73.98,34.72 71.35,34.72 68.32,37.74 v1(68.32,38.72)
DMIC0_RA: length 4.6
  TOP w0.102: U15.13 27.15,45.29 27.24,45.38 29.1,45.38 29.31,45.16 RA97.1 29.81,45.86 v2(30.26,46.31)
DMIC_CLK: length 7.7
  TOP w0.102: RA96.2 CA27.1 32.11,44.35 33.31,44.35 v2(33.66,43.99) 33.82,43.84 37.53,43.84 RV417.1
DMIC_CLK_R: length 264.1
  TOP w0.102: v1(236.99,13.11) 236.13,13.98 v1(236.13,20.38) ; v1(67.14,38.81) 67.14,39.21 65.51,40.84 59.05,40.84 56.75,43.15 v2(47.89,43.15) 47.05,43.99 41.15,43.99 CV754.1 40.21,43.99 39.25,43.99 RV417.2
  IN3 w0.102: v1(236.13,20.38) 235.66,20.85 220.41,20.85 220.06,21.2 210.14,21.2 209.26,20.31 198.24,20.31 197.7,20.85 197.7,21.77 193.48,25.99 180.83,25.99 174.55,32.27 173.18,32.27 171.69,33.76 171.69,36.69 168.24,40.15 159.67,40.15 158.96,40.86 112.15,40.86 112.07,40.93 109.68,40.93 108.44,39.7 108.44,37.69 106.65,35.9 105.12,35.9 v1(105.04,35.82)
  BOTTOM w0.102: v1(67.14,38.81) 67.15,38.81 67.5,38.47 67.5,38.23 71.27,34.46 74.01,34.46 74.67,35.12 74.67,37.34 75.18,37.85 77.95,37.85 79.33,36.46 83.04,36.46 84.47,35.03 84.47,31.76 85.18,31.05 89.23,31.05 92.33,34.15 102.7,34.15 104.38,35.82 v1(105.04,35.82) ; JTB1.36 264.1,10.68 263.6,11.18 261.73,11.18 261.48,10.93 256.88,10.93 256.59,11.22 251.36,11.22 250.89,10.75 239.89,10.75 237.96,12.68 237.32,12.68 236.99,13.01 v1(236.99,13.11)
DMIC_CLK_RA: length 3.6
  TOP w0.102: U15.12 28.65,43.99 28.87,44.21 29.49,44.21 RA96.1 29.81,43.74 v2(30.75,42.81)
DP_PCH_HPD: length 277.2
  TOP w0.089: v1(275.74,30.96) v2(275.2,30.96)
  IN2 w0.089: 269.09,42.2 269.09,42.12 269.11,42.11 269.11,41.77 269.49,41.39 269.49,39.73 269.82,39.41 269.82,37.88 270.21,37.5 v1(271.54,37.5) 272.43,38.39 273.36,38.39 275.4,36.35 275.4,35.68 275.83,35.25 275.83,33.96 276.05,33.75 276.05,33.75 276.07,33.73 276.23,33.73 276.52,33.45 276.52,32.32 275.74,31.54 v1(275.74,30.96)
  IN2 w0.102: 269.09,42.2 269.09,43.23 267.99,44.34 265.03,44.34 264.11,43.42 261.61,43.42 261.22,43.8 260.39,43.8 258.69,45.5 258.69,48.85 258.27,49.26 250.55,49.26 249.89,49.92 239.54,49.92 232.86,43.25 113.66,43.25 107.55,37.14 102.8,37.14 99.01,40.93 93.39,40.93 90.93,38.47 74.63,38.47 74.31,38.79 72.95,38.79 72,37.84 71.6,37.84 69.78,39.66 62.16,39.66 61.75,40.06 56.05,40.06 54.04,42.07 48.95,42.07 45.57,45.45 45.57,46.99 v1(42.05,50.5)
  BOTTOM w0.089: U7.K38 271.19,37.15 v1(271.54,37.5) ; U7.C22 274.67,30.56 275.07,30.96 v1(275.74,30.96)
  BOTTOM w0.102: v1(42.05,50.5) 41.73,50.82 36.74,50.82 36.04,50.12 RV411.1
DPLL_REF_CLK: length 122.5
  IN3 w0.089: v1(177.11,88.21) 177.4,88.51 177.5,88.51 177.61,88.61 179.89,88.61 181.54,86.96 181.93,86.96 181.95,86.95 181.96,86.95 ; 264.58,38.89 264.58,38.77 264.41,38.61 264.41,36.7 264.33,36.62 264.17,36.62 v1(264.04,36.75)
  IN3 w0.127: 264.58,38.89 264.58,41.48 263.05,43.01 261.64,43.01 261.06,42.43 260.02,42.43 257.17,45.28 241.82,45.28 241.09,46.01 240.71,46.01 240.58,45.88 240.2,45.88 240.07,46.01 239.69,46.01 239.56,45.88 239.18,45.88 239.05,46.01 238.67,46.01 238.54,45.88 238.16,45.88 238.03,46.01 237.65,46.01 237.52,45.88 237.14,45.88 237.01,46.01 236.63,46.01 236.5,45.88 236.12,45.88 235.99,46.01 235.61,46.01 235.48,45.88 235.1,45.88 234.97,46.01 234.59,46.01 234.46,45.88 234.07,45.88 233.95,46.01 233.56,46.01 233.43,45.88 233.05,45.88 232.92,46.01 232.54,46.01 232.41,45.88 232.03,45.88 231.9,46.01 231.52,46.01 231.39,45.88 231.01,45.88 230.88,46.01 227.77,46.01 216.82,56.95 214.8,56.95 203.9,67.85 198.94,67.85 197.56,69.23 187.54,69.23 185.07,71.7 185.07,84.32 182.44,86.95 181.96,86.95
  BOTTOM w0.089: U6.AE6 v1(177.11,88.21)
  BOTTOM w0.102: U7.AF36 264.23,36.56 v1(264.04,36.75)
DPLL_REF_CLK#: length 122.5
  IN3 w0.089: 181.96,87.2 181.94,87.2 181.92,87.18 181.63,87.18 179.98,88.83 177.52,88.83 177.41,88.73 177.28,88.73 177.11,88.9 v1(177.11,89.02) ; v1(263.99,36.19) 263.99,36.2 264.19,36.4 264.42,36.4 264.63,36.61 264.63,38.52 264.81,38.7 264.81,38.86 264.83,38.88 264.83,38.89
  IN3 w0.127: 181.96,87.2 182.55,87.2 185.33,84.43 185.33,71.81 187.65,69.49 197.67,69.49 199.04,68.11 204.01,68.11 214.91,57.21 216.93,57.21 227.87,46.27 241.2,46.27 241.93,45.53 257.27,45.53 260.12,42.69 260.95,42.69 261.53,43.26 263.15,43.26 264.83,41.59 264.83,38.89
  BOTTOM w0.089: U6.AC6 v1(177.11,89.02)
  BOTTOM w0.102: U7.AF35 264.22,36.27 264.06,36.27 v1(263.99,36.19)
DRAMRST_CNTRL_PCH: length 16.2
  TOP w0.102: RH53.1 273.89,13.6 273,13.6 272.6,13.99 v2(271.99,13.99) v3(271.15,13.99)
  GND1 w0.102: v3(271.15,13.99) 270.88,13.99 v5(270.77,13.88)
  IN1 w0.076: v4(269.63,24.22) 269.63,24.11 269.94,23.81 269.94,23.49 269.66,23.21 269.66,20.58 270.01,20.23 270.01,19.66
  IN1 w0.102: 270.01,19.66 270.01,18.64 269.89,18.52 269.89,14.37 270.38,13.88 v5(270.77,13.88)
  GND3 w0.089: v4(269.63,24.22) 269.63,24.63 v7(269.62,24.65)
  BOTTOM w0.089: v7(269.62,24.65) 269.89,24.65 U7.N8
DRAMRST_CNTRL_S3: length 166.6
  TOP w0.089: v3(168.34,17.03) 168.08,17.03 167.97,16.91 167.53,16.91 UE1.M6
  GND1 w0.076: v3(168.34,17.03) v5(167.96,17.03)
  IN1 w0.076: v5(167.96,17.03) 167.52,16.58 165.6,16.58 165.42,16.4 163.4,16.4 162.91,16.88 162.91,17.03 162.07,17.88 162.07,18.8 161.84,19.03 161.84,20.33 160.65,21.52
  IN1 w0.102: v1(137.45,61.55) 137.7,61.3 137.7,54.66 148.51,43.86 148.51,34.27 151.65,31.12 151.65,27.73 150.4,26.49 150.4,23.96 151.34,23.02 151.34,22.11 151.99,21.46 160.59,21.46 160.65,21.52
  BOTTOM w0.102: RU54.1 137.01,61.99 v1(137.45,61.55) ; v1(137.45,61.55) 137.44,61.54 132.1,61.54 128.27,57.71 128.27,54.11 129.37,53 176.93,53 186.09,62.16 QD2.2 184.19,70.17 QD1.2 ; v1(137.45,61.55) 139.28,61.55 140.54,62.81 v2(140.54,63.62) RU62.2 CU39.1 140.54,67.83 141.25,68.54 QU3.2
DSP_PD#: length 149
  TOP w0.102: v1(143.83,17.65) 143.83,17.7 144.18,18.05 UE36.17 ; v1(36.46,29.37) 36.46,29.13 36.26,28.93 35.55,28.93 35.34,29.13 35.34,30.72 35.55,30.92 v2(35.55,33.03) 35.55,33.21 35.08,33.68 29.05,33.68 28.88,33.85 24.3,33.85 23.99,33.54 RA91.2 23.2,33.28 22.83,32.91 20.95,32.91 20.81,32.77 20.81,31.28 20.48,30.95 20.1,30.95 19.67,30.51 U12.17
  IN3 w0.102: v4(40.85,28.48) 41.37,28.99 42.52,28.99 42.73,28.78 48.64,28.78 48.86,28.99 53.57,28.99 56.2,31.62 57.81,31.62 58.08,31.35 58.08,28.93 59.29,27.72 63.59,27.72 65.07,29.2 74.03,29.2 75.21,30.38 81.8,30.38 82.36,29.81 82.99,29.81 85.05,27.76 90.23,27.76 94.21,23.78 99.7,23.78 103.84,19.64 116.46,19.64 116.85,19.25 121.8,19.25 121.89,19.16 123.48,19.16 124.19,19.87 126.94,19.87 127.52,19.29 127.88,19.29 128.28,19.7 140.63,19.7 142.92,17.41 143.58,17.41 v1(143.83,17.65)
  IN4 w0.102: v4(40.85,28.48) 40.85,30.03 39.97,30.92 36.89,30.92 36.46,30.49 v1(36.46,29.37)
DSWODVREN: length 6.1
  TOP w0.089: 277.14,25.91 276.78,25.55 v2(276.78,25.28) v1(276.78,24.77)
  TOP w0.102: 277.14,25.91 277.62,26.38 RH122.2 RH119.2
  BOTTOM w0.089: v1(276.78,24.77) 276.53,24.52 275.03,24.52 274.77,24.78 274.42,24.78 274.33,24.87 U7.C8
EAPD#: length 179.1
  TOP w0.089: UE1.D6 163.19,17.16 v3(162.94,16.91)
  TOP w0.102: v1(156.05,14.85) v2(157.11,14.85) 157.25,14.85 157.81,15.41 RE28.2 158.92,15.88 v1(159.11,15.69) ; U15.14 26.75,45.27 27.06,45.58 28.94,45.58 29.12,45.76 v1(29.12,46.04)
  GND1 w0.089: v4(163.45,17.05) 163.31,16.91 v3(162.94,16.91)
  IN2 w0.102: v1(29.12,46.04) 31.05,46.04 33.8,43.29 36.53,43.29 37.75,42.07 39.41,42.07 45.04,36.44 49.54,36.44 49.91,36.08 52.45,36.08 53.19,35.34 59.69,35.34 60.1,34.93 62.85,34.93 65.26,32.51 65.26,31 66.34,29.93 71.52,29.93 72.26,30.67 80.94,30.67 81.67,29.93 93.1,29.93 93.59,30.41 98.59,30.41 108.05,20.95 116.54,20.95 117.15,20.34 122.92,20.34 123.31,20.73 127.14,20.73 127.54,20.33 146.67,20.33 147.16,19.85 147.81,19.85 149.68,17.98 153.52,17.98 154.47,17.03 154.47,15.88 155.51,14.85 v1(156.05,14.85)
  IN3 w0.076: v4(163.45,17.05) 162.9,17.6 161.8,17.6 161.48,17.28 161.48,16.39 161.19,16.1 160.65,16.1
  IN3 w0.102: v1(29.12,46.04) 27.27,44.18 27.27,40.52 26.48,39.74 19.22,39.74 16.14,36.66 16.14,35.98 v1(15.1,34.93) ; v1(159.11,15.69) 159.51,16.1 160.65,16.1
  BOTTOM w0.254: RA99.1 14.72,35.31 v1(15.1,34.93)
EC_BATT_PRS#: length 104.7
  TOP w0.076: 167.44,14.55 167.34,14.66 UE1.M1
  TOP w0.089: 167.44,14.55 v3(167.7,14.3)
  TOP w0.102: CE13.1 157.86,19.24 158.79,19.24 159.86,18.16 v1(159.86,17.93)
  TOP w0.254: PR113.2 98.84,24.93 v3(98.87,24.95) 99.33,25.41 v2(102.55,25.41) 103.54,24.42 PR114.1 ; PC228.1 v1(84.67,25.92)
  GND1 w0.076: v3(167.7,14.3) v5(167.7,13.93)
  GND1 w0.254: v3(98.87,24.95) 98.25,24.95 v4(98.06,25.14)
  IN1 w0.076: v5(167.7,13.93) 167.57,14.07 165.91,14.07 165.75,14.23 165.01,14.23 164.37,14.87 163.11,14.87 162.79,14.55 162.47,14.55 161.73,15.29 161.73,16.23 161.43,16.53 161.43,16.77 161.2,17 161.12,17 160.71,17.41 160.65,17.41
  IN1 w0.102: 160.65,17.41 160.38,17.41 v1(159.86,17.93)
  IN3 w0.102: v1(159.86,17.93) 159.45,18.35 159.45,18.9 158.93,19.41 157.94,19.41 157.11,18.59 149.8,18.59 149.15,19.24 148.34,19.24 148.03,19.55 146.55,19.55 146.23,19.86 141.93,19.86 141.08,20.71 129.19,20.71 128.99,20.92 122.49,20.92 121.88,20.3 117.35,20.3 116.93,20.72 106.26,20.72 101.84,25.14 v4(98.06,25.14)
  IN4 w0.254: v4(98.06,25.14) 97.1,24.19 92.92,24.19 90.12,27 85.47,27 84.67,26.2 v1(84.67,25.92)
EC_CRY2: length 4.8
  TOP w0.089: UE1.K1 166.34,14.6 166.34,13.6
  TOP w0.102: 166.34,13.6 166.34,13.5 CE18.1 RE40.1 RE39.2 165.78,11.19 165.31,10.73 v2(164.92,10.73)
EC_ENVDD: length 111.5
  TOP w0.089: UE1.A10 161.35,19.16
  TOP w0.102: 161.35,19.16 v3(161.03,19.48)
  GND1 w0.076: 160.65,19.74 160.77,19.74 v3(161.03,19.48)
  GND1 w0.102: 160.65,19.74 v4(160.08,19.74)
  IN3 w0.102: v1(68.87,30.74) 69.27,30.34 74.02,30.34 74.87,31.19 76.89,31.19 77.16,31.46 82.75,31.46 83.59,30.63 87.61,30.63 88.9,29.33 90.89,29.33 94.27,25.95 101.88,25.95 106.51,21.33 117.19,21.33 117.61,20.91 121.63,20.91 122.24,21.53 127.14,21.53 127.83,22.21 128.55,22.21 129.44,21.32 141.33,21.32 142.18,20.47 146.49,20.47 146.81,20.15 148.28,20.15 148.59,19.85 149.41,19.85 150.05,19.2 156.84,19.2 157.82,20.18 159.65,20.18 v4(160.08,19.74)
  BOTTOM w0.102: v1(68.87,30.74) 68.36,30.74 67.6,31.5 v2(67.6,31.78) 66.67,32.71 66.67,33.53 66.02,34.18 66.02,36.78 RV415.1 65.87,39.08 DV19.2
EC_INV_PWM: length 93.2
  TOP w0.076: UE1.K8 166.75,18.16 v1(166.79,18.12)
  TOP w0.102: v3(84.14,30.12) v2(84.14,28.86)
  GND1 w0.102: v3(84.14,30.12) 84.14,29.68 v4(83.96,29.5)
  IN3 w0.076: 160.65,17.2 160.72,17.2 161.78,18.27 161.78,18.78 162.19,19.18 165.42,19.18 166.48,18.12 v1(166.79,18.12)
  IN3 w0.102: v4(83.96,29.5) 84.28,29.81 87.27,29.81 88.57,28.52 90.39,28.52 94.38,24.53 98.52,24.53 98.72,24.73 101.67,24.73 106.15,20.25 116.71,20.25 117.1,19.86 122.19,19.86 122.84,20.51 128.82,20.51 129.02,20.31 140.91,20.31 142.41,18.8 144.26,18.8 144.49,18.58 146.01,18.58 146.39,18.19 146.75,18.19 147.05,18.5 149.31,18.5 149.7,18.12 156.98,18.12 157.38,17.72 158.92,17.72 159.44,17.2 160.65,17.2
EC_ON: length 22.9
  TOP w0.089: 164.86,14.16 164.86,14.58 UE1.G1
  TOP w0.102: RE340.1 179.58,17.04 v8(179.58,16.16) 179.58,14.95 v1(179.51,14.88) ; 164.86,14.16 164.86,13.63 v1(164.49,13.25) 164.3,13.07 164.3,12.5 CE23.1
  IN3 w0.102: v1(164.49,13.25) 164.49,13.64 164.99,14.14 167.13,14.14 167.76,14.77 169.91,14.77 170.6,14.08 171.33,14.08 171.66,14.42 171.66,14.8 172.02,15.16 179.23,15.16 v1(179.51,14.88)
EC_ON_CTRL#: length 22.7
  TOP w0.089: v1(163.81,15.69) 164.03,15.92 164.03,16.33 164.12,16.41 164.53,16.41 UE1.G5
  TOP w0.102: v1(172.14,16.19) 173.31,15.02 173.58,15.02 174.27,14.33 174.27,12.62 174.75,12.14 DE8.2 175.26,11.35 175.38,11.23 CE26.1 RE49.2 177.16,11.35 DE9.2 178.43,10.84 178.64,10.64 179.44,10.64 v2(179.47,10.6)
  IN3 w0.076: 168.78,16.87 168.75,16.9 166.42,16.9 165.56,16.04 164.45,16.04 164.11,15.69 v1(163.81,15.69)
  IN3 w0.102: v1(172.14,16.19) 171.55,15.6 170.05,15.6 168.78,16.87
EC_PECI: length 2.8
  TOP w0.089: 165.03,14.51 165.03,14.91 UE1.H2
  TOP w0.102: RE38.1 165.06,12.87 165.06,14.48 165.03,14.51
EC_RST#: length 3.9
  TOP w0.089: 166.52,21.72 166.52,21.15 166.28,20.91 UE1.K13
  TOP w0.102: CE14.2 RE11.2 166.81,22.87 166.52,22.58 166.52,21.72
EC_RUNTIME_SCI#: length 138.7
  TOP w0.089: UE1.N6 167.98,17.16 168.13,17.32 168.46,17.32 168.5,17.28
  TOP w0.102: v3(169.81,17.24) 169.65,17.08 v2(169.4,17.08) 169.1,17.08 168.9,17.28 168.5,17.28 ; v3(267.47,14.18) 267.52,14.13 267.52,13.72 267.47,13.67 RPH9.5
  GND1 w0.102: v4(170.22,17.17) 170.15,17.24 169.82,17.24 v3(169.81,17.24) ; v3(267.47,14.18) 267.47,13.7 v5(267.55,13.62)
  IN1 w0.076: 272.37,19.06 272.37,19.5 271.83,20.04 271.83,21.27 272.49,21.93 272.49,26.39 272.17,26.71 272.17,26.73 272.11,26.78 v4(271.81,26.78)
  IN1 w0.102: v5(267.55,13.62) 267.73,13.44 270.66,13.44 271.24,12.87 271.51,12.87 272.39,13.75 272.39,14.98 273.29,15.88 273.29,16.34 272.37,17.27 272.37,19.06
  IN2 w0.102: v4(170.22,17.17) 170.52,17.46 181.79,17.46 182.83,18.5 192.74,18.5 193.84,19.6 198.92,19.6 200.33,21.01 232.7,21.01 233.16,20.55 233.16,19.98 234.82,18.32 v4(234.81,18.32)
  IN4 w0.089: v4(271.81,26.78) 271.78,26.76 270.22,26.76 269.84,27.14 266.5,27.14 266.2,26.83 266.2,24.01 265.47,23.28 265.47,22.01 263.59,20.14 262.82,20.14 262.34,19.66
  IN4 w0.102: 262.34,19.66 262.12,19.44 260.63,19.44 259.68,18.49 253.08,18.49 252.91,18.31 252.44,18.31 250.75,16.62 243.88,16.62 242.69,17.81 241.49,17.81 241.08,17.41 237.42,17.41 236.51,18.32 v4(234.81,18.32)
  GND3 w0.089: v4(271.81,26.78) 271.97,26.95 v7(271.97,27.16)
  BOTTOM w0.089: v7(271.97,27.16) 272.07,27.06 272.45,27.06 272.59,27.2 U7.G15
EC_RX: length 124.6
  TOP w0.076: v1(166.8,18.65) 166.79,18.66 UE1.K9
  IN2 w0.076: v1(166.8,18.65) 167.27,19.13 168.77,19.13 168.78,19.11
  IN2 w0.102: v4(229.08,23.1) 228.59,22.6 204.27,22.6 203.35,21.67 200.12,21.67 198.66,20.21 193.59,20.21 192.49,19.11 168.78,19.11
  IN4 w0.102: v6(279.95,38.11) 279.57,38.11 279.57,38.11 278.69,38.11 275.97,35.39 273.95,35.39 271.97,33.41 269.05,33.41 268.6,32.96 268.6,32.52 268.1,32.01 267.4,32.01 267.14,32.27 264.41,32.27 264.04,31.89 262.46,31.89 261.32,30.75 257.95,30.75 257.38,30.18 257.38,29.5 256.66,28.79 256.4,28.79 255.08,27.46 249.31,27.46 244.68,22.83 229.35,22.83 v4(229.08,23.1)
  GND3 w0.102: v6(279.95,38.11) 280.14,38.11 v7(280.33,37.92)
  BOTTOM w0.102: v7(280.33,37.92) 280.45,37.8 JSSD.51
EC_SMB_CK1: length 89.8
  TOP w0.089: UE1.A8 161.73,18.21 161.24,18.21
  TOP w0.102: v2(101.45,23.5) 101.91,23.96 v3(102.4,23.96) ; RPH19.6 158.4,17.54 v1(158.62,17.32) 159.57,17.32 159.78,17.52 160.87,17.52 160.93,17.58 160.93,18.11 161.03,18.21 161.24,18.21
  GND1 w0.102: v4(101.6,23.72) 101.84,23.96 v3(102.4,23.96)
  IN3 w0.102: v1(158.62,17.32) 158.4,17.1 157.72,17.1 156.9,17.91 149.33,17.91 149.03,17.61 144.79,17.61 143.98,18.42 143.72,18.42 143.57,18.58 142.35,18.58 140.82,20.1 128.49,20.1 128.28,20.31 122.92,20.31 122.28,19.66 117.02,19.66 116.63,20.05 104.01,20.05 101.44,22.62 101.44,23.56 v4(101.6,23.72) 101.41,23.91 101.41,24.17 101.14,24.44 98.92,24.44 98.72,24.24 94.38,24.24 90.38,28.24 86.32,28.24 86.04,28.52 86.04,29.1 v1(86.22,29.28)
  BOTTOM w0.254: PR231.1 84.33,28.35 85.68,28.35 86.1,28.77 86.1,29.17 v1(86.22,29.28)
EC_SMB_CK1_R: length 2
  BOTTOM w0.254: PU200.9 82.89,28.34 PR231.2
EC_SMB_CK2_PX: length 12.2
  TOP w0.102: RV325.2 v1(214.77,76.39)
  BOTTOM w0.089: 216.58,77.32 217.66,78.41 217.66,78.49 217.9,78.72 217.9,80.25 UV1.T4
  BOTTOM w0.102: QV21.1 212.36,73.24 212.85,73.73 212.85,75 v2(214.03,76.18) 214.23,76.39 v1(214.77,76.39) 215.48,77.1 216.36,77.1 216.58,77.32
EC_SMB_DA1: length 89.1
  TOP w0.089: UE1.A7 161.73,17.6 161.24,17.6
  TOP w0.102: 161.24,17.6 160.95,17.32 159.86,17.32 159.66,17.11 159.03,17.11 v1(158.65,16.73) 158.54,16.73 158.29,16.98 157.98,16.98 RPH19.5 ; v3(100.37,23.96) 100.37,24.43 v2(99.88,24.91)
  GND1 w0.102: v4(101.02,23.72) 100.61,23.72 v3(100.37,23.96)
  IN3 w0.102: v1(158.65,16.73) 158.49,16.89 157.63,16.89 156.81,17.71 149.41,17.71 149.11,17.41 144.7,17.41 143.9,18.22 143.64,18.22 143.49,18.37 142.27,18.37 140.74,19.9 128.4,19.9 128.2,20.1 123.01,20.1 122.36,19.46 116.93,19.46 116.55,19.85 103.93,19.85 101.24,22.53 101.24,23.51 v4(101.02,23.72) 101.21,23.91 101.21,24.08 101.05,24.24 99,24.24 98.8,24.04 94.3,24.04 90.3,28.04 86.24,28.04 85.84,28.43 85.84,29.08 v1(85.63,29.28)
  BOTTOM w0.254: v1(85.63,29.28) 85.75,29.17 85.75,28.92 85.53,28.7 84.33,28.7 PR230.1
