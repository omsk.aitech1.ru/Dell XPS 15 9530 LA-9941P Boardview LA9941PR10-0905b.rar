# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BMON_OUT: length 2.9
  TOP w0.254: PR281.1 116.05,18.8 116.14,18.71 v2(116.14,18.46) 116.14,18.27 115.55,17.68 PU202.6
BOOT1: length 3.6
  BOTTOM w0.203: PU700.18 125.6,113.67 126.17,113.1 126.36,113.1
  BOTTOM w0.508: 126.36,113.1 126.49,112.97 v2(126.49,112.43) 126.49,111.64 PR740.1
BOOT2: length 1.7
  BOTTOM w0.102: v2(118.68,113.95) 119.35,114.63 PR713.1
BOOT_1.35V: length 5
  TOP w0.203: PU400.18 128.03,17.44 v9(128.05,17.41)
  BOTTOM w0.102: v9(128.05,17.41) 128.57,17.41 128.87,17.71 v2(128.87,18.19)
  BOTTOM w0.508: PR400.2 127.26,18.74 128.05,17.95 v9(128.05,17.41)
BST1_3V: length 1.7
  TOP w0.102: v2(44.13,29.55) 43.28,30.4 PR307.1
BST1_5V: length 1.5
  TOP w0.102: PC311.1 55.05,31.25 v2(55.59,31.8)
BST_3V:
  vias: v2(45.82,31.39)
BST_5V: length 2.4
  TOP w0.203: 50.88,31.97 PU300.17
  TOP w0.508: PR308.1 52.49,29.98 52.21,30.26 52.21,30.8 51.91,31.1
  vias: v2(51.51,31.63)
BST_+1.5VRUN: length 1.9
  TOP w0.102: v1(189.93,121.83) 189.93,122.42 v2(189.81,122.54)
  BOTTOM w0.203: v1(189.93,121.83) 189.93,122.12 189.67,122.37 PU600.5
BST_+V1.05V: length 1.7
  TOP w0.102: v2(233.07,63.93) 232.41,64.59 PR501.1
  vias: v9(232.15,66.17) v9(232.79,66.17)
BT_RADIO_DIS#: length 47.8
  TOP w0.089: v1(261.1,23.29) 261.1,23.36 260.44,24.02 259.71,24.02 259.22,23.53 257.83,23.53 v2(256.76,22.46) 256.51,22.21 256.51,22.05 255.22,20.76 RH174.2
  IN1 w0.076: 258.17,19.66 258.17,20.03 258.81,20.68 259.44,20.68 260.67,21.9 260.67,22.85 v1(261.1,23.29)
  IN1 w0.102: v4(259.09,14.59) 259.07,14.62 259.07,15.14 258.17,16.04 258.17,19.66
  IN2 w0.102: v4(259.09,14.59) 259.96,14.59 260.45,15.09 263.64,15.09 264.66,14.07 267.76,14.07 268.01,13.82 271.1,13.82 271.53,13.39 274.32,13.39 v4(274.92,13.98)
  IN4 w0.102: v6(266.03,10.18) 266.19,10.02 267.51,10.02 268.03,10.54 269.73,10.54 270.03,10.83 271.24,10.83 272.51,12.1 273,12.1 274.88,13.98 v4(274.92,13.98)
  GND3 w0.102: v7(266.5,10.18) v6(266.03,10.18)
  BOTTOM w0.102: U7.AN6 261.4,23.59 v1(261.1,23.29) ; JTB1.24 v7(266.5,10.18)
BTST:
  vias: v2(76.57,27.92)
BUF_CPU_RST#: length 11.9
  TOP w0.089: v1(142.17,96.46) 142.17,96.96
  TOP w0.102: 142.17,96.96 v2(142,97.14)
  BOTTOM w0.089: v1(142.17,96.46) 142.42,96.46 143.63,97.67 144.16,97.67 U6.L54
  BOTTOM w0.102: RU48.2 137.03,99.3 137.03,97.23 137.29,96.97 RU37.2 140.45,96.46 v1(142.17,96.46)
BUFO_CPU_RST#: length 17.1
  BOTTOM w0.102: RU48.1 RU11.2 135.06,101.37 135.06,104.66 134.55,105.16 v2(134.55,106.66) 134.55,108.85 135.13,109.42 136.9,109.42 137.36,109.87 RU42.2 ; RU48.1 RU13.1 ; RU48.1 134.38,99.86 134.12,100.13 UU2.4
C1_C2: length 4.1
  BOTTOM w0.089: U6.C1 182.31,103.32
  BOTTOM w0.102: 182.31,103.32 183.26,103.32 v2(183.5,103.56)
  BOTTOM w0.305: U6.C2 U6.C1
C3_B2: length 6
  BOTTOM w0.089: U6.B2 180.67,104.11 182.31,105.75
  BOTTOM w0.102: v2(183.63,105.95) 182.51,105.95 182.31,105.75
  BOTTOM w0.203: U6.B2 179.66,104.09 178.81,103.24 U6.C3
CAB_DET_SINK: length 339
  TOP w0.102: v2(23.76,80.92) 23.76,79.67 v1(24.15,79.29)
  IN2 w0.089: 269.75,19.66 269.75,21.54 270.15,21.94 270.15,22.37 270.89,23.11 270.89,25.58 270.56,25.91 270.56,26.71 v1(271.05,27.2)
  IN2 w0.102: v4(184.7,16.71) 185.31,17.32 193.17,17.32 193.36,17.13 198.3,17.13 199.28,18.11 202.09,18.11 203.23,19.24 212.47,19.24 213.2,19.97 223.63,19.97 224.15,19.46 230.34,19.46 231.88,17.91 240.76,17.91 241.72,18.87 247.2,18.87 249.31,16.76 250.57,16.76 251,17.18 251.88,17.18 252.07,16.99 252.87,16.99 253.49,16.37 255.03,16.37 255.52,16.87 261.95,16.87 262.25,17.17 264.89,17.17 265.13,17.4 268.26,17.4 269.75,18.89 269.75,19.66 ; v4(152.15,19.85) 150.46,21.54 150.46,22.97 150.16,23.26 146.66,23.26 145.94,23.99 133.44,23.99 133.03,24.39 132.09,24.39 131.59,23.89 121.67,23.89 121.18,23.4 107.9,23.4 99.26,32.04 86.55,32.04 85.68,32.91 82.16,32.91 81.85,33.22 65.71,33.22 63.18,35.75 60.54,35.75 60.13,36.15 54.42,36.15 53.48,37.09 50.33,37.09 49.96,37.46 45.46,37.46 39.84,43.09 38.17,43.09 36.8,44.46 34.14,44.46 30.85,47.75 30.85,52.02 30.49,52.38 29.89,52.38 29.35,52.92 29.35,57.1 26.88,59.57 26.88,63.59 25.97,64.5 25.97,69.07 23.4,71.64 23.4,72.88 24.84,74.32 24.84,78.59 v1(24.15,79.29) 21.57,79.29 20.7,80.16 18.24,80.16 16.01,82.38 15.58,82.38 11.95,86.01 11.95,90.2 v4(12.8,91.05)
  IN3 w0.102: v4(184.7,16.71) 184.2,16.21 175.76,16.21 174.31,17.66 171.8,17.66 171.58,17.88 171.58,21.21 171.34,21.45 168.57,21.45 167.71,20.59 156.63,20.59 155.71,19.67 152.32,19.67 v4(152.15,19.85)
  GND3 w0.102: v7(12.25,91.05) v4(12.8,91.05)
  BOTTOM w0.102: QV37.2 13.74,90.55 13.56,90.37 12.93,90.37 v7(12.25,91.05) RV453.1 10.63,91.05 10.07,90.5 10.07,89.82 9.86,89.61 JMDP.4 ; U7.L15 271.05,27.48 v1(271.05,27.2) ; U11.10 24.92,80.06 v1(24.15,79.29)
CAB_DET_SINK#: length 5.8
  BOTTOM w0.102: RV452.2 14.77,89.46 QV37.1 v2(14.71,87.51)
CAPS_LED#: length 15.5
  TOP w0.076: UE1.B3 162.34,15.66 v3(162.6,15.92)
  GND1 w0.076: v3(162.6,15.92) 162.2,15.52 v4(162.2,15.48)
  IN3 w0.076: 168.78,17.18 168.65,17.05 166.36,17.05 165.49,16.19 162.86,16.19 162.2,15.52 v4(162.2,15.48)
  IN3 w0.102: 168.78,17.18 169.05,17.18 v4(169.29,16.94)
  GND3 w0.102: v4(169.29,16.94) 169.35,17 v7(169.35,17.41)
  BOTTOM w0.102: QZ24.2 169.87,22.3 RE52.2 169.01,22.22 v2(169.01,21.34) 169.01,18.27 169.35,17.93 v7(169.35,17.41)
CCD_INT: length 17.9
  TOP w0.102: v2(270.19,14.66) 270.19,14.31 270.84,13.66 v3(271.46,13.66) 272.65,13.66 273.14,13.16 RH63.1
  GND1 w0.102: v3(271.46,13.66) 271.32,13.53 v5(271.04,13.53)
  IN1 w0.076: 270.65,19.66 270.65,20.55 270.23,20.97 270.23,21.93 270.88,22.58 270.88,24.03 270.36,24.55 v4(270.36,24.9)
  IN1 w0.102: v5(271.04,13.53) 271.25,13.73 271.25,17.14 270.5,17.89 270.5,18.27 270.65,18.42 270.65,19.66
  GND3 w0.089: v4(270.36,24.9) v7(270.36,24.48)
  BOTTOM w0.089: U7.N7 270.06,24.19 v7(270.36,24.48)
CCD_INT#: length 138.7
  TOP w0.102: UE36.20 145.93,16.32 146.39,15.86 146.39,15.15 v3(146.16,14.92)
  GND1 w0.102: v3(146.16,14.92) v5(145.81,14.92)
  IN1 w0.102: v4(143.04,14.66) 143.29,14.92 v5(145.81,14.92)
  IN2 w0.102: v4(256.55,10.27) 256.55,10.78 256.09,11.23 254.13,11.23 252.09,13.28 251.41,13.28 251.24,13.11 251.24,10.02 250.73,9.51 250.18,9.51 250.06,9.63 246.42,9.63 244.82,11.23 236.64,11.23 236.23,11.63 234.74,11.63 234.13,11.03 221.22,11.03 216.83,15.42 214.15,15.42 210.13,11.4 190.55,11.4 190.33,11.63 188.11,11.63 187.62,11.14 187.62,10.83 187.36,10.57 184.16,10.57 184.12,10.62 155.66,10.62 154.87,11.4 154.87,12.32 152.12,15.07 149.9,15.07 148.3,13.47 144.36,13.47 144,13.83 144,14.38 143.72,14.66 v4(143.04,14.66)
  IN4 w0.102: v6(260.77,10.02) 260.73,10.02 260.59,9.88 256.94,9.88 v4(256.55,10.27)
  GND3 w0.102: v6(260.77,10.02) 260.79,10.04 v7(261.3,10.04)
  BOTTOM w0.102: JTB1.50 v7(261.3,10.04)
CDCLK_REQ#: length 67
  TOP w0.102: v2(263.57,18.77) 262.99,18.19 v3(262.46,18.19) 262.46,17.9 261.58,17.03 RPH25.5
  GND1 w0.102: v4(263.14,18.05) 263.01,18.19 v3(262.46,18.19)
  IN2 w0.089: v4(267.42,21.08) 267.6,20.9 268.77,20.9 269.1,20.57 269.1,19.66
  IN2 w0.102: v4(263.14,18.05) 263.22,18.12 265.57,18.12 265.67,18.22 268.09,18.22 269.1,19.23 269.1,19.66
  IN4 w0.089: 265.44,19.66 265.62,19.84 265.62,20.25 265.9,20.52 267.85,20.52 267.94,20.61 271.05,20.61 271.4,20.96 271.73,20.96 272.02,20.66 273.76,20.66 v6(273.84,20.74)
  IN4 w0.102: v4(263.14,18.05) 263.43,18.33 263.61,18.33 264.79,19.51 265.29,19.51 265.44,19.66 ; v6(282.19,20.92) 282.19,15.41 280.3,13.52 278.43,13.52 274.67,9.76 273.01,9.76 272.32,9.07 265.6,9.07 v6(265.23,9.43)
  GND3 w0.089: v4(267.42,21.08) 267.79,20.71 v7(267.79,20.53) ; v6(273.84,20.74) 273.93,20.83 v7(274.3,20.83)
  GND3 w0.102: v7(282.19,21.54) v6(282.19,20.92) ; v7(264.9,10.09) 264.9,9.76 v6(265.23,9.43)
  BOTTOM w0.089: v7(267.79,20.53) 267.79,21.23 267.53,21.49 267.53,21.78 267.73,21.99 267.73,22 267.73,22 267.73,22.45 U7.V3
  BOTTOM w0.102: v7(274.3,20.83) 276.59,20.83 278.12,19.31 280.21,19.31 280.45,19.55 280.45,20.74 281.25,21.54 v7(282.19,21.54) ; JTB1.32 v7(264.9,10.09)
CELL: length 5.5
  TOP w0.102: v1(84.71,26.94) 84.92,26.94 v2(85.46,27.48)
  TOP w0.254: PR224.1 v1(84.71,26.94)
  BOTTOM w0.254: PU200.10 81.96,27.84 82.99,26.81 PQ207.1 84.58,26.81 v1(84.71,26.94)
CFG0: length 22.3
  TOP w0.089: v1(148.33,87.7) 147.89,88.15 143.19,88.15 142.17,89.16 142.17,89.29
  TOP w0.102: 142.17,89.29 139.98,91.49 v2(139.98,91.85) 139.98,93.78 138.01,95.75 138.01,96.97 137.53,97.45 137.53,99.76 137.82,100.05 JXDP.9
  BOTTOM w0.089: v1(148.33,87.7) 147.95,87.32 U6.AG49
CFG1: length 19.1
  TOP w0.089: v1(147.52,88.54) 147.17,88.89 v2(147.17,91.17) 147.17,91.98 147,92.15 146.68,92.15 146.47,92.36 146.47,93.68 145.52,94.62 145.29,94.62 145.08,94.83 145.08,95.24 145.29,95.45 145.67,95.45 145.86,95.64 145.86,96.15 145.78,96.23 144.27,96.23
  TOP w0.102: JXDP.11 141.22,100.55 142.52,99.25 142.52,97.14 143.43,96.23 144.27,96.23
  BOTTOM w0.089: v1(147.52,88.54) 147.87,88.89 U6.AD49
CFG2: length 21.2
  TOP w0.089: 142.75,100.17 142.75,97.23 143.55,96.42 146.03,96.42 146.18,96.27 146.18,95.59 146.56,95.21 146.56,94.62 146.37,94.43 146.37,94.05 146.62,93.8 147.19,93.8 147.74,93.25 147.74,92.41 147.99,92.15 147.99,91.2 148.26,90.93 RU77.1 149.14,89.87 v2(148.94,89.66) 148.76,89.48 147.72,89.48 v1(147.59,89.35)
  TOP w0.102: 142.75,100.17 141.37,101.55 JXDP.15
  BOTTOM w0.089: v1(147.59,89.35) 147.85,89.61 147.85,89.73 U6.AC49
CFG3: length 24.6
  TOP w0.089: v1(147.52,87.73) 147.12,87.32 143.62,87.32 142.17,88.76
  TOP w0.102: JXDP.17 138.43,102.05 138.11,102.37 137.79,102.37 137.31,101.89 137.31,97.34 137.81,96.85 137.81,95.67 138.73,94.74 138.73,92.21 140.86,90.08 ; 140.86,90.08 142.17,88.76 ; 140.86,90.08 v2(140.87,90.08)
  BOTTOM w0.089: v1(147.52,87.73) 147.87,88.07 U6.AE49
CFG4: length 36.5
  TOP w0.102: v1(137.91,90.24) v2(138.42,90.75) 138.52,90.85 138.52,94.66 137.6,95.58 137.6,96.76 137.11,97.26 137.11,102.63 137.6,103.13 137.6,104.23 138.16,104.78 138.49,104.78 138.73,104.55 JXDP.27 141.58,104.55 v1(142.02,104.99)
  IN3 w0.089: v1(146.79,91.76) 145.76,90.73 143.1,90.73 142.78,90.41
  IN3 w0.102: v1(137.91,90.24) 142.61,90.24 142.78,90.41
  BOTTOM w0.089: U6.Y50 v1(146.79,91.76)
  BOTTOM w0.102: RU115.1 136.92,106.05 141.36,106.05 142.02,105.39 v1(142.02,104.99)
CFG5: length 33.2
  TOP w0.102: v1(141.39,104.96) 141.3,105.05 JXDP.29 137.98,105.05 137.4,104.46 137.4,103.21 136.9,102.72 136.9,97.18 137.4,96.68 137.4,95.5 138.32,94.58 138.32,91.22 137.23,90.14 v2(137.23,89.86) 137.23,89.76 137.6,89.39 v1(137.91,89.39)
  IN3 w0.089: 145.81,89.77 147.16,89.77 v1(147.55,90.17)
  IN3 w0.102: 145.81,89.77 145.58,89.55 138.07,89.55 v1(137.91,89.39)
  BOTTOM w0.089: v1(147.55,90.17) 147.87,90.49 U6.AB49
  BOTTOM w0.102: v1(141.39,104.96) 141.39,105.44 141.26,105.57 RU85.1
CFG6: length 32.8
  TOP w0.102: v1(142.11,107.13) 142.11,106.69 v2(141.8,106.38) 141.47,106.05 JXDP.33 138.23,106.05 137.2,105.02 137.2,103.3 136.7,102.8 136.7,97.09 137.2,96.59 137.2,95.13 v1(137.91,94.41)
  IN3 w0.089: 142.34,95.32 142.95,95.32 143.29,94.98 144.02,94.98 144.37,94.62 145.64,94.62 146.09,94.17 v1(146.09,93.39)
  IN3 w0.102: 142.34,95.32 138.83,95.32 v1(137.91,94.41)
  BOTTOM w0.089: U6.V51 v1(146.09,93.39)
  BOTTOM w0.102: v1(142.11,107.13) 141.47,106.49 137.8,106.49 137.7,106.59 RU86.1
CFG7: length 31.1
  TOP w0.102: v1(141.46,107.12) 141.46,106.75 141.26,106.55 JXDP.35 138.44,106.55 136.97,105.08 136.97,103.53 136.5,103.06 136.5,97 136.97,96.53 136.97,92.97 v2(137.41,92.52) v1(137.91,92.02)
  IN3 w0.089: 142.34,92.96 145.71,92.96 v1(146.09,92.58)
  IN3 w0.102: v1(137.91,92.02) 138.2,92.02 139.22,93.04 142.11,93.04 142.19,92.96 142.34,92.96
  BOTTOM w0.089: U6.W51 v1(146.09,92.58)
  BOTTOM w0.102: RU87.1 141.29,106.95 v1(141.46,107.12)
CFG8: length 28.2
  TOP w0.102: v1(133.58,89.87) 134.55,89.87 135.11,90.42 v2(135.11,90.86) 135.11,95.49 135.48,95.85 135.48,99.79 135.23,100.05 JXDP.10
  IN3 w0.089: 142.92,90.22 143.24,90.54 146.3,90.54 v1(147.56,91.8)
  IN3 w0.102: 142.92,90.22 142.5,89.8 133.65,89.8 v1(133.58,89.87)
  BOTTOM w0.089: v1(147.56,91.8) 147.87,91.49 U6.Y49
CFG9: length 23.3
  TOP w0.102: 132.32,100.01 v2(132.31,100.01) ; 132.32,100.01 132.48,100.01 133.02,100.55 JXDP.12 ; 132.32,100.01 132.18,99.87 132.18,99.36 132.32,99.22 132.32,98.74 132.18,98.6 132.18,97.69 133.06,96.81 133.06,91.78 v1(132.85,91.57)
  IN3 w0.089: v1(143.7,91.76) 142.57,91.76 142.46,91.87
  IN3 w0.102: 142.46,91.87 142.31,92.02 138.78,92.02 138.07,91.31 133.11,91.31 v1(132.85,91.57)
  BOTTOM w0.089: v1(143.7,91.76) 143.99,91.76 U6.Y54
CFG10: length 25.9
  TOP w0.102: JXDP.16 132.41,101.55 v2(132.15,101.29) 131.98,101.11 131.98,97.61 132.86,96.73 132.86,92.15 132.44,91.74 132.44,91.27 v1(132.71,91)
  IN3 w0.089: v1(144.7,91.77) 144.23,91.3 142.66,91.3 142.46,91.1
  IN3 w0.102: 142.46,91.1 132.81,91.1 v1(132.71,91)
  BOTTOM w0.089: U6.Y53 145.07,91.4 v1(144.7,91.77)
CFG11: length 27.1
  TOP w0.102: v1(131.99,91.64) 131.99,92.19 v2(132.19,92.38) 132.65,92.85 132.65,96.64 131.77,97.52 131.77,101.46 132.06,101.75 132.59,101.75 132.88,102.05 JXDP.18
  IN3 w0.089: v1(144.7,92.58) 144.26,92.14 142.55,92.14 142.46,92.22
  IN3 w0.102: 142.46,92.22 138.69,92.22 137.98,91.51 133.48,91.51 132.98,92.02 132.37,92.02 v1(131.99,91.64)
  BOTTOM w0.089: U6.W53 145.07,92.21 v1(144.7,92.58)
CFG12: length 26.8
  TOP w0.102: JXDP.28 132.54,104.55 131.16,103.17 131.16,97.27 131.76,96.67 v2(131.76,95.63) v1(131.76,94.47)
  IN3 w0.089: 142.8,94.74 143.98,94.74 144.52,94.21 v1(144.7,94.21) ; 142.63,94.91 142.34,94.91
  IN3 w0.102: v1(131.76,94.47) 132.23,94 139.03,94 139.95,94.91 142.34,94.91 ; 142.8,94.74 142.63,94.91
  BOTTOM w0.089: U6.U53 145.07,93.84 v1(144.7,94.21)
CFG13: length 30
  TOP w0.102: JXDP.30 132.15,105.05 130.96,103.85 130.96,97.17 130.64,96.85 130.64,96.08 130.92,95.8 130.92,93.44 v2(130.72,93.24) 130.41,92.93 v1(130.28,92.93)
  IN3 w0.089: v1(143.99,93.39) 143.89,93.28 142.46,93.28
  IN3 w0.102: 142.46,93.28 139.18,93.28 138.32,92.42 130.79,92.42 v1(130.28,92.93)
  BOTTOM w0.089: U6.V54 v1(143.99,93.39)
CFG14: length 32.2
  TOP w0.102: JXDP.34 132.87,106.05 130.76,103.94 130.76,98.06 130.51,97.82 v2(130.51,97.52) 130.41,97.42 130.41,96.02 130.72,95.72 130.72,94.02 v1(130.27,93.57)
  IN3 w0.089: v1(144.71,95.03) 144.64,95.03 143.78,95.89 143.02,95.89 143.02,95.88
  IN3 w0.102: v1(130.27,93.57) 132.15,95.45 133.09,95.45 134.44,96.79 140.38,96.79 141.3,95.88 143.02,95.88
  BOTTOM w0.089: v1(144.71,95.03) 144.69,95.05 144.69,95.06 145.07,94.68 U6.R53
CFG15: length 33.1
  TOP w0.102: v1(130.23,94.16) 129.47,94.92 v2(129.47,96.07) 129.47,97.47 130.55,98.55 130.55,104.15 132.95,106.55 JXDP.36
  IN3 w0.089: 143.02,96.08 143.86,96.08 144.51,95.44 145.07,95.44 v1(145.46,95.05)
  IN3 w0.102: 143.02,96.08 141.48,96.08 140.5,97.06 134.33,97.06 132.98,95.72 131.79,95.72 v1(130.23,94.16)
  BOTTOM w0.089: v1(145.46,95.05) 145.77,94.74 U6.R52
CFG16: length 24.2
  TOP w0.102: JXDP.6 132.95,99.05 132.46,98.56 132.46,97.7 133.26,96.9 133.26,93.9 133.41,93.75 v2(133.41,93.09) 133.41,91.01 132.85,90.45 v1(132.85,90.44)
  IN3 w0.089: 142.65,90.9 142.85,91.11 144.74,91.11 v1(145.39,91.76)
  IN3 w0.102: v1(132.85,90.44) 133.14,90.44 133.61,90.9 142.65,90.9
  BOTTOM w0.089: U6.Y52 v1(145.39,91.76)
CFG17: length 25.4
  TOP w0.102: v1(132.85,89.85) v2(133.47,90.47) 133.75,90.76 133.75,93.7 133.47,93.98 133.47,96.98 132.69,97.76 132.69,98.41 132.83,98.55 JXDP.4
  IN3 w0.089: v1(146.09,91.76) 145.25,90.92 142.94,90.92 142.72,90.7
  IN3 w0.102: 142.72,90.7 133.69,90.7 v1(132.85,89.85)
  BOTTOM w0.089: U6.Y51 v1(146.09,91.76)
CFG18: length 28
  TOP w0.102: JXDP.24 v2(132.21,103.55) 132.14,103.55 131.37,102.77 131.37,97.36 132.18,96.54 132.18,94.32 131.88,94.01 131.59,94.01 131.35,93.77 131.35,93.43 v1(131.76,93.02)
  IN3 w0.089: 142.34,93.76 144.15,93.76 144.52,93.4 v1(144.7,93.4)
  IN3 w0.102: 142.34,93.76 139.37,93.76 138.33,92.72 132.07,92.72 v1(131.76,93.02)
  BOTTOM w0.089: U6.V53 145.07,93.03 v1(144.7,93.4)
CFG19: length 28.2
  TOP w0.102: v1(131.76,93.61) 131.98,93.61 v2(132.27,93.9) 132.45,94.08 132.45,96.56 131.57,97.44 131.57,102.69 131.93,103.05 JXDP.22
  IN3 w0.089: v1(145.39,93.39) 145.39,93.56 145.18,93.77 144.41,93.77 144.23,93.95 142.94,93.95 142.34,94.56
  IN3 w0.102: v1(131.76,93.61) 132.08,93.61 132.6,93.09 138.41,93.09 140.03,94.71 142.18,94.71 142.34,94.56
  BOTTOM w0.089: U6.V52 v1(145.39,93.39)
CFG_RCOMP: length 5.1
  BOTTOM w0.089: 142.34,93.96 143.19,94.81 144.2,94.81 U6.R54
  BOTTOM w0.102: 142.34,93.96 v2(142,93.63) 141.78,93.4 140.59,93.4 RH27.1
CHG_LGATE:
  vias: v2(77.46,25.66)
CHG_LX: length 4.3
  IN1 w1.016: 71.54,27.19 71.54,27.57 73.7,29.73 74.59,29.73
  vias: v2(71.83,25.62) v9(71.29,26.3) v9(71.92,26.3) v9(76.18,29.51) v9(76.81,29.51)
CHG_UGATE: length 8.4
  TOP w0.102: v9(76.11,28.71) v2(75.34,28.71)
  IN1 w1.016: 75.22,28.59 74.46,28.59 73.06,27.19 73.06,25.79 71,23.73 71,23.15
  vias: v9(70.83,21.6) v9(70.85,22.24) v9(76.75,28.71)
CLK_27M_IN: length 9.9
  BOTTOM w0.102: UV1.H3 224.2,79.61 224.63,79.19 224.63,78.81 225.3,78.13 225.3,77.31 226.1,76.51 v9(226.1,75.93) 226.1,74.82 CV575.1 226.15,74.34 226.15,72.37 227.16,71.36 YV1.1
CLK_27M_OUT: length 7.3
  BOTTOM w0.102: UV1.H2 224.2,78.78 225.05,77.93 225.05,77.2 225.84,76.41 225.84,74.9 CV576.1 225.89,74.16 225.89,73.9 225.05,73.06 YV1.3
CLK_BUF_BCLK: length 15.2
  TOP w0.102: v1(251.05,35.82) 250.97,35.9 249.48,35.9 249.36,35.78 RPH27.3
  IN4 w0.076: 254.47,36.16 254.49,36.16 254.49,36.17 254.57,36.17 254.58,36.18 255.04,36.18 256.56,34.65 256.56,33.43 257.84,32.15 260.44,32.15 260.54,32.04 260.54,31.87 v1(260.49,31.82)
  IN4 w0.089: 254.47,36.16 251.43,36.16 251.09,35.82 v1(251.05,35.82)
  BOTTOM w0.102: U7.AT24 260.48,31.53 260.48,31.8 v1(260.49,31.82)
CLK_BUF_BCLK#: length 15.6
  TOP w0.102: RPH27.4 249.36,36.28 249.48,36.16 250.81,36.16 v1(251.05,36.41)
  IN4 w0.076: 254.47,36.41 255.13,36.41 256.79,34.75 256.79,33.52 257.94,32.38 260.53,32.38 v1(261.09,31.82)
  IN4 w0.089: 254.47,36.41 v1(251.05,36.41)
  BOTTOM w0.102: U7.AR24 260.82,31.55 v1(261.09,31.82)
CLK_CPU_DMI: length 120.4
  IN3 w0.089: v1(264.01,38.49) 263.9,38.49 263.81,38.59 263.81,39.85 262.81,40.84 ; 181.96,86.08 181.77,86.08 181.36,86.49 178.01,86.49 176.58,87.92 176.58,89.93 176.62,89.98 176.62,90.34 176.91,90.63 v1(177.13,90.63)
  IN3 w0.127: 181.96,86.08 182.59,86.08 184.56,84.11 184.56,71.49 187.33,68.72 197.35,68.72 198.73,67.34 203.69,67.34 215.74,55.3 216.86,55.3 227.45,44.71 257.02,44.71 259.8,41.92 261.73,41.92 262.81,40.84
  BOTTOM w0.089: v1(177.13,90.63) 177.05,90.63 176.73,90.95 U6.AA6
  BOTTOM w0.102: U7.AF40 264.41,38.23 264.27,38.23 v1(264.01,38.49)
CLK_CPU_DMI#: length 120.5
  IN3 w0.089: v1(264.04,37.92) 263.59,38.37 263.59,39.76 262.74,40.6 262.72,40.6 262.66,40.66 262.66,40.65 262.64,40.65 262.63,40.66 ; 181.96,85.83 181.95,85.83 181.93,85.85 181.69,85.85 181.27,86.27 177.92,86.27 176.36,87.83 176.36,90.03 176.41,90.07 v1(176.41,90.65)
  IN3 w0.127: 262.63,40.66 261.63,41.67 259.7,41.67 256.91,44.45 227.34,44.45 216.75,55.04 215.63,55.04 203.58,67.09 198.62,67.09 197.24,68.47 187.22,68.47 184.31,71.38 184.31,84 182.48,85.83 181.96,85.83
  BOTTOM w0.089: U6.AB6 176.73,90.33 v1(176.41,90.65)
  BOTTOM w0.102: v1(264.04,37.92) 264.21,37.75 U7.AF39
CLK_CPU_ITP: length 198.3
  TOP w0.102: JXDP.40 132.84,107.55 132.78,107.48 132.78,107.13 132.4,106.75 130.2,106.75 128.93,108.02 128.93,111.33 v9(129.56,111.96) 132.04,114.43 134.81,114.43 136.02,115.64 136.02,116.5 v1(135.85,116.66)
  IN1 w0.089: v1(265.15,45.01) 265.3,45.16 265.3,46.75 263.66,48.38 259.83,48.38 258.82,47.37 253.81,47.37 251.55,49.64 250.96,49.64 249.72,50.88 249.72,51.86 244.39,57.2 243.07,57.2 237.81,62.45 232.47,62.45 229.27,65.65 223.89,65.65 221.4,63.16 215.4,63.16 212.13,66.44 209.8,66.44 205.15,71.09 203.31,71.09 200.84,73.57 200.84,77.87 199.4,79.31 198.56,79.31 192.48,85.39 191.2,85.39 185.24,91.35 185.24,102.04 179.62,107.67 176.76,107.67 173.8,110.62 151.1,110.62 144.77,116.96 140.14,116.96 139.18,116 136.26,116 136.04,116.21 136.04,116.47 v1(135.85,116.66)
  BOTTOM w0.089: 264.53,42.2 263.84,41.51 263.84,40.35 U7.AH45
  BOTTOM w0.102: 264.53,42.2 265.3,42.97 265.3,44.85 v1(265.15,45.01)
CLK_CPU_ITP#: length 199.1
  TOP w0.102: JXDP.42 132.93,108.05 132.73,107.85 132.73,107.8 132.74,107.8 132.52,107.59 132.52,107.24 132.29,107.01 130.3,107.01 129.18,108.12 129.18,111.22 132.14,114.18 134.91,114.18 136.27,115.54 136.27,116.5 v1(136.43,116.66)
  IN1 w0.089: v1(265.74,45.01) 265.54,45.2 265.54,46.85 263.76,48.62 259.73,48.62 258.72,47.61 253.91,47.61 251.65,49.88 251.06,49.88 249.96,50.98 249.96,51.96 244.49,57.44 243.17,57.44 237.91,62.7 232.57,62.7 229.37,65.9 223.79,65.9 221.3,63.41 215.5,63.41 212.23,66.68 209.9,66.68 205.25,71.33 203.41,71.33 201.08,73.67 201.08,77.97 199.5,79.55 198.66,79.55 192.58,85.63 191.3,85.63 185.48,91.45 185.48,102.14 179.72,107.91 176.86,107.91 173.9,110.87 151.2,110.87 144.87,117.2 140.04,117.2 139.08,116.24 136.36,116.24 136.28,116.31 136.28,116.51 v1(136.43,116.66)
  BOTTOM w0.089: U7.AH43 263.88,39.48 263.88,39.93 263.88,39.93 263.88,39.95 264.09,40.15 264.09,41.41 264.88,42.2
  BOTTOM w0.102: 264.88,42.2 265.57,42.9 265.57,44.84 v1(265.74,45.01)
CLK_CPU_SSC_DPLL: length 126.8
  TOP w0.089: v1(176.27,92.24) 176.12,92.39 175.31,92.39 174.37,93.33 173.47,93.33 RU40.2
  IN3 w0.089: v1(263,38.05) 263.4,38.45 263.4,39.59 262.79,40.19 262.79,40.21 262.74,40.26 262.74,40.27 262.74,40.28 262.73,40.29 ; 181.96,85.24 181.94,85.24 181.92,85.22 181.81,85.22 181.08,85.96 177.84,85.96 175.78,88.02 175.78,92.25 175.95,92.42 176.08,92.42 v1(176.27,92.24)
  IN3 w0.127: 181.96,85.24 182.35,85.24 183.8,83.79 183.8,71.17 187.01,67.96 196.53,67.96 197.92,66.57 203.38,66.57 215.74,54.21 216.5,54.21 226.77,43.94 256.7,43.94 259.49,41.16 259.82,41.16 259.85,41.13 260.18,41.13 260.43,40.88 261.79,40.88 262.38,40.29 262.73,40.29
  BOTTOM w0.089: U7.AJ39 263.29,37.75 v1(263,38.05) ; v1(176.27,92.24) 176.66,91.84 U6.Y6
CLK_CPU_SSC_DPLL#: length 126.9
  TOP w0.089: v1(176.22,92.79) 176.05,92.63 175.41,92.63 v9(174.89,93.15) 174.47,93.57 173.34,93.57 RU44.2
  IN3 w0.089: v1(176.22,92.79) 176.07,92.64 175.86,92.64 175.56,92.34 175.56,87.93 177.75,85.74 180.98,85.74 181.72,85.01 181.92,85.01 181.94,84.99 181.96,84.99 ; 262.61,40.03 262.64,40.03 263.18,39.5 263.18,38.81 v1(262.98,38.62)
  IN3 w0.127: 181.96,84.99 182.24,84.99 183.54,83.69 183.54,71.06 186.91,67.7 196.43,67.7 197.82,66.31 203.28,66.31 215.63,53.96 216.39,53.96 226.66,43.69 227.04,43.69 227.17,43.56 227.55,43.56 227.68,43.69 228.06,43.69 228.19,43.56 228.57,43.56 228.7,43.69 229.08,43.69 229.21,43.56 229.59,43.56 229.72,43.69 230.1,43.69 230.23,43.56 230.61,43.56 230.74,43.69 231.12,43.69 231.25,43.56 231.64,43.56 231.76,43.69 232.15,43.69 232.28,43.56 232.66,43.56 232.79,43.69 256.59,43.69 259.38,40.9 259.71,40.9 259.74,40.87 260.08,40.87 260.33,40.62 261.69,40.62 262.28,40.03 262.61,40.03
  BOTTOM w0.089: v1(262.98,38.62) 263.26,38.35 U7.AJ40 ; v1(176.22,92.79) 176.24,92.77 176.61,92.77 U6.V6
CLK_PCH_14M: length 2.6
  BOTTOM w0.089: 272.31,42.2 272.81,41.7 272.81,40.35 U7.F45
  BOTTOM w0.102: 272.31,42.2 RH62.1
CLK_PCI0: length 5.7
  TOP w0.089: v1(273.38,39.19) 274.21,40.01 v8(274.89,40.01) 275.84,40.01 276.54,39.32 277.14,39.32
  TOP w0.102: RH144.2 277.14,39.32
  BOTTOM w0.089: U7.D44 273.8,39.61 v1(273.38,39.19)
CLK_PCI1: length 4.4
  BOTTOM w0.089: U7.E44 272.84,39.73 272.42,40.15 272.42,40.41 272.62,40.6 272.62,41.51 272.48,41.64 v2(271.99,41.64) 271.85,41.64 271.29,42.2
  BOTTOM w0.102: RH145.2 271.29,42.2
CLK_PCI2: length 4.7
  TOP w0.089: 277.14,37.88 275.77,37.88 275.46,37.57 v8(274.74,37.57) 274.66,37.65 274.66,38.29 v1(274.65,38.3)
  TOP w0.102: 277.14,37.88 277.4,37.88 RH146.2
  BOTTOM w0.089: v1(274.65,38.3) 274.48,38.47 U7.B42
CLK_PCI_DEBUG: length 17.8
  TOP w0.102: v3(279.59,37.55) 279.58,37.54 RH146.1
  GND1 w0.102: v3(279.59,37.55) 279.7,37.55 279.91,37.35 v5(279.91,37.28)
  IN1 w0.076: v5(279.91,37.28) 281.56,37.28 282.19,36.65 282.19,25.6 281.59,25 280.78,25 v4(280.68,24.9)
  GND3 w0.102: v4(280.68,24.9) 280.78,25 v7(281.62,25)
CLK_PCI_LPBACK: length 21.1
  TOP w0.102: v1(275.39,40.84) v8(276.85,40.84) 277.14,40.84 RH144.1
  IN1 w0.076: v1(277.1,29.33) 277.16,29.33 278.18,30.35 278.18,38.04 v1(275.39,40.84)
  BOTTOM w0.089: v1(277.1,29.33) 276.98,29.45 276.34,29.45 275.86,28.97 275.86,28.91 275.53,28.58 275.07,28.58 274.78,28.87 274.57,28.87 274.23,28.53 U7.D17
CLK_PCI_LPC: length 135.3
  TOP w0.089: 168.78,16.52 168.58,16.72 167.84,16.72 UE1.N5
  TOP w0.102: 168.78,16.52 169.16,16.52 169.29,16.39 170.17,16.39 RE13.1 v3(171.16,17.39)
  GND1 w0.102: v3(171.16,17.39) 171.2,17.42 v5(171.2,17.79)
  IN1 w0.076: v1(201.4,23.16) 201.4,22.57 202.91,21.06 202.91,18.83 201.18,17.1 194.41,17.1 193.45,18.06 181.49,18.06 180.68,17.26 176,17.26 175.57,17.69 171.3,17.69 v5(171.2,17.79)
  IN4 w0.076: v1(201.4,23.16) 201.96,23.72 202.26,23.72 205.15,26.61 205.15,36.6 213.04,44.48 252.89,44.48 255.79,47.38 258.96,47.38 260.26,48.67 265.54,48.67 266.56,47.66 266.56,43.49 266.82,43.23 266.82,42.79 267.07,42.54 269.18,42.54 269.68,43.05 v6(269.68,43.95)
  GND3 w0.102: v6(269.68,43.95) 269.68,43.77 v7(270,43.45)
  BOTTOM w0.102: RH145.1 v7(270,43.45)
CLK_PCI_TPM: length 114
  TOP w0.102: U1.21 207.88,15.58 R2.1 207.89,15.56 208.52,14.93 211.1,14.93 211.38,15.21 v2(211.38,15.4) 211.38,15.64 211.2,15.82 210.48,15.82 210.42,15.87 210.42,16.35 209.26,17.52 209.26,17.95 208.96,18.25 v1(208.96,18.31)
  IN3 w0.13: v1(280.97,38.59) 279.18,36.81 279.18,33.93 279.59,33.52 279.59,32.89 280.03,32.44 280.03,30.84 280.63,30.25 280.63,29.98 281.18,29.43 281.18,19.57 278.31,16.7 271.29,16.7 270.03,15.43 261.03,15.43 260.17,16.29 256.88,16.29 256.61,16.02 253.59,16.02 252.09,17.52 251.24,17.52 250.66,16.94 244.34,16.94 242.54,18.74 241.44,18.74 240.81,18.11 235.29,18.11 235.06,17.89 233.51,17.89 233.17,18.23 228.01,18.23 227.83,18.05 222.5,18.05 221.54,19.01 219.71,19.01 219.17,19.55 213.81,19.55 211.95,17.69 209.59,17.69 v1(208.96,18.31)
  BOTTOM w0.102: RH97.2 CH13.1 278.42,39.68 278.78,40.04 279.41,40.04 280.07,39.38 280.73,39.38 280.97,39.14 v1(280.97,38.59)
CLK_PCI_TPM_R: length 4.9
  BOTTOM w0.089: 277.14,37.35 277.13,37.35 276.54,37.93 276.08,37.93 275.75,37.6 274.98,37.6 274.7,37.88 U7.C40
  BOTTOM w0.102: RH97.1 277.81,37.88 v2(277.28,37.35) 277.14,37.35
CLK_PCIE_CD: length 36.2
  IN1 w0.076: v4(263.79,41.32) 263.92,41.19 263.99,41.13 264.2,41.13 264.73,40.6 264.73,39.89 265.64,38.98 265.64,34.12 266.18,33.58 266.18,29.86 266.52,29.53 268.14,29.53 268.75,28.92 268.75,28.21 268.18,27.64 268.18,23.55 268.34,23.39 268.34,19.9 268.48,19.75 268.48,19.66
  IN1 w0.089: 268.48,19.66 268.48,18.85 267.28,17.65 267.28,15.78 266.46,14.96 265.66,14.96 265.45,14.75 265.45,14.65 v1(265.63,14.48)
  GND3 w0.089: v7(264.41,41.17) 264.37,41.13 263.98,41.13 v4(263.79,41.32)
  BOTTOM w0.089: U7.AF45 264.74,40.43 264.74,40.84 v7(264.41,41.17)
  BOTTOM w0.102: v1(265.63,14.48) 265.49,14.34 265.49,14.05 265.06,13.62 264.81,13.37 264.81,13.16 264.9,13.06 JTB1.31
CLK_PCIE_CD#: length 36.3
  IN1 w0.076: 268.24,19.66 268.24,19.67 268.11,19.8 268.11,23.29 267.95,23.45 267.95,27.73 268.52,28.3 268.52,28.82 268.04,29.3 266.42,29.3 265.95,29.77 265.95,33.48 265.41,34.02 265.41,38.88 264.5,39.79 264.5,40.5 264.1,40.9 263.96,40.9 v4(263.79,40.74)
  IN1 w0.089: 268.24,19.66 268.24,18.95 267.04,17.75 267.04,15.88 266.36,15.2 265.56,15.2 265.21,14.85 265.21,14.64 v1(265.05,14.48)
  GND3 w0.089: v7(264.41,40.66) 264.14,40.93 263.98,40.93 v4(263.79,40.74)
  BOTTOM w0.089: v7(264.41,40.66) 264.28,40.53 264.28,40.17 264.59,39.86 U7.AF43
  BOTTOM w0.102: JTB1.33 264.5,13.1 264.55,13.15 264.55,13.47 265.24,14.16 265.24,14.29 v1(265.05,14.48)
CLK_PCIE_MINI3: length 35.6
  IN1 w0.076: 269.21,19.66 269.21,19.76 269.3,19.85 269.3,21.7 268.74,22.26 268.74,23.2 269.16,23.61 269.16,26.63 269.87,27.34 269.87,28.58 269.24,29.21 269.24,30.3 268.67,30.86 268.67,33.53 267.98,34.22 267.98,36.82 268.18,37.02 268.18,40.24 267.44,40.99 266.25,40.99 v4(266.08,41.16)
  IN1 w0.089: 269.21,19.66 269.21,18.56 268.08,17.43 268.08,15.43 266.66,14 266.21,14 265.97,13.76 265.97,13.66 v1(266.19,13.44)
  GND3 w0.089: v7(265.57,41.09) 265.69,40.97 265.89,40.97 v4(266.08,41.16)
  BOTTOM w0.089: v7(265.57,41.09) 265.42,41.25 265.29,41.25 265.23,41.18 265.23,40.45 U7.AD45
  BOTTOM w0.102: JTB1.25 266.1,12.94 266.03,13.01 266.03,13.28 v1(266.19,13.44)
CLK_PCIE_MINI3#: length 35.2
  IN1 w0.076: 268.97,19.66 268.97,19.87 269.08,19.97 269.08,21.6 268.51,22.16 268.51,23.29 268.93,23.71 268.93,26.72 269.64,27.43 269.64,28.48 269.01,29.12 269.01,30.2 268.45,30.77 268.45,33.43 267.75,34.13 267.75,36.91 267.96,37.12 267.96,40.15 267.34,40.76 266.25,40.76 v4(266.08,40.58)
  IN1 w0.089: v1(265.61,13.44) 265.73,13.57 265.73,13.86 266.11,14.24 266.56,14.24 267.84,15.53 267.84,17.53 268.97,18.66 268.97,19.66
  GND3 w0.089: v7(265.57,40.65) 265.69,40.77 265.89,40.77 v4(266.08,40.58)
  BOTTOM w0.089: U7.AD43 265.4,39.84 265.7,40.14 265.7,40.52 v7(265.57,40.65)
  BOTTOM w0.102: v1(265.61,13.44) 265.77,13.28 265.77,13.01 265.7,12.94 JTB1.27
CLK_PEG_VGA: length 97.4
  IN3 w0.089: 205.23,77.32 205.23,77.34 205.25,77.36 205.25,87.95 v4(205.03,88.17) ; v1(266.6,36.24) 266.96,36.61 266.96,37.21 265.81,38.37 265.81,38.45
  IN3 w0.127: 265.81,38.45 265.81,39.93 265.43,40.31 265.43,41.44 265.62,41.63 265.62,42.04 265.01,42.64 265.01,42.86 264.1,43.78 259.75,43.78 255.51,48.01 246.89,48.01 244.56,50.35 239.11,50.35 234.71,54.74 224.38,54.74 219.79,59.33 219.13,59.33 215.53,62.94 215.53,63.59 211.87,67.25 211.87,68.38 209.74,70.52 208.9,70.52 205.23,74.19 205.23,77.32
  GND3 w0.102: v7(204.6,87.75) 204.61,87.75 v4(205.03,88.17)
  BOTTOM w0.102: U7.AB36 266.29,36.56 v1(266.6,36.24) ; UV1.AL13 v7(204.6,87.75)
CLK_PEG_VGA#: length 98.1
  IN3 w0.089: 205.49,77.32 205.49,77.34 205.47,77.36 205.47,87.82 205.61,87.96 v4(205.88,87.96) ; 266.06,38.45 266.06,38.42 267.18,37.31 267.18,36.52 267.12,36.45 267.12,36.16 v1(266.6,35.65)
  IN3 w0.127: 205.49,77.32 205.49,74.29 209.01,70.77 209.84,70.77 212.13,68.49 212.13,67.36 215.79,63.7 215.79,63.04 219.24,59.59 219.9,59.59 224.48,55 234.82,55 239.22,50.6 244.66,50.6 247,48.27 255.62,48.27 259.86,44.03 264.2,44.03 265.27,42.97 265.27,42.75 265.88,42.14 265.88,41.52 265.68,41.33 265.68,40.42 266.06,40.04 266.06,38.45
  GND3 w0.102: v4(205.88,87.96) 205.88,87.96 205.66,87.75 v7(205.4,87.75)
  BOTTOM w0.102: U7.AB35 266.29,35.96 v1(266.6,35.65) ; UV1.AK13 v7(205.4,87.75)
CLK_REQ#: length 52.8
  TOP w0.089: 201.71,77.65 v1(201.71,77.66)
  TOP w0.102: 201.71,77.65 201.08,77.02 v9(201.08,72.75) 201.08,71.51 202.74,69.85 QV39.3
  IN1 w0.102: v1(220.66,64.27) 220.45,64.05 215.73,64.05 210.5,69.29 208.31,69.29 204.91,72.68 204.91,74.31 201.71,77.51 v1(201.71,77.66)
  IN4 w0.089: v1(206.55,85.65) 205.34,85.65 203.33,83.64 203.33,81.58 202.44,80.69
  IN4 w0.102: 202.44,80.69 202.2,80.45 202.2,78.14 v1(201.71,77.66)
  BOTTOM w0.102: v1(206.55,85.65) 206.19,86.02 206.19,86.91 UV1.AK12 ; RPH32.4 221.41,63.52 v1(220.66,64.27)
CLK_SMB: length 10.7
  TOP w0.254: v1(101.58,16.29) 102.86,16.29 103.24,16.67 v2(103.24,17.23) 103.24,18.52 102.35,19.41 PD103.2
  BOTTOM w0.254: v1(101.58,16.29) 102.42,17.13 102.42,17.24 BAT100.5
CLKA0: length 36.3
  TOP w0.114: v1(219.91,124.85) 220.29,124.47 220.53,124.47 220.85,124.79 v9(220.85,125.28) 220.85,126.36 RV348.2
  IN4 w0.107: v1(219.91,124.85) 219.48,124.41 219.48,123.73 219.11,123.36 218.51,123.36 217.96,122.81 217.96,122.21 217.71,121.96 212.99,121.96 212.19,121.17 212.19,113.41 216.05,109.54 216.05,104.17 218.12,102.1 218.63,102.1 v1(218.77,101.97)
  BOTTOM w0.089: UV1.R30 218.41,102.4 218.77,102.04 v1(218.77,101.97)
  BOTTOM w0.114: UV5.J12 220.3,124.53 219.99,124.85 v1(219.91,124.85)
CLKA0#: length 36.8
  TOP w0.114: v1(219.89,124.07) 220.07,124.25 220.62,124.25 221.07,124.7 221.07,124.98 221.09,125 221.09,125.56 221.07,125.58 221.07,125.81 RV349.2
  IN4 w0.107: v1(218.78,102.8) 218.78,102.48 218.63,102.33 218.21,102.33 216.28,104.26 216.28,109.64 212.41,113.5 212.41,121.07 213.08,121.74 217.8,121.74 218.18,122.12 218.18,122.72 218.6,123.13 219.2,123.13 219.73,123.67 220.22,123.67 220.32,123.77 220.32,124.05 220.22,124.15 219.97,124.15 v1(219.89,124.07)
  BOTTOM w0.089: v1(218.78,102.8) 218.4,103.18 UV1.R31
  BOTTOM w0.114: UV5.J11 220.29,123.67 v1(219.89,124.07)
CLKA1: length 39.4
  TOP w0.114: v1(201.88,124.85) 201.88,124.59 201.98,124.49 202.22,124.49 202.35,124.62 202.35,126.68 RV361.2
  IN4 w0.107: v1(201.88,124.85) 202.27,124.45 202.27,123.8 202.53,123.54 202.53,122.22 202.97,121.78 208.5,121.78 209.24,122.51 211.57,122.51 211.83,122.25 211.83,113.03 215.21,109.65 215.21,106.49 215.2,106.48 215.2,105.94 213.96,104.7 213.96,103.69 213.09,102.83 v1(213.01,102.83)
  BOTTOM w0.089: UV1.AB31 212.64,103.2 v1(213.01,102.83)
  BOTTOM w0.114: UV6.J12 202,124.47 201.88,124.59 v1(201.88,124.85)
CLKA1#: length 39.3
  TOP w0.114: RV362.2 202.56,126.88 202.56,124.53 202.31,124.28 202.07,124.28 v1(201.87,124.07)
  IN4 w0.107: v1(212.19,102.83) 212.19,102.78 212.32,102.65 212.49,102.65 212.62,102.78 212.62,102.99 212.84,103.21 213.18,103.21 213.75,103.78 213.75,104.78 214.99,106.02 214.99,106.48 214.98,106.48 214.98,109.56 211.6,112.94 211.6,122.16 211.47,122.28 209.33,122.28 208.6,121.55 202.88,121.55 202.3,122.13 202.3,123.45 202.04,123.71 202.04,123.89 201.9,124.04 v1(201.87,124.07)
  BOTTOM w0.089: v1(212.19,102.83) 211.82,103.2 UV1.AC31
  BOTTOM w0.114: v1(201.87,124.07) 201.87,124.07 UV6.J11
CLKB0: length 39.5
  TOP w0.114: v1(251,86.42) 251.14,86.56 251.72,86.56 252,86.29 252.65,86.29 252.67,86.27 253.22,86.27 253.24,86.29 253.94,86.29 RV374.2
  IN4 w0.107: v1(251,86.42) 251.12,86.54 251.12,86.72 250.99,86.84 250.73,86.84 250.6,86.97 250.6,87.32 249.8,88.12 249.21,88.12 248.1,89.24 248.1,91.5 244.75,94.84 241.86,94.84 241.61,94.59 239.3,94.59 236.49,91.78 231.28,91.78 228.85,89.35 227.26,89.35 226.74,88.83 226.38,88.83 226.32,88.77 v1(226.32,88.57)
  BOTTOM w0.089: v1(251,86.42) 251.39,86.81 UV9.J12 ; v1(226.32,88.57) 226,88.25 226,88.03 226.29,87.74 226.85,87.74 227.28,87.3 UV1.D12
CLKB0#: length 39.5
  TOP w0.114: RV375.2 253.94,86.5 v9(252.94,86.5) 252.09,86.5 251.81,86.77 251.47,86.77 v1(251.01,87.23)
  IN4 w0.107: v1(251.01,87.23) 251.01,87.23 249.89,88.35 249.3,88.35 248.32,89.33 248.32,91.59 244.85,95.06 241.77,95.06 241.52,94.82 239.21,94.82 236.39,92 231.18,92 228.76,89.58 227.17,89.58 226.65,89.05 225.94,89.05 v1(225.5,88.62)
  BOTTOM w0.089: v1(225.5,88.62) 225.5,88.66 225.56,88.72 225.74,88.72 225.88,88.58 225.88,88.4 225.81,88.33 225.81,87.95 226.21,87.54 226.55,87.54 UV1.E12 ; UV9.J11 250.64,86.85 v1(251.01,87.23)
CLKB1: length 38.2
  TOP w0.114: RV387.2 v9(252.97,104.5) 252.52,104.5 252,103.98 251.61,103.98 251.5,104.1 251.5,104.35 251.61,104.47 251.79,104.47 v1(251.8,104.45)
  IN4 w0.107: v1(226.32,93.61) 226.5,93.79 226.87,93.79 228.18,92.47 236.18,92.47 238.88,95.18 241.02,95.18 241.77,95.93 245.15,95.93 247.87,98.66 247.87,102.97 248.76,103.86 250.47,103.86 250.72,104.11 251.15,104.11 251.49,104.45 v1(251.8,104.45)
  BOTTOM w0.089: v1(226.32,93.61) 226.71,94 UV1.E20
  BOTTOM w0.114: v1(251.8,104.45) 251.39,104.86 UV10.J12
CLKB1#: length 38.8
  TOP w0.114: v1(250.99,104.49) 251.28,104.2 251.28,104.01 251.52,103.77 252.09,103.77 252.6,104.27 253.43,104.27 253.96,103.74 RV388.2
  IN4 w0.107: v1(250.99,104.49) 250.99,104.54 250.89,104.64 250.67,104.64 250.57,104.54 250.57,104.27 250.38,104.08 248.66,104.08 247.65,103.07 247.65,98.75 245.05,96.15 241.67,96.15 240.92,95.4 238.79,95.4 236.09,92.7 228.27,92.7 226.96,94.01 226.35,94.01 226.22,94.13 226.22,94.29 v1(226.34,94.41)
  BOTTOM w0.089: UV1.F20 226.27,94 226.45,94.19 226.45,94.31 226.34,94.43 v1(226.34,94.41)
  BOTTOM w0.114: UV10.J11 250.6,104.88 v1(250.99,104.49)
CLKIN_DMI: length 13.1
  TOP w0.102: RPH27.1 249.36,34.78 249.48,34.9 249.77,34.9 250.17,34.5 250.91,34.5 v1(251.05,34.36)
  IN4 w0.076: 254.47,34.36 254.49,34.36 254.49,34.37 254.57,34.37 254.58,34.37 254.82,34.37 258.11,31.08 258.98,31.08 259.18,31.29 259.18,31.59 v1(259.32,31.73)
  IN4 w0.089: v1(251.05,34.36) 251.3,34.36 254.47,34.36
  BOTTOM w0.102: v1(259.32,31.73) 259.32,31.59 259.03,31.3 U7.AW24
CLKIN_DMI#: length 13
  TOP w0.102: RPH27.2 249.36,35.28 249.48,35.16 249.88,35.16 250.28,34.76 250.86,34.76 v1(251.05,34.95)
  IN4 w0.076: v1(258.74,31.73) 258.83,31.73 258.95,31.61 258.95,31.38 258.88,31.31 258.2,31.31 254.91,34.6 254.47,34.6
  IN4 w0.089: v1(251.05,34.95) 251.05,34.94 251.39,34.6 254.47,34.6
  BOTTOM w0.089: U7.AY24 258.43,31.4 258.74,31.71 v1(258.74,31.73)
CLKIN_DOT96: length 7
  TOP w0.089: v1(272.76,35.68) 272.63,35.68 272.53,35.58 272.53,35.35 272.68,35.21 v9(274.1,35.21) 274.47,35.21 274.64,35.38 275.95,35.38 276.75,36.18 277.09,36.18 277.1,36.19 277.11,36.19
  TOP w0.102: RH67.1 277.73,36.55 277.37,36.19 277.11,36.19
  BOTTOM w0.089: v1(272.76,35.68) 272.59,35.51 U7.G33
CLKIN_DOT96#: length 7.1
  TOP w0.089: v1(272.16,35.68) 272.29,35.56 272.29,35.25 272.58,34.97 274.57,34.97 274.74,35.14 276.05,35.14 276.85,35.94 277.11,35.94
  TOP w0.102: 277.11,35.94 277.56,35.94 RH66.1
  BOTTOM w0.089: v1(272.16,35.68) 271.99,35.51 U7.H33
CLKIN_SATA: length 6.1
  BOTTOM w0.089: 254.47,22.18 254.49,22.18 254.5,22.18 254.96,22.18 255.2,22.42 255.2,23.81 255.77,24.37 256.61,24.37 256.91,24.06 U7.BC6
  BOTTOM w0.102: 254.47,22.18 253.19,22.18 RH69.1
CLKIN_SATA#: length 6
  BOTTOM w0.089: U7.BE6 256.56,23.97 256.56,23.81 256.49,23.73 256.22,23.73 256.14,23.81 256.14,24.05 256.07,24.12 255.87,24.12 255.45,23.71 255.45,22.32 255.06,21.93 254.5,21.93 254.49,21.93 254.47,21.93
  BOTTOM w0.102: 254.47,21.93 253.82,21.93 RH68.1
CMSRC: length 17
  TOP w0.102: v2(79.14,33.04) 79.82,32.37 v1(79.82,32.09)
  IN1 w0.254: v1(79.82,32.09) 79.51,32.4 73.47,32.4 70.42,29.34 70.02,29.34 68.55,27.88 v1(68.51,27.88)
  BOTTOM w0.254: v1(79.82,32.09) 79.82,31.91 79.54,31.63 PU200.3 ; v1(68.51,27.88) 68.38,27.88 PR200.2
COLOR_CLK: length 203.1
  TOP w0.102: QV7.6 221.02,19.01 221.3,19.29 221.3,20.67 RV333.2 221.85,21.86 223.51,23.52 v8(224.55,23.52) 228.65,23.52 231.57,26.44 231.57,30.19 231.86,30.48 231.86,45.58 230.69,46.75 v1(229.15,46.75)
  BOTTOM w0.102: v1(229.15,46.75) 229.11,46.71 162.11,46.71 161.04,45.64 120.57,45.64 114.15,39.23 106.36,39.23 101.69,34.55 92.16,34.55 89.06,31.46 85.35,31.46 84.87,31.93 84.87,35.2 83.2,36.87 79.5,36.87 76.55,39.82 JEDP1.32
COLOR_DAT: length 181.3
  TOP w0.102: v1(215.77,18.12) 215.77,17.62 215.96,17.43 v2(216.09,17.43) 216.72,17.43 216.94,17.65 RV334.2 217.48,17.71 QV7.3
  IN3 w0.102: v4(88.58,30.99) 89.59,32 105.6,32 106.78,33.18 110.32,33.18 111.52,34.38 111.91,34.38 112.01,34.28 112.01,33.34 112.12,33.24 112.32,33.24 112.42,33.34 112.42,34.28 112.52,34.38 112.72,34.38 112.83,34.28 112.83,33.34 112.93,33.24 113.13,33.24 113.23,33.34 113.23,34.28 113.33,34.38 113.54,34.38 113.64,34.28 113.64,33.34 113.74,33.24 113.94,33.24 114.05,33.34 114.05,34.28 114.15,34.38 114.35,34.38 114.45,34.28 114.45,33.34 114.55,33.24 114.76,33.24 114.86,33.34 114.86,34.28 114.96,34.38 115.16,34.38 115.26,34.28 115.26,33.34 115.37,33.24 115.57,33.24 115.67,33.34 115.67,34.28 115.77,34.38 115.98,34.38 116.08,34.28 116.08,33.34 116.18,33.24 116.38,33.24 116.48,33.34 116.48,34.28 116.59,34.38 116.79,34.38 116.89,34.28 116.89,33.34 116.99,33.24 117.2,33.24 117.3,33.34 117.3,34.28 117.4,34.38 117.6,34.38 117.7,34.28 117.7,33.34 117.8,33.24 118.01,33.24 118.11,33.34 118.11,34.28 118.21,34.38 118.41,34.38 118.52,34.28 118.52,33.34 118.62,33.24 118.82,33.24 118.92,33.34 118.92,34.28 119.02,34.38 119.23,34.38 119.33,34.28 119.33,33.34 119.43,33.24 119.63,33.24 119.74,33.34 119.74,34.28 119.84,34.38 164.63,34.38 165.74,33.27 167.83,33.27 172.74,28.35 175.21,28.35 180.58,22.98 187.4,22.98 188.11,22.27 190.24,22.27 190.49,22.52 191.74,22.52 198.45,15.81 202.9,15.81 203.84,16.75 205.24,16.75 205.51,16.47 207.11,16.47 207.72,15.86 209.27,15.86 209.73,15.4 211.95,15.4 214.67,18.12 v1(215.77,18.12)
  GND3 w0.102: v4(88.58,30.99) 88.59,30.99 88.33,31.25 v7(88.33,31.81)
  BOTTOM w0.102: v7(88.33,31.81) 88.18,31.66 85.43,31.66 85.08,32.01 85.08,35.28 83.29,37.07 79.58,37.07 77.05,39.61 JEDP1.31
COMP: length 3.9
  TOP w0.254: v1(125.92,119.45) 126.35,119.88 PR736.1
  BOTTOM w0.203: v1(125.92,119.45) 125.6,119.13 PU700.7
  BOTTOM w0.254: PC724.1 126.63,120.16 v2(126.37,119.9) v1(125.92,119.45)
CPU1.5V_S3_GATE_R: length 11.6
  BOTTOM w0.102: UU3.1 131.47,67.13 131.28,66.94 131.28,66.53 131.67,66.13 RU50.2 ; R29.2 RU50.2 ; RU50.2 v2(132.89,64.74) 133.96,63.67 RU53.2 RU54.2 137.85,64.5 QU7.2
CPU_FC_PWR: length 7.6
  BOTTOM w0.089: 177.73,105.93 177.73,104.27 177.54,104.08 177.54,103.13 177.16,102.75 U6.D5
  BOTTOM w0.102: 177.73,105.93 177.73,106.5 176.08,108.15 T172.1
CPU_FC_PWROK: length 6.1
  BOTTOM w0.089: 178.56,105.93 178.56,103.7 178.43,103.58 178.43,102.91 U6.D3
  BOTTOM w0.102: T173.1 178.56,106.5 178.56,105.93
CPU_PLTRST#: length 194
  IN1 w0.076: v4(259.57,23.63) 258.82,23.63 256.79,25.66 251.08,25.66 248.96,27.79 248.96,28.5 247.61,29.85 247.61,30.55 248.28,31.21 248.28,39.64 236.98,50.93 236.98,51.58 v4(235.01,53.55)
  IN3 w0.13: v4(235.01,53.55) 234.99,53.58 234.1,53.58 234,53.68 224,53.68 220.17,57.51 219.52,57.51 214.39,62.63 214.39,63.29 206.15,71.53 188.49,71.53 187.37,72.65 187.37,85.27 184.08,88.56 184.08,97.78 181.57,100.29 181.57,103.74 176.47,108.85 163.92,108.85 163.09,109.67 155.82,109.67 154.1,111.39 144.13,111.39 142.96,110.22 142.96,107.23 142.67,106.94 142.67,103.76 144.23,102.19 144.23,100.98 143.18,99.93 143.18,98.63 v1(143.76,98.05)
  GND3 w0.089: v7(260.12,22.99) 259.79,23.32 259.79,23.42 v4(259.57,23.63)
  BOTTOM w0.089: v1(143.76,98.05) 143.32,98.05 142.24,96.97 142.17,96.97
  BOTTOM w0.102: 142.17,96.97 v2(141.79,96.97) RU37.1
CPU_PWR_DEBUG: length 42.5
  TOP w0.102: JXDP.45 141.1,109.05 v1(141.27,108.87)
  IN1 w0.076: 145.99,105.93 147.45,104.47 158.42,104.47 158.86,104.02 160.72,104.02 161.43,103.31 161.43,101.28 161.61,101.1 168.17,101.1 v1(168.56,101.49)
  IN1 w0.102: v1(141.27,108.87) 141.4,108.75 143.17,108.75 145.99,105.93
  BOTTOM w0.089: U6.F19 168.21,101.14 v1(168.56,101.49) 169.24,101.49 169.42,101.67 169.42,105.93
  BOTTOM w0.102: RU94.2 169.42,106.29 169.42,105.93 ; v2(140.6,108.8) 140.67,108.87 v1(141.27,108.87)
CPU_TESTLOW0: length 9.3
  TOP w0.089: v1(168.92,105.74) 168.65,105.74 168.17,105.25 168.17,101.95 v2(167.96,101.73) 167.77,101.54 v1(166.94,101.54)
  BOTTOM w0.089: U6.F20 167.34,101.14 v1(166.94,101.54) ; 168.73,105.93 v1(168.92,105.74)
  BOTTOM w0.102: RH31.1 166.83,107.83 168.73,105.93
CPU_TESTLOW1: length 2.4
  TOP w0.089: v1(166.15,101.54) 166.3,101.39 v2(166.3,100.93) 166.3,99.91 RH30.1
  BOTTOM w0.254: U6.F21 166.54,101.15 v1(166.15,101.54)
CS_1.35V: length 3
  TOP w0.203: PU400.13 125.13,15.25 124.71,14.83 v2(124.71,14.6) PR401.2
CSON_B: length 67.3
  TOP w0.254: PR219.3 93.18,13.2 v1(92.83,12.84) ; PC227.1 80.25,25.56 PC226.2 80.18,24.45 v1(80.18,23.53) ; PR283.2 v1(117.66,15.5)
  IN1 w0.254: v1(92.83,12.84) 93,13.01 98.81,13.01 99.61,13.8 99.61,19.32 96.94,21.98 80.81,21.98 80.05,22.75 80.05,23.41 v1(80.18,23.53)
  IN4 w0.254: v1(117.66,15.5) 117.54,15.63 114.11,15.63 111.55,13.07 93.05,13.07 v1(92.83,12.84)
  BOTTOM w0.254: v1(80.18,23.53) 80.07,23.64 80.07,24.27 PR221.2
CSOP_B: length 66.6
  TOP w0.254: PR219.2 92.42,13.2 v1(92.8,13.58) ; v1(79.54,23.53) 79.54,24.32 PC226.1 79.34,25.59 PC225.2 ; PR284.2 117.42,16.38 v1(117.66,16.14)
  IN1 w0.254: v1(92.8,13.58) 92.9,13.47 98.6,13.47 99.16,14.03 99.16,19 96.69,21.48 80.81,21.48 79.67,22.62 79.67,23.41 v1(79.54,23.53)
  IN4 w0.254: v1(117.66,16.14) 117.54,16.01 113.92,16.01 111.33,13.42 92.95,13.42 v1(92.8,13.58)
  BOTTOM w0.254: PR218.2 79.63,24.28 79.63,23.62 v1(79.54,23.53)
CSSN_1: length 28.8
  TOP w0.254: v1(64.83,21.72) 65.14,21.72 65.34,21.52 65.34,19.17 65.57,18.94 PR201.3
  IN1 w0.254: v1(78.24,34.86) 78.39,34.71 78.39,34.22 77.33,33.16 72.18,33.16 69.05,30.03 67.42,30.03 65.66,28.27 65.66,23.08 65.34,22.76 65.34,21.93 65.14,21.72 v1(64.83,21.72)
  BOTTOM w0.254: v1(78.24,34.86) 78.29,34.81 78.29,34.28 PR210.1
CSSP_1: length 29
  TOP w0.254: PR201.2 64.63,18.94 64.96,19.27 64.96,20.96 v9(64.83,21.09)
  IN1 w0.254: v9(64.83,21.09) 65.34,21.09 65.72,21.47 65.72,22.63 66.04,22.95 66.04,28.13 67.56,29.65 69.18,29.65 72.33,32.8 77.51,32.8 78.75,34.04 78.75,34.73 v9(78.9,34.89)
  BOTTOM w0.254: v9(78.9,34.89) 78.75,34.73 78.75,34.41 PR209.1
CTL2/3_1: length 3
  BOTTOM w0.102: 22.69,53.43 22.86,53.6 US1.8 ; 22.69,53.43 RE62.2 ; 22.69,53.43 23.01,53.1 US1.7
CTL2/3_3: length 6.9
  TOP w0.102: US2.8 20.85,79.34 20.68,79.51 18.85,79.51 RE68.2 18.85,80.15 v2(20.81,80.15) 20.93,80.15 21.35,79.73 US2.7
DAT_SMB: length 9.9
  TOP w0.254: PD103.3 100.42,18.32 100.12,18.02 v8(100.12,16.96) v1(100.12,16.01)
  BOTTOM w0.254: BAT100.6 100.91,16.18 100.75,16.01 v1(100.12,16.01)
DDC_CLK_HDMI: length 26.6
  TOP w0.102: v3(25.22,102.24) 25.63,101.84 25.75,101.84 26.29,101.3 U22.32
  GND1 w0.102: v4(24.76,102.05) 25.03,102.05 v3(25.22,102.24)
  IN3 w0.089: JHDMI.15 11.32,112.38 arc(11.24,112.52) 11.21,112.69 11.21,112.79 11.31,113.09 arc(11.33,113.22) 11.31,113.34 11.29,113.4 11.19,113.68 11.19,114.01 11.21,114.04 11.21,114.06
  IN3 w0.102: 11.21,114.06 11.21,114.31 11.47,114.56 14.41,114.56 25.23,103.74 25.23,101.96 25.12,101.85 24.97,101.85 v4(24.76,102.05)
DDC_DAT_HDMI: length 27.3
  TOP w0.102: U22.33 26.55,100.9 26.38,101.07 26.19,101.07 25.65,101.61 25.54,101.61 v3(25.22,101.29)
  GND1 w0.102: v3(25.22,101.29) 25.09,101.42 v4(24.76,101.42)
  IN3 w0.089: 10.99,114.06 10.99,114.04 11.01,114.01 11.01,113.65 11.12,113.34 11.15,113.28 arc(11.16,113.22) 11.14,113.16 arc(11.14,113.15) 11.14,113.15 11.04,112.82 11.04,112.64 arc(11.02,112.55) 10.96,112.48 JHDMI.16
  IN3 w0.102: v4(24.76,101.42) 24.97,101.62 25.21,101.62 25.46,101.87 25.46,103.84 14.51,114.79 11.37,114.79 10.99,114.4 10.99,114.06
DDR3_DRAMRST#: length 142.4
  IN1 w0.102: v1(129.2,55.87) 129.98,55.09 129.98,47.06 126.05,43.13 126.05,34.87 124.32,33.14 v1(124.32,30.68)
  IN3 w0.102: v4(191.17,22.09) 191.17,22.09 191.2,22.07 188.03,22.07 187.32,22.78 180.5,22.78 175.13,28.15 172.66,28.15 168.53,32.27 166.21,32.27 164.68,33.79 125.01,33.79 124.32,33.11 v1(124.32,30.68)
  IN4 w0.102: v1(192.1,24.52) 191.17,23.59 v4(191.17,22.09)
  BOTTOM w0.102: RU73.2 143.76,55.44 142.75,54.43 130.65,54.43 v1(129.2,55.87) ; JDIMM1.30 117.6,30.24 118.03,30.68 v1(124.32,30.68) ; JDIMM2.30 v1(192.1,24.52)
DDR3_DRAMRST#_R: length 4.4
  BOTTOM w0.102: QU3.1 143.56,67.42 143.76,67.22 v2(143.76,66.48) RU73.1 RU72.2
DDR_A_BS0: length 64.1
  IN4 w0.117: v1(144.52,36.64) 144.52,36.88 144.39,37.01 144.06,37.01 143.94,36.88 143.94,34.06 144.06,33.93 144.83,33.93 144.95,34.06 144.95,34.3 144.83,34.42 144.55,34.42 144.42,34.55 144.42,34.76 144.55,34.89 144.83,34.89 144.95,35.02 144.95,43.35 166.46,64.85 166.46,68.54 166.96,69.03 166.96,72.37 167.08,72.5 167.27,72.5 167.4,72.37 167.4,71.01 167.5,70.91 v1(167.85,70.91)
  BOTTOM w0.089: U6.BC20 167.13,75.85 167.13,71.62 v1(167.85,70.91)
  BOTTOM w0.16: v1(144.52,36.64) 144.09,36.64 143.7,36.25 JDIMM1.109
DDR_A_BS1: length 64.7
  IN4 w0.117: v1(167.85,69.51) 167.52,69.51 167.4,69.38 167.4,68.77 166.91,68.28 166.91,64.71 145.4,43.2 145.4,31.79 145.28,31.67 143.32,31.67 143.19,31.55 143.19,31.29 143.32,31.16 145.27,31.16 145.4,31.03 145.4,29.93 145.24,29.77 v1(144.5,29.77)
  BOTTOM w0.089: 167.11,70.25 166.94,70.41 166.94,75.15 U6.BD21
  BOTTOM w0.16: v1(144.5,29.77) 143.4,28.67 JDIMM1.108 ; 167.11,70.25 v1(167.85,69.51)
DDR_A_BS2: length 62
  IN4 w0.117: v1(132.04,38.17) 132.04,38.41 132.17,38.53 132.66,38.53 132.79,38.41 132.79,36.8 132.92,36.67 133.16,36.67 133.29,36.8 133.29,38.97 133.16,39.1 132.46,39.1 132.33,39.22 132.33,39.44 132.46,39.56 133.16,39.56 133.29,39.69 133.29,45.07 147.09,58.87 147.09,67.25 150.7,70.86 154.23,70.86 157.77,74.41 v1(158.1,74.41)
  BOTTOM w0.089: v1(158.1,74.41) 158.75,74.41 158.89,74.54 158.89,75.03 U6.BD32
  BOTTOM w0.16: v1(132.04,38.17) 132.07,38.17 133.95,36.29 133.95,36.06 134.7,35.31 JDIMM1.79
DDR_A_CAS#: length 62.1
  IN4 w0.117: v1(167.85,66.71) 167.85,66.7 167.85,64.46 160.75,57.36 160.75,57.19 160.98,56.96 160.98,56.78 160.83,56.63 160.65,56.63 160.42,56.86 160.26,56.86 160.09,56.7 160.09,56.53 160.33,56.3 160.33,56.13 160.16,55.97 160,55.97 159.76,56.2 159.6,56.2 159.41,56.01 159.41,55.85 159.64,55.61 159.64,55.45 159.48,55.28 159.31,55.28 159.08,55.52 158.91,55.52 158.75,55.35 158.75,55.18 158.98,54.95 158.98,54.78 158.82,54.62 158.65,54.62 158.41,54.85 158.25,54.85 158.08,54.69 158.08,54.52 158.32,54.29 158.32,54.12 158.15,53.96 157.99,53.96 157.75,54.19 157.59,54.19 157.42,54.03 157.42,53.86 157.66,53.63 157.66,53.46 157.49,53.3 157.33,53.3 157.09,53.53 156.93,53.53 156.76,53.37 156.76,53.2 157,52.96 157,52.8 156.83,52.63 156.67,52.63 156.43,52.87 156.27,52.87 156.1,52.7 156.1,52.54 156.34,52.3 156.34,52.14 156.17,51.97 156,51.97 155.77,52.21 155.6,52.21 155.44,52.04 155.44,51.88 155.67,51.64 155.67,51.48 155.51,51.31 155.34,51.31 155.11,51.55 154.94,51.55 154.78,51.38 154.78,51.22 155.01,50.98 155.01,50.82 154.85,50.65 154.68,50.65 154.45,50.89 154.28,50.89 154.12,50.72 154.12,50.55 154.35,50.32 154.35,50.15 154.19,49.99 154.02,49.99 153.78,50.22 153.62,50.22 153.45,50.06 153.45,49.89 153.69,49.66 153.69,49.49 147.01,42.81 147.01,36.38 146.9,36.28 146.57,36.28 146.47,36.38 v1(146.47,36.64)
  BOTTOM w0.089: U6.BE21 166.4,74.76 166.27,74.62 166.27,72.55 166.17,72.45
  BOTTOM w0.16: v1(167.85,66.71) 167.32,67.24 167.32,67.83 166.17,68.98 166.17,72.45 ; JDIMM1.115 145.5,35.41 145.56,35.47 145.56,36.6 145.91,36.95 146.16,36.95 v1(146.47,36.64)
DDR_A_D0: length 78.6
  IN4 w0.076: v1(109.02,37.28) 109.29,37.28 109.41,37.15 109.41,34.66 109.54,34.53 109.72,34.53 109.84,34.66 109.84,38.97 118.54,47.67 118.54,47.8 118.15,48.18 118.15,48.29 118.26,48.4 118.37,48.4 118.76,48.01 118.88,48.01 118.97,48.1 118.97,48.23 118.59,48.62 118.59,48.72 118.69,48.83 118.8,48.83 119.03,48.6 119.16,48.6 119.25,48.69 119.25,48.82 119.02,49.05 119.02,49.15 133.34,63.47 133.34,67.99 133.28,68.04 133.28,72.6 135.63,74.94 135.63,82 140.6,86.98 143.26,86.98 v1(143.32,86.91)
  BOTTOM w0.089: v1(143.32,86.91) 143.73,86.51 U6.AH54
  BOTTOM w0.102: JDIMM1.7 110.7,35.6 v1(109.02,37.28)
