# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TMDS_L_TX2P: length 22.6
  TOP w0.102: LV10.3 18.41,97.06 18.17,97.3 17.43,97.3 16.39,98.35 16.39,99.58 16.29,99.68 13.71,99.68 13.49,99.9 13.49,100.52 13.71,100.74 16.29,100.74 16.39,100.84 16.39,101.27 16.29,101.37 14.8,101.37 14.58,101.59 14.58,102.13 14.8,102.35 v9(15.81,102.35) 16.29,102.35 16.39,102.46 16.39,103.76 16.29,103.86 16.19,103.86 16.04,103.72 DV5.1 DV5.9 14.25,103.72 14.1,103.88 13.56,103.88 12.36,105.08 12.15,105.08 JHDMI.1
TMDS_L_TXCN: length 31.2
  TOP w0.102: v1(13.64,109.16) 13.71,109.08 DV4.1 DV4.9 16.04,109.08 16.11,109.01 16.64,109.01 16.78,109.15 16.78,109.36 16.75,109.38 16.75,109.94 16.78,109.96 v9(16.78,110.96) 16.78,111.84 19.86,114.93 20.7,114.93 23.96,118.19 24.5,118.19 24.72,118.42 LV7.2
  BOTTOM w0.089: JHDMI.12 11.16,109.61 11.16,108.65 11.29,108.42 arc(11.31,108.24) 11.29,108.06 11.22,107.81 arc(11.21,107.67) 11.24,107.53 11.29,107.37 arc(11.32,107.21) 11.3,107.06 11.27,106.95 11.22,106.8 arc(11.21,106.69) 11.22,106.58 11.29,106.36 arc(11.35,106.21) 11.31,106.05 11.24,105.91 11.21,105.84 arc(11.18,105.71) 11.21,105.58 11.28,105.44 arc(11.32,105.28) 11.3,105.11 11.29,105.07 11.2,104.7 11.2,104.49 11.21,104.48 11.21,104.46 11.22,104.46 11.22,104.42 11.22,104.42 11.22,104.41
  BOTTOM w0.102: v1(13.64,109.16) 13.64,109.15 13.51,109.02 12.99,109.02 12.55,108.59 12.55,103.89 12.33,103.67 11.42,103.67 11.22,103.86 11.22,104.41
TMDS_L_TXCP: length 30.9
  TOP w0.102: v1(13.6,108.54) 13.94,108.88 14.05,108.88 14.34,108.58 DV4.2 DV4.8 16.04,108.58 16.26,108.81 16.72,108.81 16.98,109.07 v9(16.98,109.66) 16.98,110.66 17,110.68 17,111.23 16.98,111.25 16.98,111.76 19.95,114.72 20.79,114.72 24.05,117.99 24.3,117.99 24.72,117.57 LV7.3
  BOTTOM w0.089: 11.01,104.41 11.01,104.57 11.02,104.58 11.02,104.72 11.12,105.11 11.13,105.16 arc(11.14,105.26) 11.11,105.37 arc(11.08,105.44) 11.05,105.5 arc(11,105.71) 11.05,105.92 arc(11.07,105.95) 11.08,105.99 11.16,106.13 arc(11.17,106.19) 11.14,106.25 11.05,106.53 arc(11.03,106.69) 11.05,106.85 arc(11.07,106.92) 11.1,107 11.13,107.11 arc(11.14,107.21) 11.12,107.31 arc(11.11,107.34) 11.1,107.38 11.07,107.47 arc(11.04,107.66) 11.05,107.85 arc(11.05,107.85) 11.05,107.85 11.09,107.98 arc(11.1,108.05) 11.12,108.11 arc(11.14,108.24) 11.11,108.37 10.99,108.6 10.99,108.78 JHDMI.10
  BOTTOM w0.102: v1(13.6,108.54) 13.33,108.82 13.08,108.82 12.76,108.5 12.76,103.8 12.42,103.46 11.33,103.46 11.01,103.77 11.01,104.41
TMDS_RD_TX0N: length 18.6
  TOP w0.102: LV8.1 26.92,116.57 27.65,116.57 27.87,116.35 v9(27.87,114.87) 27.87,112.5 27.98,112.4 28.99,112.4 29.21,112.18 29.21,111.7 28.99,111.48 27.98,111.48 27.82,111.33 27.82,105.72 28.43,105.12 28.46,105.12 28.85,104.73 28.85,104.7 30.17,103.38 U22.24
TMDS_RD_TX0P: length 18.6
  TOP w0.102: U22.25 29.77,102.93 29.82,102.98 29.91,102.98 29.96,103.03 29.96,103.29 v9(28.49,104.76) 27.62,105.64 27.62,111.41 27.89,111.69 28.9,111.69 29,111.79 29,112.09 28.9,112.19 27.89,112.19 27.67,112.42 27.67,114.57 27.65,114.59 27.65,115.14 27.67,115.16 27.67,116.26 27.56,116.37 27.36,116.37 27.25,116.26 27.25,116.1 27.07,115.91 LV8.4
TMDS_RD_TX1N: length 13.7
  TOP w0.102: LV9.1 21.33,99.62 21.41,99.54 21.77,99.54 22,99.77 v9(22,101.38) 22,102.18 22.94,103.12 22.94,103.54 23.76,104.36 25.01,104.36 25.03,104.38 25.59,104.38 25.61,104.36 28.21,104.36 29.21,103.36 29.21,103.04 29.37,102.89 U22.26
TMDS_RD_TX1P: length 13.7
  TOP w0.102: LV9.4 21.25,98.77 21.35,98.87 21.35,99.23 21.46,99.34 21.86,99.34 22.21,99.69 22.21,101.08 22.23,101.1 22.23,101.66 22.21,101.68 22.21,102.09 23.15,103.03 23.15,103.45 23.85,104.15 v9(25.31,104.15) 28.13,104.15 29.01,103.27 29.01,103.04 28.97,103 U22.27
TMDS_RD_TX2N: length 13.6
  TOP w0.102: v1(22.82,98.94) 22.44,98.56 22.24,98.56 22.03,98.35 22.03,98.05 21.9,97.93 21.48,97.93 21.46,97.91 LV10.1 ; v1(27.05,103.66) 27.23,103.48 27.84,103.48 28.07,103.26 28.07,103 28.17,102.9 U22.29
  IN4 w0.089: v1(22.82,98.94) 23.01,98.75 23.84,98.75 24.34,99.25 26.18,99.25 26.6,99.68 26.6,100.54 26.38,100.77 26.38,103.2 26.64,103.45 26.85,103.45 v1(27.05,103.66)
TMDS_RD_TX2P: length 13.6
  TOP w0.102: v1(27.05,103.07) 27.25,103.27 27.76,103.27 27.86,103.17 27.86,103 27.77,102.91 U22.30 ; v1(22.82,98.35) 22.33,98.35 22.24,98.27 22.24,97.96 21.97,97.7 v9(21.75,97.7) 21.46,97.7 21.35,97.59 21.35,97.16 21.25,97.06 LV10.4
  IN4 w0.089: v1(27.05,103.07) 26.85,103.27 26.71,103.27 26.56,103.12 26.56,100.85 26.79,100.62 26.79,99.6 26.25,99.07 24.41,99.07 23.91,98.57 23.03,98.57 v1(22.82,98.35)
TMDS_RD_TXCN: length 18.5
  TOP w0.102: U22.21 31.37,102.85 31.35,102.86 31.35,104.73 30.92,105.16 30.92,115.2 30.37,115.75 30.37,115.78 29.98,116.17 29.95,116.17 v9(28.8,117.32) 27.85,118.28 27.12,118.28 26.97,118.42 LV7.1
TMDS_RD_TXCP: length 18.5
  TOP w0.102: U22.22 30.97,102.93 31.02,102.98 31.1,102.98 31.15,103.03 31.15,104.65 30.71,105.08 30.71,115.11 v9(30.01,115.81) 28.87,116.96 28.84,116.96 28.45,117.35 28.45,117.38 27.76,118.07 27.47,118.07 27.25,117.86 27.25,117.75 27.07,117.57 LV7.4
TMDS_TX0N: length 2.6
  TOP w0.102: U22.7 30.17,96.78 30.1,96.71 30.1,96.15 30.15,96.1 30.44,96.1 30.62,95.92 30.62,95.68 CV760.1
TMDS_TX0P: length 2.6
  TOP w0.102: U22.6 29.77,96.78 29.89,96.65 29.89,96.06 30.06,95.89 30.35,95.89 30.41,95.83 30.41,95.67 CV761.1
TMDS_TX1N: length 2.4
  TOP w0.102: U22.5 29.37,96.94 29.27,96.85 29.27,96.26 28.86,95.85 28.86,95.66 CV762.1
TMDS_TX1P: length 2.4
  TOP w0.102: CV763.1 28.65,95.69 28.65,95.94 29.06,96.35 29.06,96.8 28.97,96.9 U22.4
TMDS_TX2N: length 2.7
  TOP w0.102: v9(27.61,96.26) 27.61,96.26 ; 27.61,96.26 27.37,96.02 27.28,96.02 27.06,95.8 27.06,95.68 CV764.1 ; 27.61,96.26 28.07,96.72 28.07,96.85 28.17,96.94 U22.2
TMDS_TX2P: length 2.7
  TOP w0.102: CV765.1 26.86,95.68 26.86,95.89 27.19,96.23 27.28,96.23 27.86,96.81 27.86,96.85 27.77,96.94 U22.1
TMDS_TXCN: length 2.7
  TOP w0.102: U22.10 31.37,96.86 31.62,96.61 31.65,96.61 32.04,96.21 32.04,96.19 32.33,95.9 32.33,95.76 CV758.1
TMDS_TXCP: length 2.7
  TOP w0.102: CV759.1 32.12,95.6 32.12,95.82 v9(31.68,96.25) 30.97,96.97 U22.9
TP_CLK: length 76.1
  TOP w0.089: 161.09,16.42 161.54,16.42 UE1.A5
  TOP w0.102: L1.1 217.98,20.84 C13.1 219.29,20.51 219.71,20.92 v2(219.71,22.61) v1(219.71,24.52) ; v1(172.74,16.19) 172.74,15.9 173.34,15.3 174.1,15.3 174.64,15.83 RPE2.8 ; 161.09,16.42 160.65,16.42 v1(160.36,16.71)
  IN2 w0.102: v1(160.36,16.71) 161.63,16.71 162.24,16.1 162.83,16.1 162.95,16.22 165.5,16.22 165.67,16.39 166.68,16.39 166.94,16.14 166.94,15.6 167.56,14.98 170.37,14.98 170.96,15.56 172.11,15.56 v1(172.74,16.19)
  IN4 w0.102: v1(219.71,24.52) 219.04,25.19 209.73,25.19 208.68,24.14 207.08,24.14 202.29,19.35 200.91,19.35 199.47,17.9 197.19,17.9 196.42,17.13 187.08,17.13 187.08,17.12 173.66,17.12 v1(172.74,16.19)
TP_CLK_R: length 10.8
  TOP w0.102: L1.2 215.48,21.42 C15.1 214.6,21.01 DE5.2 213.13,21.98 212.95,22.16 212.43,22.16 210.67,23.92 v1(210.67,24.56)
  BOTTOM w0.102: v1(210.67,24.56) 210.65,24.54 210.65,24.32 v2(210.26,23.92) 210.15,23.81 209.48,23.81 209.25,23.58 JTP.2
TP_DATA: length 66.8
  TOP w0.089: UE1.B5 162.64,17.02 v3(162.64,17.17)
  TOP w0.102: C14.1 217.98,22.99 L2.1 217.26,23.49 216.2,24.54 v1(216.2,24.6) ; v1(173.32,16.2) 173.32,15.8 v2(173.49,15.63) 174.15,15.63 174.5,15.98 174.5,16.2 174.63,16.33 RPE2.7
  GND1 w0.089: v4(161.99,17.17) v3(162.64,17.17)
  IN3 w0.076: v4(161.99,17.17) 162.48,17.17 163.13,16.52 165.61,16.52 166.32,17.23 168.49,17.23 168.73,17.47 168.78,17.47
  IN3 w0.102: 168.78,17.47 169.61,17.47 169.73,17.6 170.37,17.6 171.37,16.6 172.93,16.6 v1(173.32,16.2)
  IN4 w0.102: v1(173.32,16.2) 173.72,16.59 179.11,16.59 179.6,16.11 193.92,16.11 194.74,16.92 196.5,16.92 197.28,17.7 199.55,17.7 201,19.15 202.37,19.15 207.16,23.94 208.76,23.94 209.81,24.99 215.81,24.99 v1(216.2,24.6)
TP_DATA_R: length 8.7
  TOP w0.102: L2.2 215.34,22.99 C16.1 214.73,22.94 DE5.3 212.28,22.94 211.3,23.92 v1(211.3,24.56)
  BOTTOM w0.102: JTP.1 209.75,23.43 209.83,23.5 210.55,23.5 211.3,24.25 v1(211.3,24.56)
TRIP_+V1.05V: length 2.8
  BOTTOM w0.102: v2(228.07,65.83) 228.41,66.17 PR502.2
  BOTTOM w0.254: PR502.2 228.99,67.39 PU500.2
TS_SLEEP#: length 213.4
  TOP w0.102: v1(150.05,22.7) 149.64,22.29 v2(149.64,22.03) 149.64,20.51 149.19,20.05 UE36.6
  IN2 w0.102: v1(17.33,113) 17.23,112.9 17.23,102.04 11.71,96.52 11.71,85.72 16.94,80.49 16.94,80.2 17.4,79.74 20.64,79.74 22.24,78.14 22.24,75.18 23.2,74.21 23.2,71.55 25.77,68.99 25.77,64.42 26.68,63.5 26.68,59.48 29.15,57.02 29.15,52.84 29.81,52.18 30.4,52.18 30.65,51.94 30.65,47.67 34.06,44.25 36.71,44.25 38.08,42.88 39.75,42.88 45.38,37.26 49.88,37.26 50.24,36.89 53.4,36.89 54.34,35.95 60.04,35.95 60.45,35.54 63.1,35.54 65.63,33.01 81.77,33.01 82.08,32.7 85.58,32.7 86.45,31.83 99.18,31.83 107.81,23.2 121.27,23.2 121.76,23.69 131.43,23.69 132.8,22.31 145.13,22.31 145.71,22.89 149.86,22.89 v1(150.05,22.7)
  BOTTOM w0.102: DV17.1 16.49,112.91 16.57,113 v1(17.33,113)
U2_BOOT1:
  vias: v2(143.8,119.31)
U2_BOOT3: length 2.9
  TOP w0.254: PU801.4 181.03,124.52 180.66,124.89
  TOP w0.508: PR832.1 180.76,126.31 180.34,125.89 v2(180.34,125.28) 180.34,125.21 180.66,124.89
U2_LGATE1: length 22
  TOP w1.016: 160.57,127.9 145.05,127.9 144.13,126.99 144.13,121.83
  vias: v1(145.25,121.72) v1(145.83,121.72) v2(161.35,127.38) v9(160.69,126.63) v9(161.33,126.63)
U2_LGATE2: length 27.2
  TOP w0.102: v2(171.89,119.12) 171.23,119.78 v9(171.23,120.33)
  IN1 w1.016: 146.67,123.84 146.7,123.81 148.38,123.81 148.46,123.73 148.48,123.73 151.83,120.38 154.01,120.38 154.47,119.93 158.76,119.93 159.65,120.82 170.45,120.82
  vias: v1(145.73,124.01) v1(145.73,123.43) v9(171.23,120.99)
U2_LGATE3:
  vias: v2(180.96,121.67) v9(181.23,121.04) v9(181.86,121.04)
U2_PHASE1: length 20.4
  TOP w1.016: 154.49,126.45 151.62,126.45 148.91,123.73 148.91,122.46 147.2,120.76 147.03,120.76
  IN4 w0.254: v1(141.64,128.21) 141.64,125.64 144.69,122.59 144.69,121.45 145.35,120.79 v1(145.35,120.53)
  BOTTOM w0.254: v1(141.64,128.21) PR850.1
  vias: v1(144.77,120.53) v2(155.79,126.02) v9(155.36,126.76) v9(155.99,126.76)
U2_PHASE2: length 33.1
  TOP w0.102: v2(145.93,125.37) 145.87,125.43 v1(145.1,125.43)
  IN1 w1.016: 144.84,126.68 146.06,127.9 170.47,127.9
  IN3 w0.254: v1(140.75,128.21) 142,126.96 143.57,126.96 v1(145.1,125.43)
  BOTTOM w0.254: v1(140.75,128.21) PR851.1
  vias: v1(145.07,124.77) v9(170.57,127.01) v9(171.21,127.01)
U2_PHASE3: length 44.6
  TOP w0.102: v2(183.72,128.46) 183.28,128.02 183.28,126.98 182.62,126.31 PC839.2
  IN2 w0.254: v9(179.93,127.08) 178.66,128.35 142.6,128.35 141.9,127.65 140.39,127.65 v1(139.83,128.21)
  BOTTOM w0.254: v1(139.83,128.21) 139.86,128.18 PR852.1
  vias: v9(179.93,126.44) v9(182.16,125.11) v9(182.54,125.62)
U2_PWM3: length 52.2
  TOP w0.254: PU801.5 181.03,121.84 180.5,121.32 v2(180.5,120.94) v1(180.5,120.3)
  IN2 w0.254: v1(180.5,120.3) 179.29,119.09 161.1,119.09 159.88,117.86 156.7,117.86 155.97,117.13 155.97,113.34 154.6,111.97 150.35,111.97 148.91,113.42 148.91,120.15 146.75,122.31 v1(145.38,122.31)
  BOTTOM w0.254: v1(145.38,122.31) 144.93,122.31 144.82,122.19 PU800.22
U2_UGATE1: length 13.3
  TOP w1.016: 153.84,124.85 152.01,124.85 150.28,123.13 150.28,121.45 147.46,118.63 144.16,118.63 144.13,118.66
  vias: v1(143.14,119.57) v1(143.14,118.96) v2(143.76,119.45) v9(154.7,125.01) v9(154.7,124.37)
U2_UGATE2: length 26.7
  TOP w0.102: v1(143.04,126.04) 143.04,126.12 v2(142.44,126.72)
  IN4 w1.016: 143.83,126.86 144.87,127.9 169.2,127.9
  vias: v1(143.04,125.46) v9(169.23,127.01) v9(169.86,127.01)
U2_UGATE3:
  vias: v2(181.42,126.47) v9(181.01,125.62) v9(181.39,125.11)
UG_3V: length 13.6
  IN4 w1.016: 38.8,21.78 39.46,21.78 40.32,22.64 44.44,22.64 45.27,23.48 45.27,29.66 45.2,29.73 45.27,29.81
  vias: v2(45.71,29.62) v9(37.38,19.9) v9(37.88,20.28) v9(45.63,30.19) v9(46.22,30.85)
UG_5V:
  vias: v2(51.65,28.41)
UG_+V1.05V: length 14.2
  IN2 w1.016: 233.72,65.16 236.64,62.24 245.68,62.24
  BOTTOM w0.102: v9(233.82,67.32) 234.48,67.32 v2(234.76,67.04)
  vias: v9(233.82,66.68) v9(247.58,62.06) v9(248.22,62.06)
UGATE1: length 64.1
  TOP w0.102: v9(112.48,72.3) v2(111.74,72.3)
  IN2 w1.016: 126.96,112.43 126.63,112.1 126.63,100.69 127.37,99.96 127.37,72.55 122.13,67.32 112.11,67.32 111.18,68.24 111.18,72.54 111.19,72.55
  vias: v9(113.12,72.3) v9(125.64,112.86) v9(125.64,112.2)
UGATE2: length 7.2
  IN1 w1.016: 120.21,114.77 119.67,114.77 118.63,113.73 118.63,110.02
  BOTTOM w0.102: v2(120.18,109.3) 120.01,109.13 v9(118.76,109.13)
  vias: v9(118.18,108.78) v9(121.2,115.1) v9(121.2,114.47)
USB0_CTL1: length 169.8
  TOP w0.089: 161.56,15.91 161.99,15.91 162.24,16.16 UE1.B4
  TOP w0.102: 161.56,15.91 161.15,15.5 161,15.5 v1(160.65,15.15) ; v1(30.21,51.77) 29.28,52.7 27.04,52.7 25.58,51.23 22.65,51.23 22.1,51.79 20.82,51.79 v1(20.55,51.51)
  IN2 w0.102: v1(30.21,51.77) 30.21,47.81 34.13,43.9 36.78,43.9 38,42.68 39.67,42.68 45.29,37.05 49.79,37.05 50.16,36.69 53.32,36.69 54.26,35.75 59.96,35.75 60.37,35.34 63.01,35.34 65.54,32.81 81.68,32.81 81.99,32.5 83.74,32.5 84.61,31.63 99.09,31.63 108.47,22.26 118.4,22.26 119.04,22.89 121.25,22.89 121.84,23.49 131.34,23.49 132.72,22.11 145.21,22.11 145.77,22.66 148.16,22.66 149.39,21.43 149.39,20.28 150.27,19.4 154.11,19.4 155.6,17.91 156.31,17.91 158.94,15.29 159.27,15.29 159.85,15.86 160.44,15.86 160.65,15.64 v1(160.65,15.15)
  BOTTOM w0.102: v1(20.55,51.51) 20.03,51.51 19.82,51.72 v2(19.82,51.85) 19.82,52.59 RE63.2 21.02,53.09 21.45,52.66 22.74,52.66 22.8,52.6 US1.6
USB0_DET_EC#: length 215.5
  TOP w0.102: v1(191.2,12.64) 190.73,12.18 DE7.1 DE10.1 189.12,11.43 v2(189.88,10.68)
  IN2 w0.102: JUSB1.10 14.03,62.01 14.9,62.01 16.41,63.52 22.42,63.52 24.57,61.37 24.57,59.22 26.88,56.9 26.88,53.35 28.41,51.82 28.41,45.81 28.79,45.43 31.08,45.43 33.63,42.88 36.36,42.88 36.74,42.5 36.74,41.41 41.67,36.48 44.43,36.48 44.87,36.04 49.37,36.04 49.74,35.67 52.28,35.67 53.02,34.93 59.52,34.93 59.93,34.53 62.68,34.53 64.86,32.35 64.86,30.84 66.17,29.52 71.69,29.52 72.42,30.26 80.44,30.26 81.04,29.66 81.04,29.14 81.79,28.39 91.67,28.39 93.66,26.4 96.15,26.4 96.4,26.65 101.2,26.65 107.71,20.14 116.2,20.14 116.81,19.52 122.02,19.52 122.79,18.75 123.83,18.75 123.93,18.86 128.01,18.86 128.65,19.49 141.22,19.49 142.54,18.17 142.91,18.17 143.09,18.35 144,18.35 144.04,18.3 144.04,18.3 144.91,17.43 147.73,17.43 148.2,16.96 153.1,16.96 153.45,16.61 153.45,15.46 155.71,13.2 156.64,13.2 157.28,12.56 158.01,12.56 159.11,11.46 183.25,11.46 184.44,12.64 v1(191.2,12.64)
USB0_DET_EC#_D: length 34
  TOP w0.089: v3(166.62,14.23) 166.53,14.32 166.53,14.91 UE1.K2
  TOP w0.102: DE7.2 RE55.2 193.91,12.58 v1(193.86,12.63) 193.86,12.96 v2(194.04,13.14)
  GND1 w0.076: v4(166.37,13.72) 166.37,13.72 166.62,13.98 v3(166.62,14.23)
  IN3 w0.102: v4(166.37,13.72) 167.23,13.72 167.51,13.45 169.65,13.45 170.08,13.88 171.45,13.88 171.87,14.3 171.87,14.72 172.11,14.96 176.21,14.96 176.81,14.36 181.23,14.36 181.82,14.96 184.25,14.96 185.96,13.25 193.24,13.25 v1(193.86,12.63)
USB0_PWR_EN_EC: length 166.4
  TOP w0.076: 162.15,14.34 162.28,14.46 UE1.B1
  TOP w0.102: v1(22.96,51.64) 25.7,51.64 26.97,52.92 29.7,52.92 v1(30.07,53.28) ; 162.15,14.34 161.92,14.11 v3(161.92,13.82)
  GND1 w0.076: v5(161.74,14.14) 161.92,13.95 v3(161.92,13.82)
  IN1 w0.076: v5(161.74,14.14) 161.46,14.41 160.65,14.41
  IN1 w0.102: v4(157.71,18.3) 157.71,16.37 159.66,14.41 160.65,14.41
  IN2 w0.102: v1(30.07,53.28) 30.4,53.28 31.28,52.41 31.28,47.9 34.31,44.86 36.97,44.86 38.34,43.49 40,43.49 45.63,37.87 50.23,37.87 50.59,37.5 53.65,37.5 54.59,36.56 60.3,36.56 60.7,36.15 64.82,36.15 65.14,35.84 65.14,35.68 66.99,33.83 82.25,33.83 82.56,33.52 85.97,33.52 86.8,32.68 99.49,32.68 108.17,24.01 114.08,24.01 115.32,25.25 133.04,25.25 133.69,24.6 146.35,24.6 147.06,23.88 150.45,23.88 151.12,23.21 151.12,22.09 152.48,20.73 153.7,20.73 155.74,18.7 157.31,18.7 157.71,18.3 v4(157.71,18.3)
  BOTTOM w0.102: v1(22.96,51.64) 22.64,51.64 RI17.2 ; RI17.2 22.12,51.53 v2(21.7,51.11) ; RI17.2 22.59,52.15 22.64,52.1 US1.5
USB1_CTL1: length 194.4
  TOP w0.089: v3(165.34,14.17) 165.28,14.23 UE1.H1
  TOP w0.102: US2.6 v1(21.85,79.9) 21.85,80.12 21.18,80.78 v2(19.56,80.78) RE65.2
  GND1 w0.076: v4(165.16,14.63) 165.34,14.45 v3(165.34,14.17)
  IN2 w0.076: 161.06,16.1 162.52,14.64 162.85,14.64 163.13,14.92 164.37,14.92 164.66,14.63 v4(165.16,14.63)
  IN2 w0.102: v1(21.85,79.9) 22.26,79.49 23.28,79.49 23.51,79.71 24.34,79.71 25.05,79.01 25.05,74.24 23.61,72.8 23.61,71.72 26.17,69.16 26.17,64.59 27.09,63.67 27.09,59.65 29.59,57.15 29.59,52.97 29.97,52.59 30.57,52.59 31.05,52.1 31.05,47.83 34.23,44.66 36.88,44.66 38.25,43.29 39.92,43.29 45.55,37.66 50.14,37.66 50.51,37.3 53.57,37.3 54.51,36.36 60.21,36.36 60.62,35.95 63.27,35.95 65.8,33.42 81.93,33.42 82.25,33.11 85.8,33.11 86.67,32.24 99.35,32.24 107.98,23.6 121.1,23.6 121.59,24.1 131.51,24.1 132.01,24.59 133.12,24.59 133.52,24.19 146.02,24.19 146.75,23.46 150.25,23.46 150.66,23.05 150.66,21.96 152.42,20.2 153.6,20.2 155.68,18.12 156.4,18.12 158.42,16.1 161.06,16.1
USB1_DET_EC#: length 228.6
  TOP w0.102: DE13.1 DE15.1 188.81,15 v1(188.81,14.42) v2(189.81,14.42)
  IN2 w0.102: JUSB3.10 16.49,80.08 17.39,79.18 20.33,79.18 21.21,78.3 21.21,75.63 22.79,74.04 22.79,69.99 24.61,68.18 24.61,64.71 26.07,63.25 26.07,61.68 24.98,60.59 24.98,59.43 27.49,56.92 27.49,54.87 28.02,54.34 28.02,52.67 28.61,52.08 28.61,45.94 28.92,45.63 31.17,45.63 33.71,43.09 36.44,43.09 36.94,42.59 36.94,41.49 41.76,36.68 44.52,36.68 44.96,36.24 49.45,36.24 49.82,35.87 52.36,35.87 53.1,35.14 59.61,35.14 60.01,34.73 62.76,34.73 65.06,32.43 65.06,30.92 66.26,29.73 71.6,29.73 72.34,30.46 80.53,30.46 81.24,29.75 81.24,29.22 81.87,28.6 92.63,28.6 93.81,29.78 98.36,29.78 107.8,20.34 116.28,20.34 116.89,19.73 122.1,19.73 122.87,18.96 123.74,18.96 123.85,19.06 127.93,19.06 128.56,19.7 146.06,19.7 147.26,18.5 147.93,18.5 148.1,18.34 148.1,17.77 148.5,17.37 153.27,17.37 153.86,16.78 153.86,15.63 155.88,13.61 157.11,13.61 157.66,13.06 158.49,13.06 159.6,11.95 183.06,11.95 185.53,14.42 v1(188.81,14.42)
USB1_DET_EC#_D: length 33.1
  TOP w0.089: UE1.J2 166.03,14.91 166.03,14.43 166.17,14.29 166.17,13.94 v3(165.84,13.6)
  TOP w0.102: v1(192.73,14.55) 192.93,14.75 DE13.2 RE69.2
  GND1 w0.076: 165.84,13.6 v3(165.84,13.6)
  GND1 w0.102: v4(166.09,12.53) 166.09,12.53 165.84,12.78 165.84,13.6
  IN2 w0.102: v4(166.09,12.53) 166.09,12.53 166.46,12.16 182.98,12.16 185.65,14.83 187.75,14.83 188.02,15.1 192.19,15.1 v1(192.73,14.55)
USB1_PWR_EN_EC: length 187.8
  TOP w0.089: v3(162.93,16.45) 163.14,16.66 UE1.D5
  TOP w0.102: v2(20.91,81.66) 22.05,80.52 RI32.2 22.47,80.44 v1(22.47,79.9) 22.35,79.78 US2.5
  GND1 w0.089: v3(162.93,16.45) v4(162.42,16.45)
  IN2 w0.076: 160.65,17.32 161.25,17.32 162.11,16.45 v4(162.42,16.45)
  IN2 w0.102: 160.65,17.32 159.2,17.32 158.79,17.72 158.44,17.72 158.15,18.01 158.15,18.62 157.82,18.95 155.78,18.95 153.72,21 152.5,21 151.33,22.18 151.33,23.29 150.53,24.09 147.14,24.09 146.43,24.8 133.77,24.8 133.12,25.45 107.33,25.45 99.69,33.09 86.97,33.09 86.14,33.92 82.73,33.92 82.42,34.23 69.78,34.23 68.42,35.6 65.95,35.6 64.99,36.56 60.87,36.56 60.47,36.96 54.76,36.96 53.82,37.9 51.05,37.9 49.78,39.17 47.54,39.17 46.94,39.78 44.57,39.78 40.46,43.9 39.49,43.9 36.34,47.05 32.7,47.05 31.68,48.06 31.68,53.03 29.79,54.92 29.79,57.23 27.29,59.74 27.29,63.76 26.38,64.67 26.38,69.24 23.81,71.81 23.81,72.71 25.25,74.15 25.25,79.11 24.06,80.3 22.87,80.3 v1(22.47,79.9)
USB2_CTL1: length 145.6
  TOP w0.102: UE36.14 144.26,19.55 144,19.3 144,19.14 143.69,18.83 143.24,18.83 v1(142.86,19.21) 142.38,18.73 142.38,15.81 v2(142.73,15.45)
  IN2 w0.102: v1(142.86,19.21) 143.52,18.55 144.08,18.55 144.13,18.5 145,17.64 147.81,17.64 148.28,17.17 153.18,17.17 153.66,16.69 153.66,15.55 155.8,13.41 157.02,13.41 157.58,12.85 158.41,12.85 159.51,11.75 183.15,11.75 185.24,13.84 207.09,13.84 208.09,14.84 211.27,14.84 213.47,17.05 220.36,17.05 224.1,13.31 224.7,13.31 225.35,12.66 233.39,12.66 234.68,13.94 243.38,13.94 243.43,13.89 252.34,13.89 253.43,12.8 258.74,12.8 259.09,13.14 263.81,13.14 264.73,12.23 v4(269.68,12.23)
  IN4 w0.102: v6(269.73,11.23) 269.73,12.17 v4(269.68,12.23)
  GND3 w0.102: v7(269.73,10.55) v6(269.73,11.23)
  BOTTOM w0.102: JTB1.6 270.1,10.18 v7(269.73,10.55)
USB2_DET_EC#: length 92.7
  TOP w0.102: v1(190.41,14.42) 190.73,14.11 DE14.1 DE16.1 189.12,13.58 v2(189.95,12.75)
  IN2 w0.102: v4(271.03,11.54) 270.98,11.54 269.72,12.8 267.25,12.8 266.88,12.43 264.82,12.43 263.9,13.35 259,13.35 258.66,13 253.51,13 252.42,14.09 243.52,14.09 243.46,14.15 234.59,14.15 233.5,13.06 229.09,13.06 228.49,13.65 227.76,13.65 226.99,12.88 225.42,12.88 224.63,13.67 224.02,13.67 220.44,17.25 213.39,17.25 211.18,15.04 208.01,15.04 207,14.04 190.8,14.04 v1(190.41,14.42)
  IN4 w0.102: v4(271.03,11.54) 271.03,11.49 270.72,11.18 v6(270.72,11.16)
  GND3 w0.102: v6(270.72,11.16) 270.9,10.98 v7(270.9,10.09)
  BOTTOM w0.102: JTB1.2 v7(270.9,10.09)
USB2_DET_EC#_D: length 53.5
  TOP w0.102: RE71.2 193.41,13.6 DE14.2 192.29,13.6 192.04,13.85 v1(192.04,14.55) ; UE36.8 147.43,21.27 147.67,21.5 v1(148.52,21.5)
  IN3 w0.102: v1(148.52,21.5) 149.16,20.86 154.6,20.86 155.14,21.4 160.12,21.4 160.75,22.03 167.34,22.03 167.59,22.28 171.65,22.28 172.39,21.55 172.39,20.44 173.38,19.45 176.5,19.45 177.65,18.3 188.28,18.3 v1(192.04,14.55)
  BOTTOM w0.102: v1(148.52,21.5) 149.16,21.5 v2(149.21,21.55)
USB2_PWR_EN_EC: length 141.9
  TOP w0.102: UE36.16 144.21,18.55 143.72,18.07 143.39,18.07 v1(143.27,17.94)
  IN2 w0.102: v1(143.27,17.94) 143.42,18.1 143.96,18.1 145.51,16.54 147.29,16.54 147.51,16.76 153.02,16.76 153.25,16.52 153.25,15.38 155.63,13 156.55,13 157.2,12.36 157.92,12.36 159.03,11.25 183.34,11.25 184.53,12.44 190.66,12.44 190.87,12.24 191.41,12.24 191.65,12.48 191.65,13.04 191.98,13.37 194.34,13.37 195.29,12.42 200.17,12.42 201.38,13.63 207.17,13.63 208.18,14.64 211.35,14.64 213.56,16.84 217.42,16.84 221.16,13.11 224.62,13.11 225.27,12.45 233.47,12.45 234.76,13.74 243.29,13.74 243.35,13.69 252.26,13.69 253.34,12.6 258.83,12.6 259.17,12.94 263.73,12.94 264.65,12.02 268.54,12.02 268.82,11.74 v4(270.17,11.74)
  IN4 w0.102: v4(270.17,11.74) 270.24,11.67 v6(270.24,11.23)
  GND3 w0.102: v7(270.24,10.52) v6(270.24,11.23)
  BOTTOM w0.102: v7(270.24,10.52) 270.5,10.27 JTB1.4
USB3_CTL1: length 142.6
  TOP w0.102: v1(144.61,14.08) 144.61,14.55 v2(144.23,14.94) 142.59,16.57 142.59,17.85 143.1,18.36 143.52,18.36 144.22,19.05 UE36.15
  IN2 w0.102: v1(144.61,14.08) 144.61,14.38 145.02,14.79 147.61,14.79 148.3,15.48 152.29,15.48 155.28,12.48 155.28,11.57 155.81,11.05 183.42,11.05 184.61,12.24 190.58,12.24 190.8,12.01 191.48,12.01 191.86,12.39 191.86,12.95 192.07,13.17 194.19,13.17 195.14,12.22 200.25,12.22 201.47,13.43 208.41,13.43 209.42,14.44 211.44,14.44 213.64,16.64 217.34,16.64 221.08,12.9 224.53,12.9 225.19,12.25 233.56,12.25 234.85,13.54 243.21,13.54 243.26,13.48 252.17,13.48 253.26,12.4 258.91,12.4 259.25,12.74 263.64,12.74 264.56,11.82 265.8,11.82 266.13,11.49 v1(266.13,11.23)
  BOTTOM w0.102: v1(266.13,11.23) 266.49,10.87 267.66,10.87 268.1,10.43 JTB1.16
USB3_DET_EC#: length 93.7
  TOP w0.102: DE18.1 DE17.1 ; DE17.1 190.73,17.48 191.17,17.91 191.98,17.91 v2(192.51,18.44) ; DE17.1 191.31,16.45 191.31,13.66 192.3,12.67 v1(192.3,12.64)
  IN2 w0.102: v1(192.3,12.64) 192.93,12.01 207.57,12.01 209.58,14.03 211.61,14.03 213.81,16.23 217.17,16.23 221.56,11.84 233.73,11.84 234.74,12.85 235.87,12.85 236.89,11.84 247.9,11.84 249.39,10.35 250.12,10.35 v4(250.56,9.91)
  IN4 w0.102: v6(267.45,10.75) 267.45,10.64 267.15,10.35 266.53,10.35 266.28,10.6 265.64,10.6 264.31,9.27 251.2,9.27 v4(250.56,9.91)
  GND3 w0.102: v7(268.26,10.75) v6(267.45,10.75)
  BOTTOM w0.102: JTB1.12 268.9,10.45 268.6,10.75 v7(268.26,10.75)
USB3_DET_EC#_D: length 61.9
  TOP w0.102: v1(145.29,15.72) 144.04,15.72 143.62,16.14 v2(143.62,16.49) 143.62,16.79 144.39,17.55 UE36.18 ; v1(192.91,12.64) 191.51,14.04 191.51,16.84 191.7,17.03 DE17.2 RE72.2
  IN3 w0.102: v1(145.29,15.72) 146.57,14.43 148.53,14.43 149.35,15.25 152.77,15.25 154.99,13.02 157.96,13.02 158.94,12.04 162.42,12.04 162.59,11.86 167.32,11.86 167.41,11.95 172.92,11.95 173.81,12.85 190.42,12.85 191.03,12.24 192.51,12.24 v1(192.91,12.64)
USB3_PWR_EN_EC: length 136.1
  TOP w0.102: v1(145.92,15.72) 145.43,16.21 UE36.19
  IN3 w0.102: v4(247.89,10.24) 247.62,10.24 243.5,14.36 240.83,14.36 240.23,14.96 237.34,14.96 236.79,14.41 234.05,14.41 233.6,14.87 222.38,14.87 220.81,16.44 214.81,16.44 211.57,13.2 211.57,12.85 210.61,11.88 193.61,11.88 193.41,12.09 193.41,12.8 193.16,13.05 173.73,13.05 172.83,12.16 167.33,12.16 167.23,12.07 162.72,12.07 162.54,12.24 159.02,12.24 158.04,13.22 155.08,13.22 152.85,15.45 149.26,15.45 148.45,14.64 147,14.64 v1(145.92,15.72)
  IN4 w0.102: v6(268.94,10.21) 267.99,10.21 267.59,9.81 265.14,9.81 264.39,9.07 248.99,9.07 247.89,10.17 v4(247.89,10.24)
  GND3 w0.102: v7(268.5,10.39) 268.76,10.39 v6(268.94,10.21)
  BOTTOM w0.102: JTB1.14 v7(268.5,10.39) ; v1(145.92,15.72) v2(146.56,15.72)
USB3RN1: length 261.3
  TOP w0.102: CI5.1 32.46,58.02 32.57,58.02 v1(32.76,57.84)
  IN3 w0.089: v1(260.45,32.81) 260.45,33.06 260.54,33.15 260.74,33.15 260.87,33.03 260.87,32.53 260.72,32.38 260.2,32.38 260.19,32.37 257.77,32.37 257.75,32.39 257.73,32.39
  IN3 w0.13: v1(32.76,57.84) 32.75,57.84 32.39,58.19 32.26,58.19 32.14,58.07 32.14,55.68 36.56,51.27 42.86,51.27 52.02,42.11 53.58,42.11 56.22,39.46 69.95,39.46 71.48,37.94 72.25,37.94 72.68,38.36 73.67,38.36 75.07,39.76 81.85,39.76 82.03,39.94 90.6,39.94 91.24,40.58 101.3,40.58 105.58,44.87 160.81,44.87 161.43,44.25 170.22,44.25 180.63,33.84 197.48,33.84 200.11,31.2 200.11,27.82 201.92,26.02 221.76,26.02 222.2,25.59 228.51,25.59 230.16,27.24 230.16,30.63 233.05,33.52 239.46,33.52 241.27,31.7 252,31.7 252.13,31.84 256.89,31.84 257.45,32.39 257.73,32.39
  BOTTOM w0.089: v1(260.45,32.81) 260.45,32.61 U7.AR26
USB3RN1_8723: length 7.9
  TOP w0.102: UI5.27 25.98,59.55 25.88,59.65 25.78,59.65 25.69,59.56 25.69,57.8 25.7,57.79 25.7,57.28 25.69,57.28 25.69,56.76 25.15,56.23 v9(24.57,56.23) 22.4,56.23 22.08,55.91 LI3.4
USB3RN1_C: length 3.3
  TOP w0.102: CI5.2 30.87,58.01 30.42,58.01 30.16,58.27 30.16,59.54 30.07,59.64 29.95,59.64 29.86,59.55 UI5.1
USB3RN1_D-: length 7.8
  TOP w0.102: JUSB1.5 16.06,53.67 16.44,53.67 16.89,54.11 v9(16.89,54.72) 16.89,56.03 17.03,56.17 17.22,56.17 17.29,56.09 DI1.9 DI1.1 18.9,56.09 19.04,56.24 19.5,56.24 19.84,55.91 LI3.3
USB3RN2: length 258.4
  TOP w0.102: CI11.1 32.46,62.47 32.57,62.47 v1(32.76,62.28)
  IN3 w0.089: 257.73,33.12 257.74,33.12 257.76,33.14 257.82,33.14 257.84,33.16 259.03,33.16 259.07,33.12 259.07,33.07 258.76,32.76 v1(258.73,32.76)
  IN3 w0.13: v1(32.76,62.28) 32.77,62.28 33.13,62.64 33.56,62.64 34.23,61.97 34.23,56.22 37.56,52.89 43.08,52.89 51.8,44.16 53.3,44.16 54.49,42.96 56.55,42.96 58.46,41.05 81.26,41.05 81.44,41.23 89.97,41.23 90.71,41.97 100.79,41.97 105.37,46.55 161.27,46.55 162.26,45.55 170.77,45.55 181.24,35.09 198,35.09 201.86,31.22 201.86,28.28 202.87,27.27 222.5,27.27 222.93,26.84 224.78,26.84 225.36,27.42 225.36,28.9 231.45,34.98 248.91,34.98 250.2,33.69 251.33,33.69 251.78,34.14 256.06,34.14 257.08,33.12 257.73,33.12
  BOTTOM w0.102: U7.AW26 258.73,32.55 v1(258.73,32.76)
USB3RN2_8723: length 19.5
  TOP w0.102: UI5.21 25.79,61.95 25.69,62.05 23.65,62.05 23.09,62.61 20.38,62.61 18.37,64.62 18.37,67.85 v9(19.09,68.56) 20.06,69.54 22.57,69.54 22.89,69.86 22.89,70.24 22.55,70.58 22.23,70.26 LI9.4
USB3RN2_C: length 2
  TOP w0.102: CI11.2 30.94,62.4 30.8,62.4 30.45,62.04 29.95,62.04 29.86,61.95 UI5.7
USB3RN2_D-: length 6.7
  TOP w0.102: JUSB3.5 15.1,71.99 15.24,72.13 15.46,72.13 16.89,70.69 17.28,70.69 17.4,70.57 DI6.9 DI6.1 18.95,70.57 19.02,70.64 19.47,70.64 19.85,70.26 LI9.3
USB3RN3: length 30.7
  IN1 w0.089: v1(259.66,11.78) 259.87,11.99 259.87,15.51 258.77,16.62 258.77,19.95 259.2,20.39 259.42,20.39 259.46,20.42 261.5,22.46 261.5,26.62 262,27.12 262,29.15 261.42,29.73 261.42,30.43 261.3,30.55 258.06,30.55 257.43,31.19 257.43,33.03 257.72,33.32 258.86,33.32 258.95,33.41 258.95,33.5 v1(258.73,33.72)
  BOTTOM w0.102: U7.AW29 258.73,33.53 v1(258.73,33.72) ; JTB1.57 259.7,12.27 259.82,12.15 259.82,11.94 v1(259.66,11.78)
USB3RN4: length 26.9
  IN1 w0.089: v1(260.54,33.73) 260.77,33.5 260.77,33.37 260.98,33.16 261.55,33.16 261.94,32.77 261.94,32.27 262.39,31.81 262.39,30.99 263.03,30.34 263.03,29.05 262.5,28.51 262.5,22.4 261.39,21.3 261.39,21.03 260.16,19.8 260.16,17.2 261.38,15.98 261.38,13.73 260.76,13.11 260.76,12.48 261.03,12.21 261.03,12 260.85,11.82 v1(260.83,11.82)
  BOTTOM w0.089: v1(260.54,33.73) 260.82,33.45 U7.AR29
  BOTTOM w0.102: JTB1.51 260.9,12.24 261.02,12.12 261.02,12.01 v1(260.83,11.82)
USB3RP1: length 261.3
  TOP w0.102: v1(32.76,58.42) 32.57,58.23 32.46,58.23 CI6.1
  IN3 w0.089: v1(261.24,32.78) 261.06,32.6 261.06,32.46 260.79,32.19 260.28,32.19 260.27,32.18 257.76,32.18 257.74,32.16 257.73,32.16
  IN3 w0.13: 257.73,32.16 257.54,32.16 256.98,31.61 252.23,31.61 252.09,31.47 241.18,31.47 239.36,33.29 233.15,33.29 230.39,30.53 230.39,27.14 228.61,25.36 222.1,25.36 221.67,25.79 201.82,25.79 199.89,27.73 199.89,31.11 197.39,33.61 180.53,33.61 170.12,44.02 161.34,44.02 160.72,44.64 105.68,44.64 101.4,40.36 91.34,40.36 90.69,39.71 82.12,39.71 81.94,39.53 75.16,39.53 73.77,38.13 72.77,38.13 72.35,37.71 71.39,37.71 69.86,39.23 56.13,39.23 53.48,41.88 51.92,41.88 42.77,51.04 36.47,51.04 31.92,55.59 31.92,58.17 32.17,58.42 v1(32.76,58.42)
  BOTTOM w0.089: v1(261.24,32.78) 261.14,32.67 261.14,32.5 261.39,32.25 U7.AP26
USB3RP1_8723: length 7.9
  TOP w0.102: UI5.26 25.98,59.95 25.88,59.86 25.69,59.86 25.47,59.63 v9(25.47,57.54) 25.47,56.84 25.07,56.44 24.87,56.44 24.85,56.46 24.21,56.46 24.19,56.44 22.41,56.44 22.09,56.76 LI3.1
USB3RP1_C: length 3.3
  TOP w0.102: UI5.2 29.93,59.95 30.01,59.87 30.17,59.87 30.39,59.64 30.39,58.37 30.52,58.24 30.87,58.24 CI6.2
USB3RP1_D+: length 7.8
  TOP w0.102: JUSB1.6 15.94,53.87 16.36,53.87 16.68,54.2 16.68,54.42 16.66,54.44 16.66,55 16.68,55.02 16.68,56.11 16.95,56.38 17.08,56.38 17.29,56.59 DI1.8 DI1.2 18.9,56.59 19.04,56.45 19.52,56.45 19.83,56.76 LI3.2
USB3RP2: length 258.4
  TOP w0.102: v1(32.76,62.87) 32.57,62.68 32.46,62.68 CI12.1
  IN3 w0.089: 257.73,33.35 257.76,33.35 257.76,33.35 259.11,33.35 259.26,33.2 259.26,32.79 v1(259.29,32.76)
  IN3 w0.13: 257.73,33.35 257.17,33.35 256.15,34.37 251.68,34.37 251.24,33.92 250.29,33.92 249,35.21 231.35,35.21 225.13,28.99 225.13,27.51 224.68,27.06 223.03,27.06 222.59,27.5 202.97,27.5 202.09,28.37 202.09,31.31 198.09,35.31 181.33,35.31 170.86,45.78 162.36,45.78 161.37,46.77 105.27,46.77 100.7,42.2 90.61,42.2 89.88,41.46 81.34,41.46 81.16,41.28 58.55,41.28 56.65,43.19 54.59,43.19 53.39,44.39 51.9,44.39 43.17,53.11 37.66,53.11 34.46,56.32 34.46,62.06 33.66,62.87 v1(32.76,62.87)
  BOTTOM w0.102: U7.AV26 259.62,32.26 259.29,32.6 v1(259.29,32.76)
USB3RP2_8723: length 19.5
  TOP w0.102: LI9.1 22.22,71.11 22.54,70.79 22.64,70.79 23.1,70.33 23.1,69.77 22.66,69.33 20.15,69.33 19.44,68.63 19.44,68.6 19.05,68.2 19.02,68.2 18.58,67.76 18.58,64.7 20.47,62.81 23.22,62.81 v9(23.52,62.51) 23.78,62.26 25.69,62.26 25.79,62.35 UI5.20
USB3RP2_C: length 2.1
  TOP w0.102: UI5.8 29.86,62.35 29.95,62.27 30.35,62.27 30.71,62.62 30.84,62.62 31.2,62.99 CI12.2
USB3RP2_D+: length 6.7
  TOP w0.102: LI9.2 19.6,71.11 19.34,70.85 19.12,70.85 18.9,71.07 DI6.2 DI6.8 17.35,71.07 17.18,70.9 16.98,70.9 15.54,72.33 15.24,72.33 15.1,72.47 JUSB3.6
USB3RP3: length 30.6
  IN1 w0.089: v1(260.24,11.78) 260.11,11.91 260.11,15.54 258.95,16.69 258.95,19.88 259.28,20.2 259.5,20.2 259.59,20.29 261.68,22.39 261.68,26.55 262.18,27.05 262.18,29.23 261.6,29.81 261.6,30.51 261.38,30.73 258.14,30.73 257.61,31.26 257.61,32.95 257.8,33.14 258.94,33.14 259.13,33.33 259.13,33.53 v1(259.32,33.72)
  BOTTOM w0.102: JTB1.55 260.1,12.27 260.03,12.2 260.03,11.99 v1(260.24,11.78) ; U7.AV29 259.32,33.53 v1(259.32,33.72)
USB3RP4: length 26.9
  IN1 w0.089: v1(261.17,33.73) 260.95,33.5 260.95,33.45 261.05,33.35 261.62,33.35 262.12,32.85 262.12,32.34 262.57,31.89 262.57,31.06 263.22,30.42 263.22,28.98 262.68,28.44 262.68,22.32 261.58,21.22 261.58,20.96 260.34,19.72 260.34,17.28 261.56,16.06 261.56,13.65 260.95,13.04 260.95,12.56 261.24,12.26 261.24,12 v1(261.42,11.82)
  BOTTOM w0.089: v1(261.17,33.73) 261.41,33.49 U7.AP29
  BOTTOM w0.102: JTB1.49 261.3,12.25 261.23,12.17 261.23,12.01 v1(261.42,11.82)
USB3T_N1: length 1.4
  TOP w0.102: LI2.4 22.12,57.62 22.36,57.86 22.66,57.86 CI3.2
USB3T_N2: length 4.3
  TOP w0.102: CI16.2 23.89,70.18 24.24,70.53 24.24,70.97 v9(23.92,71.29) 23.12,72.09 23.09,72.09 22.77,72.41 22.5,72.41 21.99,71.91 LI8.4
USB3T_P1: length 1.4
  TOP w0.102: CI4.2 22.71,58.18 22.41,58.18 22.12,58.47 LI2.1
USB3T_P2: length 4.3
  TOP w0.102: CI17.2 24.45,70.41 24.45,71.06 24.28,71.23 24.28,71.25 23.89,71.65 23.86,71.65 v9(23.05,72.45) 22.89,72.62 22.23,72.62 22.09,72.76 LI8.1
USB3TN1: length 260.7
  TOP w0.102: v1(32.76,59.6) 32.57,59.79 32.46,59.79 CI7.1
  IN3 w0.13: v1(32.76,59.6) 32.75,59.6 32.39,59.96 32.13,59.96 31.28,59.11 31.28,55.05 36.28,50.05 43.01,50.05 51.78,41.28 53.36,41.28 55.92,38.72 66.37,38.72 66.81,38.28 70.09,38.28 71.17,37.2 73.7,37.2 75.17,38.67 90.6,38.67 91.76,39.82 101.59,39.82 105.89,44.13 160.43,44.13 161.08,43.48 169.86,43.48 180.25,33.1 197.17,33.1 198.18,32.09 198.18,28.26 199.56,26.89 201.16,25.28 221.29,25.28 222.36,24.21 225.75,24.21 226.39,24.85 228.82,24.85 231.75,27.78 231.75,29.8 232.76,30.81 243.75,30.81 244.45,30.11 246.93,30.11 247.9,29.13 253.94,29.13 254.85,30.04 254.85,30.29 254.66,30.48 254.66,30.85 254.59,30.92 254.39,30.92 254.24,30.77 v4(254.24,30.61)
  GND3 w0.089: 254.47,30.84 254.68,31.04 v7(254.68,31.12)
  GND3 w0.102: 254.47,30.84 v4(254.24,30.61)
  BOTTOM w0.089: U7.BE24 256.28,31.16 255.72,31.16 255.45,31.43 254.85,31.43 254.68,31.25 v7(254.68,31.12)
USB3TN1_8723: length 5.4
  TOP w0.102: UI5.24 25.79,60.75 25.69,60.85 25.19,60.85 24.8,60.46 24.8,60.38 24.82,60.36 24.82,59.77 24.8,59.75 v9(24.8,58.73) 24.8,58.12 24.61,57.92 24.23,57.92 23.89,57.58 CI3.1
USB3TN1_C: length 2.7
  TOP w0.102: UI5.4 29.86,60.75 29.95,60.84 30.14,60.84 30.52,60.46 30.52,59.96 30.71,59.77 30.89,59.77 CI7.2
USB3TN1_D-: length 7.2
  TOP w0.102: LI2.3 19.84,57.62 19.61,57.85 19.22,57.85 18.96,57.59 DI1.4 DI1.7 17.29,57.59 17.16,57.73 16.79,57.73 16.59,57.93 16.59,58.28 16.57,58.3 16.57,58.86 16.59,58.88 16.59,59.26 16.23,59.62 16.01,59.62 JUSB1.8
USB3TN2: length 263.5
  TOP w0.102: v1(32.76,64.06) 32.57,64.25 32.46,64.25 CI13.1
  IN3 w0.13: v4(252.15,33.07) 252.15,33.36 252.25,33.46 252.45,33.46 252.57,33.35 252.57,33.07 252.76,32.88 252.76,32.67 252.69,32.6 250.34,32.6 248.6,34.34 231.53,34.34 227.46,30.27 227.46,27.31 226.48,26.32 222.66,26.32 222.23,26.76 202.22,26.76 200.85,28.13 200.85,31.51 197.79,34.57 181.03,34.57 170.57,45.03 161.77,45.03 161.18,45.62 105.29,45.62 101.1,41.43 91.05,41.43 90.31,40.7 81.72,40.7 81.55,40.52 56.21,40.52 53.39,43.35 51.85,43.35 43.15,52.04 36.86,52.04 33.67,55.23 33.67,61.2 33.21,61.66 32.57,61.66 32.09,62.13 32.09,64.26 32.25,64.41 32.39,64.41 32.75,64.06 v1(32.76,64.06)
  GND3 w0.102: v4(252.15,33.07) 252.31,33.07 252.57,32.81 252.57,32.21 v7(252.45,32.08)
  BOTTOM w0.089: 254.47,31.77 254.49,31.77 254.5,31.78 254.73,31.78 254.82,31.68 255.49,31.68 255.65,31.52 256.24,31.52 256.4,31.68 256.59,31.68 256.85,31.42 257,31.42 257.06,31.48 257.06,31.64 U7.BD25
  BOTTOM w0.102: v7(252.45,32.08) 252.45,32.02 252.67,31.8 252.67,31.68 252.93,31.42 v9(253.88,31.42) 254.08,31.42 254.43,31.77 254.47,31.77
USB3TN2_8723: length 7.6
  TOP w0.102: CI16.1 23.78,68.51 25.01,67.29 v9(25.01,66.81) 25.01,64.71 24.99,64.69 24.99,64.13 25.01,64.11 25.01,63.9 25.68,63.23 25.9,63.23 25.98,63.15 UI5.18
USB3TN2_C: length 2.7
  TOP w0.102: CI13.2 30.9,64.21 30.46,64.21 30.36,64.11 30.36,63.48 30.12,63.24 29.95,63.24 29.86,63.15 UI5.10
USB3TN2_D-: length 11.7
  TOP w0.102: LI8.3 19.85,71.91 19.54,72.22 19.23,72.22 19.09,72.07 DI6.4 DI6.7 17.23,72.07 17.15,72.15 16.68,72.15 16.24,72.59 16.24,78 16.13,78.11 15.24,78.11 15.1,77.97 JUSB3.8
USB3TN3: length 29.6
  IN1 w0.089: v1(253.36,23.32) 253.36,23.16 253.41,23.11 253.98,23.11 257.56,19.53 257.56,15.66 258.15,15.07 258.15,14.2 v1(258.35,14)
  BOTTOM w0.089: U7.BE26 256.49,32.39 256.38,32.5 256.2,32.5 256.16,32.46 256.16,31.99 256.08,31.91 255.84,31.91 255.79,31.95 255.79,32.45 255.74,32.5 255.22,32.5 255.22,32.5 255.2,32.5
  BOTTOM w0.102: JTB1.61 258.9,12.92 258.8,13.02 258.8,13.21 258.58,13.43 258.38,13.43 258.18,13.64 258.18,13.83 v1(258.35,14) ; 255.2,32.5 255.06,32.5 254.78,32.78 254.5,32.78 254.47,32.76 254.01,32.76 253.99,32.78 252.28,32.78 251.84,32.34 251.84,25.73 252.98,24.59 252.98,23.69 253.35,23.32 v1(253.36,23.32)
USB3TN4: length 31.3
  IN1 w0.089: v1(251.65,22.96) 251.81,22.79 251.81,22.55 252.09,22.27 253.54,22.27 256.73,19.09 256.73,15.18 256.77,15.13 256.77,14.2 v1(256.57,14)
  BOTTOM w0.089: U7.BD27 256.97,32.93 256.56,33.34 256.26,33.34 255.8,33.8 254.5,33.8 254.5,33.8 254.47,33.8
  BOTTOM w0.102: 254.47,33.8 251.85,33.8 250.81,32.76 250.81,25.29 251.65,24.46 v1(251.65,22.96) ; v1(256.57,14) 256.58,14 256.78,13.8 256.78,13.67 257.4,13.06 257.4,12.97 257.3,12.87 JTB1.69
USB3TP1: length 260.6
  TOP w0.102: v1(32.76,60.19) 32.57,60 32.46,60 CI8.1
  IN3 w0.13: v4(255.08,30.62) 255.08,30.62 255.08,29.95 254.04,28.91 247.81,28.91 246.83,29.88 244.36,29.88 243.66,30.58 232.86,30.58 231.98,29.71 231.98,27.68 228.91,24.62 226.48,24.62 225.85,23.98 222.27,23.98 221.2,25.05 201.07,25.05 197.95,28.17 197.95,31.99 197.08,32.87 180.16,32.87 169.77,43.26 160.98,43.26 160.34,43.9 105.99,43.9 101.68,39.59 91.85,39.59 90.7,38.44 75.26,38.44 73.79,36.97 71.08,36.97 70,38.05 66.72,38.05 66.27,38.49 55.82,38.49 53.26,41.05 51.68,41.05 42.92,49.82 36.19,49.82 31.05,54.95 31.05,59.21 32.03,60.19 v1(32.76,60.19)
  GND3 w0.089: v7(255.11,31.12) 255.1,31.12 254.88,30.9 254.88,30.82 v4(255.08,30.62)
  BOTTOM w0.089: v7(255.11,31.12) 255.21,31.22 255.38,31.22 255.64,30.97 256.36,30.97 256.49,31.09 256.61,31.09 256.66,31.14 256.79,31.14 256.85,31.09 U7.BD23
USB3TP1_8723: length 5.3
  TOP w0.102: CI4.1 23.91,58.44 24.22,58.13 24.52,58.13 24.6,58.2 24.6,58.44 24.58,58.46 24.58,59.01 24.6,59.03 v9(24.6,60.05) 24.6,60.55 25.1,61.06 25.69,61.06 25.79,61.15 UI5.23
USB3TP1_C: length 2.7
  TOP w0.102: CI8.2 30.86,59.99 30.8,59.99 30.75,60.05 30.75,60.55 30.23,61.07 29.95,61.07 29.86,61.15 UI5.5
USB3TP1_D+: length 7.2
  TOP w0.102: LI2.2 19.83,58.47 19.41,58.06 19.03,58.06 18.99,58.09 DI1.5 DI1.6 17.29,58.09 17.14,57.94 16.88,57.94 16.8,58.01 v9(16.8,58.58) 16.8,59.34 16.32,59.82 15.99,59.82 JUSB1.9
USB3TP2: length 263.5
  TOP w0.102: CI20.1 32.46,64.46 32.57,64.46 v1(32.76,64.64)
  IN3 w0.13: v1(32.76,64.64) 32.16,64.64 31.87,64.35 31.87,62.04 32.47,61.43 33.12,61.43 33.44,61.11 33.44,55.13 36.76,51.81 43.06,51.81 51.75,43.12 53.29,43.12 56.12,40.29 81.64,40.29 81.82,40.47 90.41,40.47 91.14,41.2 101.2,41.2 105.39,45.39 161.09,45.39 161.67,44.81 170.47,44.81 180.93,34.35 197.69,34.35 200.62,31.41 200.62,28.04 202.13,26.53 222.13,26.53 222.57,26.1 226.57,26.1 227.69,27.22 227.69,30.17 231.63,34.11 248.51,34.11 250.25,32.37 252.78,32.37 252.99,32.58 v4(252.99,33.25)
  GND3 w0.102: v4(252.99,33.25) 252.76,33.02 252.76,32.21 v7(252.88,32.08)
  BOTTOM w0.089: 254.47,31.98 254.49,31.98 254.5,31.97 254.81,31.97 254.91,31.88 255.57,31.88 255.74,31.72 256.16,31.72 256.32,31.88 256.62,31.88 256.78,32.04 257.08,32.04 257.4,31.73 U7.BC24
  BOTTOM w0.102: 254.47,31.98 254.34,31.98 254.02,31.65 253.61,31.65 253.59,31.63 253.02,31.63 252.88,31.77 v7(252.88,32.08)
USB3TP2_8723: length 7.6
  TOP w0.102: CI17.1 24.57,69.27 23.99,68.69 23.99,68.6 25.22,67.38 25.22,67.11 25.24,67.09 25.24,66.53 25.22,66.51 v9(25.22,64.41) 25.22,63.99 25.76,63.44 25.87,63.44 25.98,63.55 UI5.17
USB3TP2_C: length 2.7
  TOP w0.102: CI20.2 30.85,64.44 30.36,64.44 30.13,64.21 30.13,63.57 30.02,63.47 29.95,63.47 29.86,63.55 UI5.11
USB3TP2_D+: length 11.7
  TOP w0.102: LI8.2 19.85,72.76 19.52,72.43 19.23,72.43 19.09,72.57 DI6.5 DI6.6 17.23,72.57 17.02,72.36 16.76,72.36 16.44,72.68 16.44,78.09 16.21,78.32 15.32,78.32 15.1,78.54 JUSB3.9
USB3TP3: length 29.8
  IN1 w0.089: v1(257.77,14) 257.97,14.2 257.97,14.99 257.38,15.58 257.38,19.45 253.91,22.92 253.19,22.92 252.79,23.32 v1(252.77,23.32)
  BOTTOM w0.089: 255.2,32.7 255.22,32.7 255.22,32.7 256.46,32.7 256.86,32.29 257.29,32.29 U7.BC26
  BOTTOM w0.102: JTB1.63 258.5,12.89 258.6,12.99 258.6,13.12 258.49,13.22 258.29,13.22 257.97,13.55 257.97,13.8 v1(257.77,14) ; v1(252.77,23.32) 252.77,24.5 251.63,25.64 251.63,32.42 252.19,32.99 v9(254.29,32.99) 254.86,32.99 255.15,32.7 255.2,32.7
USB3TP4: length 31.3
  IN1 w0.089: v1(257.16,14) 256.96,14.2 256.96,15.2 256.91,15.25 256.91,19.16 253.62,22.45 252.16,22.45 251.99,22.62 251.99,22.76 252.18,22.94 v1(252.32,22.94)
  BOTTOM w0.089: U7.BE28 256.49,33.09 256.44,33.15 256.22,33.15 256.19,33.11 256.19,32.93 256.15,32.89 255.75,32.89 255.69,32.96 255.69,33.01 255.97,33.29 255.97,33.35 255.72,33.6 254.5,33.6 254.49,33.6 254.47,33.6
  BOTTOM w0.102: v1(252.32,22.94) 251.85,23.41 251.85,24.54 251.02,25.38 251.02,32.67 251.94,33.6 254.47,33.6 ; JTB1.67 257.7,12.88 257.6,12.98 257.6,13.14 256.99,13.76 256.99,13.83 v1(257.16,14)
USB20_N0: length 296
  IN3 w0.13: v1(29.03,51.61) 28.43,51.61 28.13,51.31 28.13,49.17 29.03,48.27 41.39,48.27 42.68,46.97 42.68,45.47 50.05,38.11 53,38.11 54.83,36.28 65.02,36.28 65.5,35.8 69.11,35.8 70.16,34.75 74.88,34.75 76.26,36.13 102.56,36.13 108.8,42.37 159.49,42.37 160.27,41.59 169.35,41.59 178.17,32.77 178.17,30.72 180.78,28.11 182.26,28.11 182.72,27.66 195.04,27.66 200.21,22.49 204.14,22.49 204.57,22.92 221.25,22.92 221.78,22.39 239.51,22.39 239.77,22.64 247.08,22.64 248.14,21.59 248.67,21.59 249.49,20.77 250.63,20.77 251.02,20.38 255.3,20.38 256.61,19.08 262.21,19.08 262.53,19.39 265.13,19.39 265.91,18.62 267.61,18.62 268.46,19.46 273.19,19.46 275.26,21.53 275.26,24.8 276.22,25.76 276.22,28.85 275.32,29.75 275.32,33.53 275.33,33.53 275.33,33.53 275.7,33.9 275.7,35.08 275.03,35.75 v4(275.03,36.18)
  GND3 w0.089: v4(275.03,36.18) 275.02,36.18 274.83,36.37 274.83,36.48 274.83,36.57 274.92,36.66 274.93,36.67 v3(275.23,36.67)
  BOTTOM w0.089: v3(275.23,36.67) 275.23,36.68 U7.B37
  BOTTOM w0.102: US1.2 25.41,50.86 25.26,50.72 25.26,50.61 25.5,50.37 27.76,50.37 28.47,51.07 28.72,51.07 29.03,51.38 v1(29.03,51.61)
USB20_N1: length 327.8
  TOP w0.102: v1(24.07,77.09) 23.86,77.3 23.66,77.3 23.52,77.16 US2.2
  IN3 w0.13: v1(24.07,77.09) 23.69,77.47 23.53,77.47 22.8,76.74 22.8,75.46 23.67,74.58 23.67,71.73 27.16,68.24 27.16,54.69 26.55,54.08 26.55,50.58 27.55,49.59 27.55,48.81 28.59,47.76 41.17,47.76 42.12,46.81 42.12,45.26 49.86,37.52 52.86,37.52 54.62,35.77 63.36,35.77 64.13,34.99 66.25,34.99 67.12,34.12 75.15,34.12 76.6,35.57 103,35.57 109.29,41.86 159.28,41.86 160.06,41.07 168.62,41.07 177.4,32.29 177.4,30.74 180.54,27.6 182.05,27.6 182.51,27.15 194.83,27.15 200.73,21.24 208.87,21.24 210.03,22.41 221.03,22.41 221.66,21.78 246.69,21.78 247.39,21.08 248.46,21.08 249.27,20.26 250.07,20.26 250.5,19.84 255.09,19.84 256.36,18.57 259.66,18.57 260.12,18.11 261.78,18.11 262.13,18.46 262.44,18.46 262.68,18.71 264.62,18.71 265.33,17.99 267.87,17.99 268.71,18.84 273.37,18.84 275.53,21.01 276.69,21.01 277.9,22.21 277.9,22.93 278.14,23.18 278.14,28.87 277.55,29.47 277.55,36.86 277.22,37.19 276.81,37.19 276.65,37.02 276.32,37.02 276.2,37.13 276.1,37.13 276.02,37.06 276.02,36.88 276.28,36.63 v1(276.48,36.63)
  BOTTOM w0.089: U7.A38 275.27,37.21 275.4,37.21 275.46,37.15 275.46,37.03 275.54,36.95 275.67,36.95 275.76,37.03 275.76,37.13 275.83,37.21 276.15,37.21 276.33,37.04 276.54,37.04 276.62,36.96 276.62,36.76 v1(276.48,36.63)
USB20_N2: length 36.7
  IN1 w0.089: v1(275.78,36.55) 275.78,36.4 275.4,36.02 274.19,34.81 274.19,30.07 275.05,29.2 275.05,25.84 274.73,25.53 274.73,21.89 273.9,21.05 273.9,20.02 273.7,19.81 273.7,17.84 274.66,16.88 274.66,14.62 274.14,14.09 274.14,13.33 273.65,12.84 273.65,12.25 273.29,11.9 272.81,11.9 272.02,11.11 270.22,11.11 269.43,11.9 268.36,11.9 268.13,11.67 268.13,11.35 v1(268.01,11.23)
  BOTTOM w0.089: v1(275.78,36.55) 275.87,36.55 276.01,36.41 276.01,36.26 275.93,36.17 275.67,36.17 275.57,36.07 275.46,36.07 275.41,36.12 275.41,36.33 275.37,36.37 275.24,36.37 U7.A36
  BOTTOM w0.102: JTB1.15 268.1,11.32 v1(268.01,11.23)
USB20_N3: length 38.1
  IN1 w0.089: v1(274.47,9.33) 274.48,9.33 274.87,9.72 274.87,11.6 276.06,12.78 276.06,17.75 275.33,18.48 275.33,20.45 276.17,21.29 276.17,23.74 275.6,24.31 275.6,25.04 275.83,25.27 275.83,29.14 277.5,30.82 277.5,35.11 277.38,35.23 277.25,35.23 277.15,35.14 277.02,35.14 276.99,35.1 v1(276.99,34.8)
  BOTTOM w0.089: U7.A34 275.17,35.49 275.32,35.49 275.69,35.12 276.23,35.12 276.43,35.32 276.65,35.32 276.83,35.14 276.92,35.14 276.99,35.07 v1(276.99,34.8)
  BOTTOM w0.102: JTB1.3 270.5,12.15 270.55,12.1 270.65,12.1 270.69,12.06 270.69,11.86 272.13,10.42 274.32,10.42 v9(274.59,10.15) 274.85,9.89 274.85,9.71 v1(274.47,9.33)
USB20_N4: length 37.6
  IN1 w0.089: v1(273.2,9.32) 273.2,10.11 274.15,11.06 274.15,11.8 275.41,13.05 275.41,17.06 274.35,18.12 274.35,19.49 274.55,19.69 274.55,20.7 275.17,21.31 275.17,25.35 275.43,25.62 275.43,29.38 274.69,30.12 274.69,33.25 275.47,34.03 275.47,34.27 275.75,34.55 276.08,34.55 276.22,34.69 v1(276.22,34.69)
  BOTTOM w0.089: U7.B33 274.47,35.05 274.4,35.12 274.4,35.22 274.55,35.37 274.78,35.37 275.04,35.11 275.35,35.11 275.64,34.82 275.64,34.4 275.74,34.3 275.89,34.3 276.22,34.63 v1(276.22,34.69)
  BOTTOM w0.102: v1(273.2,9.32) 273.39,9.51 273.39,9.62 273.28,9.73 271.73,9.73 270.06,11.4 269.77,11.4 269.4,11.78 269.4,11.96 269.3,12.06 JTB1.9
USB20_N9: length 342.7
  IN3 w0.13: v4(275.06,34.75) 274.89,34.58 274.66,34.58 274.19,34.12 274.19,30.43 274.61,30.01 274.61,29.17 275.43,28.35 275.43,26.23 274.15,24.96 274.15,22.73 273.24,21.81 272.09,21.81 271.11,20.83 268.23,20.83 268.04,20.65 262.75,20.65 262.37,21.03 260.53,21.03 260.09,20.58 256.62,20.58 255.35,21.85 249.94,21.85 248.97,22.82 248.37,22.82 247.3,23.88 235.67,23.88 234.71,24.85 232.73,24.85 231.76,23.88 228.03,23.88 227.6,23.45 222.08,23.45 221.65,23.88 200.9,23.88 197.29,27.49 197.29,30.95 196.51,31.73 181.72,31.73 181.62,31.63 180.67,31.63 169.75,42.55 160.96,42.55 160.18,43.33 108.4,43.33 102.18,37.12 75.86,37.12 74.46,35.72 70.56,35.72 69.49,36.79 65.97,36.79 65.52,37.25 55.23,37.25 52.84,39.63 50,39.63 43.75,45.88 43.75,47.27 41.79,49.24 35.97,49.24 30.11,55.1 30.11,60.19 31.17,61.24 31.17,73.82 31.87,74.52 31.87,83.24 32.63,84.01 32.63,90.87 30.37,93.13 30.37,103.09 30.77,103.49 31.55,103.49 v1(31.77,103.26)
  GND3 w0.089: v4(275.06,34.75) 275.57,34.24 v7(275.57,33.81)
  BOTTOM w0.089: v7(275.57,33.81) U7.A30
  BOTTOM w0.102: RI8.1 27.84,105.56 LI4.1 28.41,105.56 28.73,105.88 29.73,105.88 30.16,105.44 v9(30.16,105.04) 30.16,104.25 30.88,103.53 31.5,103.53 v1(31.77,103.26)
USB20_N9_R: length 33.3
  IN4 w0.089: v1(26.94,111.05) 27.8,111.05 28.31,111.56 28.31,114.13 28.88,114.7 v1(29.75,114.7)
  BOTTOM w0.102: RI8.2 26.67,105.56 LI4.2 25.6,105.56 25.28,105.88 24.76,105.88 24.39,106.25 24.39,109.88 25.55,111.05 v1(26.94,111.05) ; v1(29.75,114.7) 28.79,114.7 28.66,114.83 28.66,116.9 28.03,117.53 27.24,117.53 26.66,118.12 DI3.2 26.02,117.31 25.89,117.18 25.31,117.18 23.58,115.45 23.58,111.79 22.89,111.1 20.94,111.1 20.65,111.39 JTS.4
USB20_N12: length 31.3
  IN1 w0.089: v1(272.43,31.78) 272.8,31.41 272.8,30.78 274.67,28.91 274.67,26.3 274.34,25.97 274.34,22.83 272.95,21.44 272.95,20.96 273.24,20.66 273.24,19.99 273.05,19.8 273.05,17.57 273.97,16.65 273.97,14.86 273.46,14.35 273.46,13.59 272.98,13.11 272.6,13.11 272.23,12.74 272.23,12.44 271.92,12.12 270.75,12.12 270.06,12.81 267.76,12.81 266.96,12.02 266.96,11.48 v1(266.73,11.25)
  BOTTOM w0.089: U7.G26 272.59,31.94 v1(272.43,31.78)
  BOTTOM w0.102: JTB1.21 266.9,11.42 v1(266.73,11.25)
USB20_P0: length 296.1
  IN3 w0.13: v4(274.44,36.18) 274.8,35.83 274.8,35.65 275.47,34.98 275.47,33.99 275.24,33.76 275.23,33.76 275.09,33.62 275.09,29.66 275.99,28.76 275.99,25.86 275.03,24.89 275.03,21.63 273.12,19.72 268.39,19.72 267.52,18.85 266,18.85 265.23,19.62 262.43,19.62 262.12,19.31 256.7,19.31 255.4,20.61 251.11,20.61 250.72,21 249.58,21 248.77,21.82 248.23,21.82 247.18,22.87 239.68,22.87 239.42,22.61 221.87,22.61 221.34,23.14 204.48,23.14 204.05,22.72 200.31,22.72 195.14,27.88 182.81,27.88 182.36,28.34 180.87,28.34 178.4,30.82 178.4,32.86 169.44,41.81 160.36,41.81 159.58,42.6 108.7,42.6 102.46,36.36 76.16,36.36 74.78,34.98 70.25,34.98 69.21,36.03 65.59,36.03 65.11,36.51 54.92,36.51 53.09,38.34 50.14,38.34 42.91,45.57 42.91,47.07 41.48,48.5 29.12,48.5 28.36,49.26 28.36,51.21 28.53,51.38 28.66,51.38 28.86,51.19 29.24,51.19 29.33,51.1 29.33,50.88 29.22,50.77 v1(29.02,50.77)
  GND3 w0.089: v4(274.44,36.18) 274.66,36.4 274.66,36.48 274.66,36.57 274.57,36.66 v7(274.23,36.66)
  BOTTOM w0.089: v7(274.23,36.66) 274.09,36.8 273.93,36.8 U7.D37
  BOTTOM w0.102: v1(29.02,50.77) 28.93,50.86 28.56,50.86 27.85,50.16 v9(26.96,50.16) 25.42,50.16 25.05,50.52 25.05,50.75 24.91,50.9 US1.3
USB20_P1: length 327.7
  TOP w0.102: v1(24.06,77.7) 23.87,77.51 23.74,77.51 23.6,77.66 US2.3
  IN3 w0.13: v1(24.06,77.7) 23.43,77.7 22.57,76.84 22.57,75.36 23.44,74.49 23.44,71.64 26.94,68.15 26.94,54.79 26.33,54.18 26.33,50.48 27.32,49.49 27.32,48.71 28.5,47.53 41.08,47.53 41.9,46.71 41.9,45.17 49.77,37.3 52.77,37.3 54.52,35.54 63.27,35.54 64.04,34.77 66.15,34.77 67.03,33.89 75.25,33.89 76.69,35.34 103.1,35.34 109.39,41.63 159.18,41.63 159.96,40.85 168.53,40.85 177.18,32.2 177.18,30.65 180.45,27.37 181.96,27.37 182.41,26.92 194.74,26.92 200.64,21.01 208.97,21.01 210.13,22.18 220.94,22.18 221.57,21.55 246.59,21.55 247.29,20.85 248.37,20.85 249.18,20.04 249.98,20.04 250.41,19.61 255,19.61 256.27,18.34 259.56,18.34 260.02,17.88 261.87,17.88 262.23,18.23 262.53,18.23 262.78,18.48 264.52,18.48 265.24,17.77 267.96,17.77 268.81,18.61 273.46,18.61 275.62,20.78 276.79,20.78 278.13,22.12 278.13,22.84 278.37,23.08 278.37,28.97 277.78,29.57 277.78,36.95 277.31,37.42 v1(276.48,37.42)
  BOTTOM w0.089: U7.C38 274.66,37.06 275.01,37.41 276.47,37.41 v1(276.48,37.42)
