# Allegro board LA9941PR10-0905b.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
INA199A2DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
ISL95812HRZ-T_QFN32_4X4
  oval 0.203x0.914 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.077) 18(2.4,4.077) 19(2,4.077) 20(1.6,4.077) 21(1.2,4.077) 22(0.8,4.077) 23(0.4,4.077) 24(0,4.077)
  oval 0.914x0.203 smd: 9(3.438,0.639) 10(3.438,1.039) 11(3.438,1.438) 12(3.438,1.838) 13(3.438,2.239) 14(3.438,2.639) 15(3.438,3.039) 16(3.438,3.438) 25(-0.639,3.438) 26(-0.639,3.039) 27(-0.639,2.639) 28(-0.639,2.239) 29(-0.639,1.838) 30(-0.639,1.438) 31(-0.639,1.039) 32(-0.639,0.639)
  rect 2.642x2.642 smd: 33(1.4,2.039)
J-L_UCNR2234B020-0_20P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.194x2.692 smd: 21(-2.4,1.95) 22(11.9,1.95)
  rect 2.311x1.295 smd: 23(0.85,3.9) 24(8.65,3.9)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
K4G41325FC-HC04_FBGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
KB9012BF-A3_LFBGA_128P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2,-0.5) B6(2.5,-0.5) B7(3,-0.5) B8(3.5,-0.5) B9(4,-0.5) B10(4.5,-0.5) B11(5,-0.5) B12(5.5,-0.5) B13(6,-0.5) C1(0,-1) C2(0.5,-1) C12(5.5,-1) C13(6,-1) D1(0,-1.5) D2(0.5,-1.5) D4(1.5,-1.5) D5(2,-1.5) D6(2.5,-1.5) D7(3,-1.5) D8(3.5,-1.5) D9(4,-1.5) D10(4.5,-1.5) D12(5.5,-1.5) D13(6,-1.5) E1(0,-2) E2(0.5,-2) E4(1.5,-2) E5(2,-2) E6(2.5,-2) E7(3,-2) E8(3.5,-2) E9(4,-2) E10(4.5,-2) E12(5.5,-2) E13(6,-2) F1(0,-2.5) F2(0.5,-2.5) F4(1.5,-2.5) F5(2,-2.5) F9(4,-2.5) F10(4.5,-2.5) F12(5.5,-2.5) F13(6,-2.5) G1(0,-3) G2(0.5,-3) G4(1.5,-3) G5(2,-3) G9(4,-3) G10(4.5,-3) G12(5.5,-3) G13(6,-3) H1(0,-3.5) H2(0.5,-3.5) H4(1.5,-3.5) H5(2,-3.5) H9(4,-3.5) H10(4.5,-3.5) H12(5.5,-3.5) H13(6,-3.5) J1(0,-4) J2(0.5,-4) J4(1.5,-4) J5(2,-4) J6(2.5,-4) J7(3,-4) J8(3.5,-4) J9(4,-4) J10(4.5,-4) J12(5.5,-4) J13(6,-4) K1(0,-4.5) K2(0.5,-4.5) K4(1.5,-4.5) K5(2,-4.5) K6(2.5,-4.5) K7(3,-4.5) K8(3.5,-4.5) K9(4,-4.5) K10(4.5,-4.5) K12(5.5,-4.5) K13(6,-4.5) L1(0,-5) L2(0.5,-5) L12(5.5,-5) L13(6,-5) M1(0,-5.5) M2(0.5,-5.5) M3(1,-5.5) M4(1.5,-5.5) M5(2,-5.5) M6(2.5,-5.5) M7(3,-5.5) M8(3.5,-5.5) M9(4,-5.5) M10(4.5,-5.5) M11(5,-5.5) M12(5.5,-5.5) M13(6,-5.5) N1(0,-6) N2(0.5,-6) N3(1,-6) N4(1.5,-6) N5(2,-6) N6(2.5,-6) N7(3,-6) N8(3.5,-6) N9(4,-6) N10(4.5,-6) N11(5,-6) N12(5.5,-6) N13(6,-6)
KC3810_QFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.438x2.438 smd: 25(1.25,1.975)
KC_FBMA-L11-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
KC_FBMA-L11-201209-221LMA35_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
L2N7002WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
LED_12-22-Y2BHC-A30-2C_3P
  rect 0.991x1.499 smd: 1(0,0) 3(-3,0)
  rect 0.889x0.889 smd: 2(-1.5,-0.65)
LED_LTW-270TLA_2P
  rect 0.889x0.889 smd: 1(0,0) 2(1.9,0)
LNG3DMTR_LGA16_3X3
  oval 0.305x0.864 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 9(2,2.958) 10(1.5,2.958) 11(1,2.958) 12(0.5,2.958) 13(0,2.958)
  oval 0.864x0.305 smd: 6(2.479,0.979) 7(2.479,1.479) 8(2.479,1.979) 14(-0.479,1.979) 15(-0.479,1.479) 16(-0.479,0.979)
LYNXPOINT_BGA_695P-T
  round 0.356 smd: A2(0.624,0) A4(1.217,0) A5(1.81,0) A41(16.915,0) A43(17.508,0) A44(18.101,0) B1(0,-0.624) B2(0.603,-0.603) B44(18.022,-0.603) B45(18.625,-0.524) BA1(0,-16.915) BA45(18.625,-16.915) BC1(0,-17.508) BC45(18.625,-17.508) BD1(0,-18.101) BD2(0.603,-18.022) BD44(18.022,-18.022) BD45(18.625,-18.101) BE2(0.524,-18.625) BE3(1.117,-18.625) BE5(1.71,-18.625) BE41(16.915,-18.625) BE43(17.508,-18.625) BE44(18.101,-18.625) C45(18.625,-1.117) D1(0,-1.217) E1(0,-1.81) E45(18.625,-1.71)
  round 0.33 smd: A6(2.483,0) A40(16.242,0) AY1(0,-16.242) AY45(18.625,-16.242) B4(1.315,-0.586) B42(17.233,-0.637) BA2(0.551,-16.664) BB2(0.563,-17.31) BB44(17.988,-17.233) BD4(1.391,-17.988) BD41(16.664,-18.074) BD42(17.31,-18.061) BE6(2.383,-18.625) BE40(16.242,-18.625) D2(0.637,-1.391) D44(18.061,-1.315) E44(18.074,-1.96) F1(0,-2.483) F45(18.625,-2.383)
  round 0.305 smd: A8(3.216,0) A10(4.029,0) A12(4.842,0) A14(5.655,0) A16(6.468,0) A18(7.28,0) A20(8.093,0) A22(8.906,0) A24(9.719,0) A26(10.532,0) A28(11.344,0) A30(12.157,0) A32(12.97,0) A34(13.783,0) A36(14.596,0) A38(15.408,0) AA2(0.452,-8.478) AA4(1.336,-8.5) AA14(5.515,-8.827) AA16(6.328,-8.827) AA18(7.141,-8.827) AA20(7.954,-8.827) AA22(8.766,-8.827) AA24(9.579,-8.827) AA26(10.392,-8.827) AA28(11.205,-8.827) AA30(12.018,-8.827) AA32(12.83,-8.827) AA42(17.289,-8.5) AA44(18.173,-8.521) AB1(0,-8.906) AB3(0.904,-8.906) AB6(1.934,-9.008) AB7(2.531,-9.008) AB8(3.128,-9.008) AB10(3.724,-9.008) AB11(4.321,-9.008) AB12(4.918,-9.008) AB34(13.707,-9.008) AB35(14.304,-9.008) AB36(14.9,-9.008) AB38(15.497,-9.008) AB39(16.094,-9.008) AB40(16.691,-9.008) AB43(17.721,-8.906) AB45(18.625,-8.906) AC2(0.472,-9.312) AC44(18.152,-9.312) AD1(0,-9.719) AD3(0.904,-9.719) AD6(1.934,-9.617) AD7(2.531,-9.617) AD8(3.128,-9.617) AD10(3.724,-9.617) AD11(4.321,-9.617) AD12(4.918,-9.617) AD14(5.515,-9.488) AD16(6.328,-9.488) AD18(7.141,-9.488) AD20(7.954,-9.488) AD22(8.766,-9.488) AD24(9.579,-9.488) AD26(10.392,-9.488) AD28(11.205,-9.488) AD30(12.018,-9.488) AD32(12.83,-9.488) AD34(13.707,-9.617) AD35(14.304,-9.617) AD36(14.9,-9.617) AD38(15.497,-9.617) AD39(16.094,-9.617) AD40(16.691,-9.617) AD43(17.721,-9.719) AD45(18.625,-9.719) AE2(0.452,-10.103) AE4(1.336,-10.125) AE14(5.515,-10.148) AE16(6.328,-10.148) AE18(7.141,-10.148) AE20(7.954,-10.148) AE22(8.766,-10.148) AE24(9.579,-10.148) AE26(10.392,-10.148) AE28(11.205,-10.148) AE30(12.018,-10.148) AE32(12.83,-10.148) AE42(17.289,-10.125) AE44(18.173,-10.147) AF1(0,-10.532) AF3(0.904,-10.532) AF6(1.934,-10.595) AF7(2.531,-10.595) AF8(3.128,-10.595) AF10(3.724,-10.595) AF11(4.321,-10.595) AF12(4.918,-10.595) AF34(13.707,-10.595) AF35(14.304,-10.595) AF36(14.9,-10.595) AF38(15.497,-10.595) AF39(16.094,-10.595) AF40(16.691,-10.595) AF43(17.721,-10.532) AF45(18.625,-10.532) AG2(0.472,-10.938) AG14(5.515,-10.808) AG16(6.328,-10.808) AG18(7.141,-10.808) AG20(7.954,-10.808) AG22(8.766,-10.808) AG24(9.579,-10.808) AG26(10.392,-10.808) AG28(11.205,-10.808) AG30(12.018,-10.808) AG32(12.83,-10.808) AG44(18.152,-10.938) AH1(0,-11.344) AH3(0.904,-11.344) AH43(17.721,-11.344) AH45(18.625,-11.344) AJ2(0.452,-11.729) AJ4(1.336,-11.751) AJ6(1.934,-11.573) AJ7(2.531,-11.573) AJ8(3.128,-11.573) AJ10(3.724,-11.573) AJ11(4.321,-11.573) AJ12(4.918,-11.573) AJ14(5.515,-11.469) AJ16(6.328,-11.469) AJ18(7.141,-11.469) AJ20(7.954,-11.469) AJ22(8.766,-11.469) AJ24(9.579,-11.469) AJ26(10.392,-11.469) AJ28(11.205,-11.469) AJ30(12.018,-11.469) AJ32(12.83,-11.469) AJ34(13.707,-11.573) AJ35(14.304,-11.573) AJ36(14.9,-11.573) AJ38(15.497,-11.573) AJ39(16.094,-11.573) AJ40(16.691,-11.573) AJ42(17.289,-11.751) AJ44(18.173,-11.773) AK1(0,-12.157) AK3(0.904,-12.157) AK14(5.515,-12.129) AK16(6.328,-12.129) AK18(7.141,-12.129) AK20(7.954,-12.129) AK22(8.766,-12.129) AK24(9.579,-12.129) AK26(10.392,-12.129) AK28(11.205,-12.129) AK30(12.018,-12.129) AK32(12.83,-12.129) AK43(17.721,-12.157) AK45(18.625,-12.157) AL2(0.472,-12.564) AL6(1.934,-12.551) AL7(2.531,-12.551) AL8(3.128,-12.551) AL10(3.724,-12.551) AL11(4.321,-12.551) AL12(4.918,-12.551) AL34(13.707,-12.551) AL35(14.304,-12.551) AL36(14.9,-12.551) AL38(15.497,-12.551) AL39(16.094,-12.551) AL40(16.691,-12.551) AL44(18.152,-12.564) AM1(0,-12.97) AM3(0.904,-12.97) AM14(5.515,-12.79) AM16(6.328,-12.79) AM18(7.141,-12.79) AM20(7.954,-12.79) AM22(8.766,-12.79) AM24(9.579,-12.79) AM26(10.392,-12.79) AM28(11.205,-12.79) AM30(12.018,-12.79) AM32(12.83,-12.79) AM43(17.721,-12.97) AM45(18.625,-12.97) AN2(0.452,-13.355) AN4(1.336,-13.376) AN6(1.934,-13.529) AN7(2.531,-13.529) AN8(3.128,-13.529) AN10(3.724,-13.529) AN11(4.321,-13.529) AN34(13.656,-13.529) AN35(14.304,-13.529) AN36(14.9,-13.529) AN38(15.497,-13.529) AN39(16.094,-13.529) AN40(16.691,-13.529) AN42(17.289,-13.376) AN44(18.173,-13.398) AP1(0,-13.783) AP3(0.904,-13.783) AP13(5.096,-13.656) AP15(6.074,-13.707) AP17(7.052,-13.707) AP20(8.03,-13.707) AP22(9.008,-13.707) AP24(9.617,-13.707) AP26(10.595,-13.707) AP29(11.573,-13.707) AP31(12.551,-13.707) AP43(17.721,-13.783) AP45(18.625,-13.783) AR2(0.472,-14.189) AR13(5.096,-14.304) AR15(6.074,-14.304) AR17(7.052,-14.304) AR20(8.03,-14.304) AR22(9.008,-14.304) AR24(9.617,-14.304) AR26(10.595,-14.304) AR29(11.573,-14.304) AR31(12.551,-14.304) AR33(13.529,-14.304) AR44(18.152,-14.189) AT1(0,-14.596) AT3(0.904,-14.596) AT6(1.934,-14.507) AT7(2.531,-14.507) AT8(3.128,-14.507) AT10(4.118,-14.9) AT13(5.096,-14.9) AT15(6.074,-14.9) AT17(7.052,-14.9) AT20(8.03,-14.9) AT22(9.008,-14.9) AT24(9.617,-14.9) AT26(10.595,-14.9) AT29(11.573,-14.9) AT31(12.551,-14.9) AT33(13.529,-14.9) AT36(14.9,-14.507) AT38(15.497,-14.507) AT39(16.094,-14.507) AT40(16.691,-14.507) AT43(17.721,-14.596) AT45(18.625,-14.596) AU2(0.452,-14.98) AU4(1.336,-15.002) AU42(17.289,-15.002) AU44(18.173,-15.024) AV1(0,-15.408) AV3(0.904,-15.408) AV6(1.934,-15.485) AV7(2.531,-15.485) AV10(4.118,-15.497) AV13(5.096,-15.497) AV15(6.074,-15.497) AV17(7.052,-15.497) AV20(8.03,-15.497) AV22(9.008,-15.497) AV24(9.617,-15.497) AV26(10.595,-15.497) AV29(11.573,-15.497) AV31(12.551,-15.497) AV33(13.529,-15.497) AV36(14.507,-15.497) AV40(16.691,-15.485) AV43(17.721,-15.408) AV45(18.625,-15.408) AW2(0.472,-15.815) AW8(3.14,-16.094) AW10(4.118,-16.094) AW13(5.096,-16.094) AW15(6.074,-16.094) AW17(7.052,-16.094) AW20(8.03,-16.094) AW22(9.008,-16.094) AW24(9.617,-16.094) AW26(10.595,-16.094) AW29(11.573,-16.094) AW31(12.551,-16.094) AW33(13.529,-16.094) AW36(14.507,-16.094) AW38(15.485,-16.094) AW40(17.123,-16.221) AW44(18.152,-15.815) AY3(0.978,-16.221) AY5(1.743,-16.051) AY7(2.404,-17.123) AY8(3.14,-16.691) AY10(4.118,-16.691) AY13(5.096,-16.691) AY15(6.074,-16.691) AY17(7.052,-16.691) AY20(8.03,-16.691) AY22(9.008,-16.691) AY24(9.617,-16.691) AY26(10.595,-16.691) AY29(11.573,-16.691) AY31(12.551,-16.691) AY33(13.529,-16.691) AY36(14.507,-16.691) AY38(15.485,-16.691) AY43(17.721,-16.221) B5(1.96,-0.586) B7(2.739,-0.552) B9(3.645,-0.452) B11(4.436,-0.472) B13(5.27,-0.452) B15(6.061,-0.472) B17(6.896,-0.452) B19(7.687,-0.472) B21(8.521,-0.452) B23(9.312,-0.472) B25(10.147,-0.452) B27(10.938,-0.472) B29(11.773,-0.452) B31(12.564,-0.472) B33(13.398,-0.452) B35(14.189,-0.472) B37(15.024,-0.452) B39(15.815,-0.472) BA40(16.051,-16.882) BB4(1.391,-17.302) BB9(3.623,-17.289) BB13(5.248,-17.289) BB17(6.874,-17.289) BB21(8.5,-17.289) BB25(10.125,-17.289) BB29(11.751,-17.289) BB33(13.376,-17.289) BB37(15.002,-17.289) BB42(17.302,-17.233) BC6(2.404,-17.721) BC8(3.216,-17.721) BC10(4.029,-17.721) BC12(4.842,-17.721) BC14(5.655,-17.721) BC16(6.468,-17.721) BC18(7.28,-17.721) BC20(8.093,-17.721) BC22(8.906,-17.721) BC24(9.719,-17.721) BC26(10.532,-17.721) BC28(11.344,-17.721) BC30(12.157,-17.721) BC32(12.97,-17.721) BC34(13.783,-17.721) BC36(14.596,-17.721) BC38(15.408,-17.721) BC40(16.221,-17.647) BD7(2.81,-18.152) BD9(3.601,-18.173) BD11(4.436,-18.152) BD13(5.227,-18.173) BD15(6.061,-18.152) BD17(6.852,-18.173) BD19(7.687,-18.152) BD21(8.478,-18.173) BD23(9.312,-18.152) BD25(10.103,-18.173) BD27(10.938,-18.152) BD29(11.729,-18.173) BD31(12.564,-18.152) BD33(13.355,-18.173) BD35(14.189,-18.152) BD37(14.98,-18.173) BD39(15.815,-18.152) BE8(3.216,-18.625) BE10(4.029,-18.625) BE12(4.842,-18.625) BE14(5.655,-18.625) BE16(6.468,-18.625) BE18(7.28,-18.625) BE20(8.093,-18.625) BE22(8.906,-18.625) BE24(9.719,-18.625) BE26(10.532,-18.625) BE28(11.344,-18.625) BE30(12.157,-18.625) BE32(12.97,-18.625) BE34(13.783,-18.625) BE36(14.596,-18.625) BE38(15.408,-18.625) C6(2.37,-1.017) C8(3.216,-0.904) C10(4.029,-0.904) C12(4.842,-0.904) C14(5.655,-0.904) C16(6.468,-0.904) C18(7.28,-0.904) C20(8.093,-0.904) C22(8.906,-0.904) C24(9.719,-0.904) C26(10.532,-0.904) C28(11.344,-0.904) C30(12.157,-0.904) C32(12.97,-0.904) C34(13.783,-0.904) C36(14.596,-0.904) C38(15.408,-0.904) C40(16.221,-0.904) D4(1.323,-1.391) D9(3.623,-1.336) D13(5.248,-1.336) D17(6.874,-1.336) D21(8.5,-1.336) D25(10.125,-1.336) D29(11.751,-1.336) D33(13.376,-1.336) D37(15.002,-1.336) D42(17.233,-1.323) E6(2.574,-1.743) F3(0.978,-2.359) F8(3.14,-1.934) F10(4.118,-1.934) F13(5.096,-1.934) F15(6.074,-1.934) F17(7.052,-1.934) F20(8.03,-1.934) F22(9.008,-1.934) F24(9.617,-1.934) F26(10.595,-1.934) F29(11.573,-1.934) F31(12.551,-1.934) F33(13.529,-1.934) F36(14.507,-1.934) F38(15.485,-1.934) F39(16.221,-1.502) F41(16.882,-2.574) F43(17.647,-2.404) G2(0.532,-2.752) G5(1.562,-2.48) G8(3.14,-2.531) G10(4.118,-2.531) G13(5.096,-2.531) G15(6.074,-2.531) G17(7.052,-2.531) G20(8.03,-2.531) G22(9.008,-2.531) G24(9.617,-2.531) G26(10.595,-2.531) G29(11.573,-2.531) G31(12.551,-2.531) G33(13.529,-2.531) G36(14.507,-2.531) G38(15.485,-2.531) G44(18.152,-2.81) H1(0,-3.216) H3(0.904,-3.216) H6(1.934,-3.14) H7(2.531,-3.14) H10(4.118,-3.128) H13(5.096,-3.128) H15(6.074,-3.128) H17(7.052,-3.128) H20(8.03,-3.128) H22(9.008,-3.128) H24(9.617,-3.128) H26(10.595,-3.128) H29(11.573,-3.128) H31(12.551,-3.128) H33(13.529,-3.128) H36(14.507,-3.128) H39(16.094,-3.14) H40(16.691,-3.14) H43(17.721,-3.216) H45(18.625,-3.216) J2(0.452,-3.601) J4(1.336,-3.623) J42(17.289,-3.623) J44(18.173,-3.645) K1(0,-4.029) K3(0.904,-4.029) K6(1.934,-4.118) K7(2.531,-4.118) K8(3.128,-4.118) K10(3.724,-4.118) K13(5.096,-3.724) K15(6.074,-3.724) K17(7.052,-3.724) K20(8.03,-3.724) K22(9.008,-3.724) K24(9.617,-3.724) K26(10.595,-3.724) K29(11.573,-3.724) K31(12.551,-3.724) K33(13.529,-3.724) K36(14.507,-3.724) K38(15.497,-4.118) K39(16.094,-4.118) K40(16.691,-4.118) K43(17.721,-4.029) K45(18.625,-4.029) L2(0.472,-4.436) L13(5.096,-4.321) L15(6.074,-4.321) L17(7.052,-4.321) L20(8.03,-4.321) L22(9.008,-4.321) L24(9.617,-4.321) L26(10.595,-4.321) L29(11.573,-4.321) L31(12.551,-4.321) L33(13.529,-4.321) L44(18.152,-4.436) M1(0,-4.842) M3(0.904,-4.842) M15(6.074,-4.918) M17(7.052,-4.918) M20(8.03,-4.918) M22(9.008,-4.918) M24(9.617,-4.918) M26(10.595,-4.918) M29(11.573,-4.918) M31(12.551,-4.918) M33(13.529,-4.969) M43(17.721,-4.842) M45(18.625,-4.842) N2(0.452,-5.227) N4(1.336,-5.248) N6(1.934,-5.096) N7(2.531,-5.096) N8(3.128,-5.096) N10(3.724,-5.096) N11(4.321,-5.096) N12(4.969,-5.096) N35(14.304,-5.096) N36(14.9,-5.096) N38(15.497,-5.096) N39(16.094,-5.096) N40(16.691,-5.096) N42(17.289,-5.248) N44(18.173,-5.27) P1(0,-5.655) P3(0.904,-5.655) P14(5.515,-5.525) P16(6.328,-5.525) P18(7.141,-5.525) P20(7.954,-5.525) P22(8.766,-5.525) P24(9.579,-5.525) P26(10.392,-5.525) P28(11.205,-5.525) P30(12.018,-5.525) P32(12.83,-5.525) P43(17.721,-5.655) P45(18.625,-5.655) R2(0.472,-6.061) R6(1.934,-6.074) R7(2.531,-6.074) R8(3.128,-6.074) R10(3.724,-6.074) R11(4.321,-6.074) R12(4.918,-6.074) R14(5.515,-6.186) R16(6.328,-6.186) R18(7.141,-6.186) R20(7.954,-6.186) R22(8.766,-6.186) R24(9.579,-6.186) R26(10.392,-6.186) R28(11.205,-6.186) R30(12.018,-6.186) R32(12.83,-6.186) R34(13.707,-6.074) R35(14.304,-6.074) R36(14.9,-6.074) R38(15.497,-6.074) R39(16.094,-6.074) R40(16.691,-6.074) R44(18.152,-6.061) T1(0,-6.468) T3(0.904,-6.468) T43(17.721,-6.468) T45(18.625,-6.468) U2(0.452,-6.852) U4(1.336,-6.874) U6(1.934,-7.052) U7(2.531,-7.052) U8(3.128,-7.052) U10(3.724,-7.052) U11(4.321,-7.052) U12(4.918,-7.052) U14(5.515,-6.846) U16(6.328,-6.846) U18(7.141,-6.846) U20(7.954,-6.846) U22(8.766,-6.846) U24(9.579,-6.846) U26(10.392,-6.846) U28(11.205,-6.846) U30(12.018,-6.846) U32(12.83,-6.846) U34(13.707,-7.052) U35(14.304,-7.052) U36(14.9,-7.052) U38(15.497,-7.052) U39(16.094,-7.052) U40(16.691,-7.052) U42(17.289,-6.874) U44(18.173,-6.896) V1(0,-7.28) V3(0.904,-7.28) V14(5.515,-7.506) V16(6.328,-7.506) V18(7.141,-7.506) V20(7.954,-7.506) V22(8.766,-7.506) V24(9.579,-7.506) V26(10.392,-7.506) V28(11.205,-7.506) V30(12.018,-7.506) V32(12.83,-7.506) V43(17.721,-7.28) V45(18.625,-7.28) W2(0.472,-7.687) W44(18.152,-7.687) Y1(0,-8.093) Y3(0.904,-8.093) Y6(1.934,-8.03) Y7(2.531,-8.03) Y8(3.128,-8.03) Y10(3.724,-8.03) Y11(4.321,-8.03) Y12(4.918,-8.03) Y14(5.515,-8.167) Y16(6.328,-8.167) Y18(7.141,-8.167) Y20(7.954,-8.167) Y22(8.766,-8.167) Y24(9.579,-8.167) Y26(10.392,-8.167) Y28(11.205,-8.167) Y30(12.018,-8.167) Y32(12.83,-8.167) Y34(13.707,-8.03) Y35(14.304,-8.03) Y36(14.9,-8.03) Y38(15.497,-8.03) Y39(16.094,-8.03) Y40(16.691,-8.03) Y43(17.721,-8.093) Y45(18.625,-8.093)
MAX9892ERTLFT_UCSP_6P
  round 0.267 smd: A1(0,0) A2(0.5,0) A3(1,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5)
MC74VHC1G08DFT2G_SC70-5
  oval 0.381x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MDS1521URH_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
MDU1512RH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MDU1516URH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MDV1522URH_PDFN33-8-5
  oval 0.406x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.65x0.65 smd: 5(0.975,1.475)
MDV1524URH_PDFN33-8-5
  oval 0.406x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.65x0.65 smd: 5(0.975,1.475)
MDV1527URH_POWERDFN33-8-5
  oval 0.406x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.65x0.65 smd: 5(0.975,1.475)
MDV1528URH_PDFN33-8-5
  oval 0.406x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.65x0.65 smd: 5(0.975,1.475)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AG102SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15GA750SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM18AG121SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18AG601SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18PG181SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18PG181SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18PG300SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM21PG600SN1D_L0805_2P
  rect 0.991x1.753 smd: 1(0,0) 2(1.5,0)
MURAT_DLP11SN900HL2L_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,0.55) 4(0,0.55)
MURAT_DLW21SN900HQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_LQM18FN4R7M00D_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
N13M_FCBGA_908P
  round 0.381 smd: A2(0.8,0) A3(1.6,0) A5(3.3,0) A6(4.1,0) A8(5.8,0) A9(6.6,0) A11(8.3,0) A12(9.1,0) A14(10.8,0) A15(11.6,0) A17(13.3,0) A18(14.1,0) A20(15.8,0) A21(16.6,0) A23(18.3,0) A24(19.1,0) A26(20.8,0) A27(21.6,0) A29(23.3,0) A30(24.1,0) A32(25.8,0) A33(26.6,0) AA1(0,-16.6) AA2(0.8,-16.6) AA3(1.6,-16.6) AA4(2.4,-16.6) AA5(3.2,-16.6) AA6(4.05,-16.6) AA7(4.9,-16.6) AA8(5.7,-16.6) AA27(21.7,-16.6) AA28(22.5,-16.6) AA29(23.35,-16.6) AA30(24.2,-16.6) AA31(25,-16.6) AA32(25.8,-16.6) AA33(26.6,-16.6) AA34(27.4,-16.6) AB2(0.8,-17.45) AB3(1.6,-17.45) AB4(2.4,-17.45) AB5(3.2,-17.45) AB7(4.9,-17.45) AB8(5.7,-17.45) AB27(21.7,-17.45) AB28(22.5,-17.45) AB30(24.2,-17.45) AB31(25,-17.45) AB32(25.8,-17.45) AB33(26.6,-17.45) AC1(0,-18.3) AC2(0.8,-18.3) AC3(1.6,-18.3) AC4(2.4,-18.3) AC5(3.2,-18.3) AC6(4.05,-18.3) AC7(4.9,-18.3) AC8(5.7,-18.3) AC27(21.7,-18.3) AC28(22.5,-18.3) AC29(23.35,-18.3) AC30(24.2,-18.3) AC31(25,-18.3) AC32(25.8,-18.3) AC33(26.6,-18.3) AC34(27.4,-18.3) AD1(0,-19.1) AD2(0.8,-19.1) AD3(1.6,-19.1) AD4(2.4,-19.1) AD5(3.2,-19.1) AD6(4.05,-19.1) AD7(4.9,-19.1) AD8(5.7,-19.1) AD27(21.7,-19.1) AD28(22.5,-19.1) AD29(23.35,-19.1) AD30(24.2,-19.1) AD31(25,-19.1) AD32(25.8,-19.1) AD33(26.6,-19.1) AD34(27.4,-19.1) AE2(0.8,-19.95) AE3(1.6,-19.95) AE4(2.4,-19.95) AE5(3.2,-19.95) AE7(4.9,-19.95) AE8(5.7,-19.95) AE27(21.7,-19.95) AE28(22.5,-19.95) AE30(24.2,-19.95) AE31(25,-19.95) AE32(25.8,-19.95) AE33(26.6,-19.95) AF1(0,-20.8) AF2(0.8,-20.8) AF3(1.6,-20.8) AF4(2.4,-20.8) AF5(3.2,-20.8) AF6(4.05,-20.8) AF7(4.9,-20.8) AF8(5.7,-20.8) AF27(21.7,-20.8) AF28(22.5,-20.8) AF29(23.35,-20.8) AF30(24.2,-20.8) AF31(25,-20.8) AF32(25.8,-20.8) AF33(26.6,-20.8) AF34(27.4,-20.8) AG1(0,-21.6) AG2(0.8,-21.6) AG3(1.6,-21.6) AG4(2.4,-21.6) AG5(3.2,-21.6) AG6(4.05,-21.6) AG7(4.9,-21.6) AG8(5.7,-21.7) AG9(6.6,-21.7) AG10(7.45,-21.7) AG11(8.3,-21.7) AG12(9.1,-21.7) AG13(9.95,-21.7) AG14(10.8,-21.7) AG15(11.6,-21.7) AG16(12.45,-21.7) AG17(13.3,-21.7) AG18(14.1,-21.7) AG19(14.95,-21.7) AG20(15.8,-21.7) AG21(16.6,-21.7) AG22(17.45,-21.7) AG23(18.3,-21.7) AG24(19.1,-21.7) AG25(19.95,-21.7) AG26(20.8,-21.7) AG27(21.7,-21.7) AG28(22.5,-21.6) AG29(23.35,-21.6) AG30(24.2,-21.6) AG31(25,-21.6) AG32(25.8,-21.6) AG33(26.6,-21.6) AG34(27.4,-21.6) AH2(0.8,-22.45) AH3(1.6,-22.45) AH4(2.4,-22.45) AH5(3.2,-22.45) AH6(4.05,-22.45) AH7(4.9,-22.5) AH8(5.8,-22.5) AH9(6.6,-22.5) AH10(7.45,-22.5) AH11(8.3,-22.5) AH12(9.1,-22.5) AH13(9.95,-22.5) AH14(10.8,-22.5) AH15(11.6,-22.5) AH16(12.45,-22.5) AH17(13.3,-22.5) AH18(14.1,-22.5) AH19(14.95,-22.5) AH20(15.8,-22.5) AH21(16.6,-22.5) AH22(17.45,-22.5) AH23(18.3,-22.5) AH24(19.1,-22.5) AH25(19.95,-22.5) AH26(20.8,-22.5) AH27(21.6,-22.5) AH28(22.5,-22.5) AH29(23.35,-22.45) AH30(24.2,-22.45) AH31(25,-22.45) AH32(25.8,-22.45) AH33(26.6,-22.45) AJ1(0,-23.3) AJ2(0.8,-23.3) AJ3(1.6,-23.3) AJ4(2.4,-23.3) AJ5(3.2,-23.3) AJ6(4.05,-23.35) AJ7(4.95,-23.35) AJ8(5.8,-23.35) AJ9(6.6,-23.35) AJ11(8.3,-23.35) AJ12(9.1,-23.35) AJ14(10.8,-23.35) AJ15(11.6,-23.35) AJ17(13.3,-23.35) AJ18(14.1,-23.35) AJ20(15.8,-23.35) AJ21(16.6,-23.35) AJ23(18.3,-23.35) AJ24(19.1,-23.35) AJ26(20.8,-23.35) AJ27(21.6,-23.35) AJ28(22.45,-23.35) AJ29(23.35,-23.35) AJ30(24.2,-23.3) AJ31(25,-23.3) AJ32(25.8,-23.3) AJ33(26.6,-23.3) AJ34(27.4,-23.3) AK1(0,-24.1) AK2(0.8,-24.1) AK3(1.6,-24.1) AK4(2.4,-24.1) AK5(3.2,-24.2) AK6(4.1,-24.2) AK7(4.95,-24.2) AK8(5.8,-24.2) AK9(6.6,-24.2) AK10(7.45,-24.2) AK11(8.3,-24.2) AK12(9.1,-24.2) AK13(9.95,-24.2) AK14(10.8,-24.2) AK15(11.6,-24.2) AK16(12.45,-24.2) AK17(13.3,-24.2) AK18(14.1,-24.2) AK19(14.95,-24.2) AK20(15.8,-24.2) AK21(16.6,-24.2) AK22(17.45,-24.2) AK23(18.3,-24.2) AK24(19.1,-24.2) AK25(19.95,-24.2) AK26(20.8,-24.2) AK27(21.6,-24.2) AK28(22.45,-24.2) AK29(23.3,-24.2) AK30(24.2,-24.2) AK31(25,-24.1) AK32(25.8,-24.1) AK33(26.6,-24.1) AK34(27.4,-24.1) AL2(0.8,-24.95) AL3(1.6,-24.95) AL4(2.4,-25) AL5(3.3,-25) AL6(4.1,-25) AL7(4.95,-25) AL8(5.8,-25) AL9(6.6,-25) AL10(7.45,-25) AL11(8.3,-25) AL12(9.1,-25) AL13(9.95,-25) AL14(10.8,-25) AL15(11.6,-25) AL16(12.45,-25) AL17(13.3,-25) AL18(14.1,-25) AL19(14.95,-25) AL20(15.8,-25) AL21(16.6,-25) AL22(17.45,-25) AL23(18.3,-25) AL24(19.1,-25) AL25(19.95,-25) AL26(20.8,-25) AL27(21.6,-25) AL28(22.45,-25) AL29(23.3,-25) AL30(24.1,-25) AL31(25,-25) AL32(25.8,-24.95) AL33(26.6,-24.95) AM1(0,-25.8) AM2(0.8,-25.8) AM3(1.6,-25.8) AM4(2.45,-25.8) AM5(3.3,-25.8) AM6(4.1,-25.8) AM7(4.95,-25.8) AM8(5.8,-25.8) AM9(6.6,-25.8) AM10(7.45,-25.8) AM11(8.3,-25.8) AM12(9.1,-25.8) AM13(9.95,-25.8) AM14(10.8,-25.8) AM15(11.6,-25.8) AM16(12.45,-25.8) AM17(13.3,-25.8) AM18(14.1,-25.8) AM19(14.95,-25.8) AM20(15.8,-25.8) AM21(16.6,-25.8) AM22(17.45,-25.8) AM23(18.3,-25.8) AM24(19.1,-25.8) AM25(19.95,-25.8) AM26(20.8,-25.8) AM27(21.6,-25.8) AM28(22.45,-25.8) AM29(23.3,-25.8) AM30(24.1,-25.8) AM31(24.95,-25.8) AM32(25.8,-25.8) AM33(26.6,-25.8) AM34(27.4,-25.8) AN1(0,-26.6) AN2(0.8,-26.6) AN3(1.6,-26.6) AN4(2.45,-26.6) AN5(3.3,-26.6) AN6(4.1,-26.6) AN7(4.95,-26.6) AN8(5.8,-26.6) AN9(6.6,-26.6) AN10(7.45,-26.6) AN11(8.3,-26.6) AN12(9.1,-26.6) AN13(9.95,-26.6) AN14(10.8,-26.6) AN15(11.6,-26.6) AN16(12.45,-26.6) AN17(13.3,-26.6) AN18(14.1,-26.6) AN19(14.95,-26.6) AN20(15.8,-26.6) AN21(16.6,-26.6) AN22(17.45,-26.6) AN23(18.3,-26.6) AN24(19.1,-26.6) AN25(19.95,-26.6) AN26(20.8,-26.6) AN27(21.6,-26.6) AN28(22.45,-26.6) AN29(23.3,-26.6) AN30(24.1,-26.6) AN31(24.95,-26.6) AN32(25.8,-26.6) AN33(26.6,-26.6) AN34(27.4,-26.6) AP2(0.8,-27.4) AP3(1.6,-27.4) AP5(3.3,-27.4) AP6(4.1,-27.4) AP8(5.8,-27.4) AP9(6.6,-27.4) AP11(8.3,-27.4) AP12(9.1,-27.4) AP14(10.8,-27.4) AP15(11.6,-27.4) AP17(13.3,-27.4) AP18(14.1,-27.4) AP20(15.8,-27.4) AP21(16.6,-27.4) AP23(18.3,-27.4) AP24(19.1,-27.4) AP26(20.8,-27.4) AP27(21.6,-27.4) AP29(23.3,-27.4) AP30(24.1,-27.4) AP32(25.8,-27.4) AP33(26.6,-27.4) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.45,-0.8) B5(3.3,-0.8) B6(4.1,-0.8) B7(4.95,-0.8) B8(5.8,-0.8) B9(6.6,-0.8) B10(7.45,-0.8) B11(8.3,-0.8) B12(9.1,-0.8) B13(9.95,-0.8) B14(10.8,-0.8) B15(11.6,-0.8) B16(12.45,-0.8) B17(13.3,-0.8) B18(14.1,-0.8) B19(14.95,-0.8) B20(15.8,-0.8) B21(16.6,-0.8) B22(17.45,-0.8) B23(18.3,-0.8) B24(19.1,-0.8) B25(19.95,-0.8) B26(20.8,-0.8) B27(21.6,-0.8) B28(22.45,-0.8) B29(23.3,-0.8) B30(24.1,-0.8) B31(24.95,-0.8) B32(25.8,-0.8) B33(26.6,-0.8) B34(27.4,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.45,-1.6) C5(3.3,-1.6) C6(4.1,-1.6) C7(4.95,-1.6) C8(5.8,-1.6) C9(6.6,-1.6) C10(7.45,-1.6) C11(8.3,-1.6) C12(9.1,-1.6) C13(9.95,-1.6) C14(10.8,-1.6) C15(11.6,-1.6) C16(12.45,-1.6) C17(13.3,-1.6) C18(14.1,-1.6) C19(14.95,-1.6) C20(15.8,-1.6) C21(16.6,-1.6) C22(17.45,-1.6) C23(18.3,-1.6) C24(19.1,-1.6) C25(19.95,-1.6) C26(20.8,-1.6) C27(21.6,-1.6) C28(22.45,-1.6) C29(23.3,-1.6) C30(24.1,-1.6) C31(24.95,-1.6) C32(25.8,-1.6) C33(26.6,-1.6) C34(27.4,-1.6) D2(0.8,-2.45) D3(1.6,-2.45) D4(2.4,-2.4) D5(3.3,-2.4) D6(4.1,-2.4) D7(4.95,-2.4) D8(5.8,-2.4) D9(6.6,-2.4) D10(7.45,-2.4) D11(8.3,-2.4) D12(9.1,-2.4) D13(9.95,-2.4) D14(10.8,-2.4) D15(11.6,-2.4) D16(12.45,-2.4) D17(13.3,-2.4) D18(14.1,-2.4) D19(14.95,-2.4) D20(15.8,-2.4) D21(16.6,-2.4) D22(17.45,-2.4) D23(18.3,-2.4) D24(19.1,-2.4) D25(19.95,-2.4) D26(20.8,-2.4) D27(21.6,-2.4) D28(22.45,-2.4) D29(23.3,-2.4) D30(24.1,-2.4) D31(25,-2.4) D32(25.8,-2.45) D33(26.6,-2.45) E1(0,-3.3) E2(0.8,-3.3) E3(1.6,-3.3) E4(2.4,-3.3) E5(3.2,-3.2) E6(4.1,-3.2) E7(4.95,-3.2) E8(5.8,-3.2) E9(6.6,-3.2) E10(7.45,-3.2) E11(8.3,-3.2) E12(9.1,-3.2) E13(9.95,-3.2) E14(10.8,-3.2) E15(11.6,-3.2) E16(12.45,-3.2) E17(13.3,-3.2) E18(14.1,-3.2) E19(14.95,-3.2) E20(15.8,-3.2) E21(16.6,-3.2) E22(17.45,-3.2) E23(18.3,-3.2) E24(19.1,-3.2) E25(19.95,-3.2) E26(20.8,-3.2) E27(21.6,-3.2) E28(22.45,-3.2) E29(23.3,-3.2) E30(24.2,-3.2) E31(25,-3.3) E32(25.8,-3.3) E33(26.6,-3.3) E34(27.4,-3.3) F1(0,-4.1) F2(0.8,-4.1) F3(1.6,-4.1) F4(2.4,-4.1) F5(3.2,-4.1) F6(4.05,-4.05) F7(4.95,-4.05) F8(5.8,-4.05) F9(6.6,-4.05) F11(8.3,-4.05) F12(9.1,-4.05) F14(10.8,-4.05) F15(11.6,-4.05) F17(13.3,-4.05) F18(14.1,-4.05) F20(15.8,-4.05) F21(16.6,-4.05) F23(18.3,-4.05) F24(19.1,-4.05) F26(20.8,-4.05) F27(21.6,-4.05) F28(22.45,-4.05) F29(23.35,-4.05) F30(24.2,-4.1) F31(25,-4.1) F32(25.8,-4.1) F33(26.6,-4.1) F34(27.4,-4.1) G2(0.8,-4.95) G3(1.6,-4.95) G4(2.4,-4.95) G5(3.2,-4.95) G6(4.05,-4.95) G7(4.9,-4.9) G8(5.8,-4.9) G9(6.6,-4.9) G10(7.45,-4.9) G11(8.3,-4.9) G12(9.1,-4.9) G13(9.95,-4.9) G14(10.8,-4.9) G15(11.6,-4.9) G16(12.45,-4.9) G17(13.3,-4.9) G18(14.1,-4.9) G19(14.95,-4.9) G20(15.8,-4.9) G21(16.6,-4.9) G22(17.45,-4.9) G23(18.3,-4.9) G24(19.1,-4.9) G25(19.95,-4.9) G26(20.8,-4.9) G27(21.6,-4.9) G28(22.5,-4.9) G29(23.35,-4.95) G30(24.2,-4.95) G31(25,-4.95) G32(25.8,-4.95) G33(26.6,-4.95) H1(0,-5.8) H2(0.8,-5.8) H3(1.6,-5.8) H4(2.4,-5.8) H5(3.2,-5.8) H6(4.05,-5.8) H7(4.9,-5.8) H8(5.7,-5.7) H9(6.6,-5.7) H10(7.45,-5.7) H11(8.3,-5.7) H12(9.1,-5.7) H13(9.95,-5.7) H14(10.8,-5.7) H15(11.6,-5.7) H16(12.45,-5.7) H17(13.3,-5.7) H18(14.1,-5.7) H19(14.95,-5.7) H20(15.8,-5.7) H21(16.6,-5.7) H22(17.45,-5.7) H23(18.3,-5.7) H24(19.1,-5.7) H25(19.95,-5.7) H26(20.8,-5.7) H27(21.7,-5.7) H28(22.5,-5.8) H29(23.35,-5.8) H30(24.2,-5.8) H31(25,-5.8) H32(25.8,-5.8) H33(26.6,-5.8) H34(27.4,-5.8) J1(0,-6.6) J2(0.8,-6.6) J3(1.6,-6.6) J4(2.4,-6.6) J5(3.2,-6.6) J6(4.05,-6.6) J7(4.9,-6.6) J8(5.7,-6.6) J27(21.7,-6.6) J28(22.5,-6.6) J29(23.35,-6.6) J30(24.2,-6.6) J31(25,-6.6) J32(25.8,-6.6) J33(26.6,-6.6) J34(27.4,-6.6) K2(0.8,-7.45) K3(1.6,-7.45) K4(2.4,-7.45) K5(3.2,-7.45) K7(4.9,-7.45) K8(5.7,-7.45) K27(21.7,-7.45) K28(22.5,-7.45) K30(24.2,-7.45) K31(25,-7.45) K32(25.8,-7.45) K33(26.6,-7.45) L1(0,-8.3) L2(0.8,-8.3) L3(1.6,-8.3) L4(2.4,-8.3) L5(3.2,-8.3) L6(4.05,-8.3) L7(4.9,-8.3) L8(5.7,-8.3) L27(21.7,-8.3) L28(22.5,-8.3) L29(23.35,-8.3) L30(24.2,-8.3) L31(25,-8.3) L32(25.8,-8.3) L33(26.6,-8.3) L34(27.4,-8.3) M1(0,-9.1) M2(0.8,-9.1) M3(1.6,-9.1) M4(2.4,-9.1) M5(3.2,-9.1) M6(4.05,-9.1) M7(4.9,-9.1) M8(5.7,-9.1) M27(21.7,-9.1) M28(22.5,-9.1) M29(23.35,-9.1) M30(24.2,-9.1) M31(25,-9.1) M32(25.8,-9.1) M33(26.6,-9.1) M34(27.4,-9.1) N2(0.8,-9.95) N3(1.6,-9.95) N4(2.4,-9.95) N5(3.2,-9.95) N7(4.9,-9.95) N8(5.7,-9.95) N27(21.7,-9.95) N28(22.5,-9.95) N30(24.2,-9.95) N31(25,-9.95) N32(25.8,-9.95) N33(26.6,-9.95) P1(0,-10.8) P2(0.8,-10.8) P3(1.6,-10.8) P4(2.4,-10.8) P5(3.2,-10.8) P6(4.05,-10.8) P7(4.9,-10.8) P8(5.7,-10.8) P27(21.7,-10.8) P28(22.5,-10.8) P29(23.35,-10.8) P30(24.2,-10.8) P31(25,-10.8) P32(25.8,-10.8) P33(26.6,-10.8) P34(27.4,-10.8) R1(0,-11.6) R2(0.8,-11.6) R3(1.6,-11.6) R4(2.4,-11.6) R5(3.2,-11.6) R6(4.05,-11.6) R7(4.9,-11.6) R8(5.7,-11.6) R27(21.7,-11.6) R28(22.5,-11.6) R29(23.35,-11.6) R30(24.2,-11.6) R31(25,-11.6) R32(25.8,-11.6) R33(26.6,-11.6) R34(27.4,-11.6) T2(0.8,-12.45) T3(1.6,-12.45) T4(2.4,-12.45) T5(3.2,-12.45) T7(4.9,-12.45) T8(5.7,-12.45) T27(21.7,-12.45) T28(22.5,-12.45) T30(24.2,-12.45) T31(25,-12.45) T32(25.8,-12.45) T33(26.6,-12.45) U1(0,-13.3) U2(0.8,-13.3) U3(1.6,-13.3) U4(2.4,-13.3) U5(3.2,-13.3) U6(4.05,-13.3) U7(4.9,-13.3) U8(5.7,-13.3) U27(21.7,-13.3) U28(22.5,-13.3) U29(23.35,-13.3) U30(24.2,-13.3) U31(25,-13.3) U32(25.8,-13.3) U33(26.6,-13.3) U34(27.4,-13.3) V1(0,-14.1) V2(0.8,-14.1) V3(1.6,-14.1) V4(2.4,-14.1) V5(3.2,-14.1) V6(4.05,-14.1) V7(4.9,-14.1) V8(5.7,-14.1) V27(21.7,-14.1) V28(22.5,-14.1) V29(23.35,-14.1) V30(24.2,-14.1) V31(25,-14.1) V32(25.8,-14.1) V33(26.6,-14.1) V34(27.4,-14.1) W2(0.8,-14.95) W3(1.6,-14.95) W4(2.4,-14.95) W5(3.2,-14.95) W7(4.9,-14.95) W8(5.7,-14.95) W27(21.7,-14.95) W28(22.5,-14.95) W30(24.2,-14.95) W31(25,-14.95) W32(25.8,-14.95) W33(26.6,-14.95) Y1(0,-15.8) Y2(0.8,-15.8) Y3(1.6,-15.8) Y4(2.4,-15.8) Y5(3.2,-15.8) Y6(4.05,-15.8) Y7(4.9,-15.8) Y8(5.7,-15.8) Y27(21.7,-15.8) Y28(22.5,-15.8) Y29(23.35,-15.8) Y30(24.2,-15.8) Y31(25,-15.8) Y32(25.8,-15.8) Y33(26.6,-15.8) Y34(27.4,-15.8)
  round 0.406 smd: AA12(8.2,-17.2) AA13(9.2,-17.2) AA14(10.2,-17.2) AA15(11.2,-17.2) AA16(12.2,-17.2) AA17(13.2,-17.2) AA18(14.2,-17.2) AA19(15.2,-17.2) AA20(16.2,-17.2) AA21(17.2,-17.2) AA22(18.2,-17.2) AA23(19.2,-17.2) AB12(8.2,-18.2) AB13(9.2,-18.2) AB14(10.2,-18.2) AB15(11.2,-18.2) AB16(12.2,-18.2) AB17(13.2,-18.2) AB18(14.2,-18.2) AB19(15.2,-18.2) AB20(16.2,-18.2) AB21(17.2,-18.2) AB22(18.2,-18.2) AB23(19.2,-18.2) AC12(8.2,-19.2) AC13(9.2,-19.2) AC14(10.2,-19.2) AC15(11.2,-19.2) AC16(12.2,-19.2) AC17(13.2,-19.2) AC18(14.2,-19.2) AC19(15.2,-19.2) AC20(16.2,-19.2) AC21(17.2,-19.2) AC22(18.2,-19.2) AC23(19.2,-19.2) M12(8.2,-8.2) M13(9.2,-8.2) M14(10.2,-8.2) M15(11.2,-8.2) M16(12.2,-8.2) M17(13.2,-8.2) M18(14.2,-8.2) M19(15.2,-8.2) M20(16.2,-8.2) M21(17.2,-8.2) M22(18.2,-8.2) M23(19.2,-8.2) N12(8.2,-9.2) N13(9.2,-9.2) N14(10.2,-9.2) N15(11.2,-9.2) N16(12.2,-9.2) N17(13.2,-9.2) N18(14.2,-9.2) N19(15.2,-9.2) N20(16.2,-9.2) N21(17.2,-9.2) N22(18.2,-9.2) N23(19.2,-9.2) P12(8.2,-10.2) P13(9.2,-10.2) P14(10.2,-10.2) P15(11.2,-10.2) P16(12.2,-10.2) P17(13.2,-10.2) P18(14.2,-10.2) P19(15.2,-10.2) P20(16.2,-10.2) P21(17.2,-10.2) P22(18.2,-10.2) P23(19.2,-10.2) R12(8.2,-11.2) R13(9.2,-11.2) R14(10.2,-11.2) R15(11.2,-11.2) R16(12.2,-11.2) R17(13.2,-11.2) R18(14.2,-11.2) R19(15.2,-11.2) R20(16.2,-11.2) R21(17.2,-11.2) R22(18.2,-11.2) R23(19.2,-11.2) T12(8.2,-12.2) T13(9.2,-12.2) T14(10.2,-12.2) T15(11.2,-12.2) T16(12.2,-12.2) T17(13.2,-12.2) T18(14.2,-12.2) T19(15.2,-12.2) T20(16.2,-12.2) T21(17.2,-12.2) T22(18.2,-12.2) T23(19.2,-12.2) U12(8.2,-13.2) U13(9.2,-13.2) U14(10.2,-13.2) U15(11.2,-13.2) U16(12.2,-13.2) U17(13.2,-13.2) U18(14.2,-13.2) U19(15.2,-13.2) U20(16.2,-13.2) U21(17.2,-13.2) U22(18.2,-13.2) U23(19.2,-13.2) V12(8.2,-14.2) V13(9.2,-14.2) V14(10.2,-14.2) V15(11.2,-14.2) V16(12.2,-14.2) V17(13.2,-14.2) V18(14.2,-14.2) V19(15.2,-14.2) V20(16.2,-14.2) V21(17.2,-14.2) V22(18.2,-14.2) V23(19.2,-14.2) W12(8.2,-15.2) W13(9.2,-15.2) W14(10.2,-15.2) W15(11.2,-15.2) W16(12.2,-15.2) W17(13.2,-15.2) W18(14.2,-15.2) W19(15.2,-15.2) W20(16.2,-15.2) W21(17.2,-15.2) W22(18.2,-15.2) W23(19.2,-15.2) Y12(8.2,-16.2) Y13(9.2,-16.2) Y14(10.2,-16.2) Y15(11.2,-16.2) Y16(12.2,-16.2) Y17(13.2,-16.2) Y18(14.2,-16.2) Y19(15.2,-16.2) Y20(16.2,-16.2) Y21(17.2,-16.2) Y22(18.2,-16.2) Y23(19.2,-16.2)
NCT3705U-A_SOT23-5
  oval 0.508x0.965 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0,2.35)
NEC_MPC0740LR42C_2P
  rect 2.692x2.591 smd: 1(0,0) 2(6.2,0)
PANAS_ETQP3W1R5WFN_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PJDLC05_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PJDLC05C_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS8201ATQFN40GTR2A0_TQFN40_5X5
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.975) 22(3.2,4.975) 23(2.8,4.975) 24(2.4,4.975) 25(2,4.975) 26(1.6,4.975) 27(1.2,4.975) 28(0.8,4.975) 29(0.4,4.975) 30(0,4.975)
  oval 1.016x0.203 smd: 11(4.288,0.688) 12(4.288,1.088) 13(4.288,1.488) 14(4.288,1.888) 15(4.288,2.288) 16(4.288,2.688) 17(4.288,3.088) 18(4.288,3.488) 19(4.288,3.888) 20(4.288,4.288) 31(-0.688,4.288) 32(-0.688,3.888) 33(-0.688,3.488) 34(-0.688,3.088) 35(-0.688,2.688) 36(-0.688,2.288) 37(-0.688,1.888) 38(-0.688,1.488) 39(-0.688,1.088) 40(-0.688,0.688)
  rect 3.607x3.607 smd: 41(1.8,2.488)
PS8330BQFN48GTR-A0_QFN48_7X7
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,6.95) 26(5,6.95) 27(4.5,6.95) 28(4,6.95) 29(3.5,6.95) 30(3,6.95) 31(2.5,6.95) 32(2,6.95) 33(1.5,6.95) 34(1,6.95) 35(0.5,6.95) 36(0,6.95)
  oval 1.041x0.254 smd: 13(6.225,0.725) 14(6.225,1.225) 15(6.225,1.725) 16(6.225,2.225) 17(6.225,2.725) 18(6.225,3.225) 19(6.225,3.725) 20(6.225,4.225) 21(6.225,4.725) 22(6.225,5.225) 23(6.225,5.725) 24(6.225,6.225) 37(-0.725,6.225) 38(-0.725,5.725) 39(-0.725,5.225) 40(-0.725,4.725) 41(-0.725,4.225) 42(-0.725,3.725) 43(-0.725,3.225) 44(-0.725,2.725) 45(-0.725,2.225) 46(-0.725,1.725) 47(-0.725,1.225) 48(-0.725,0.725)
  rect 3.708x3.708 smd: 49(2.75,3.475)
PS8520BTQFN20GTR2_TQFN20_4X4
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.8) 12(1.5,3.8) 13(1,3.8) 14(0.5,3.8) 15(0,3.8)
  oval 1.194x0.254 smd: 6(2.9,0.9) 7(2.9,1.4) 8(2.9,1.9) 9(2.9,2.4) 10(2.9,2.9) 16(-0.9,2.9) 17(-0.9,2.4) 18(-0.9,1.9) 19(-0.9,1.4) 20(-0.9,0.9)
  rect 2.108x2.108 smd: 21(1,1.9)
PS8723BTQFN32GTR-A0_TQFN32_3X6
  oval 0.203x0.965 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 17(4,3.025) 18(3.6,3.025) 19(3.2,3.025) 20(2.8,3.025) 21(2.4,3.025) 22(2,3.025) 23(1.6,3.025) 24(1.2,3.025) 25(0.8,3.025) 26(0.4,3.025) 27(0,3.025)
  oval 0.991x0.203 smd: 12(5,0.713) 13(5,1.113) 14(5,1.513) 15(5,1.913) 16(5,2.313) 28(-1,2.313) 29(-1,1.913) 30(-1,1.513) 31(-1,1.113) 32(-1,0.713)
  rect 4.597x1.803 smd: 33(2,1.513)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_2512_4P
  custom 0.826x0.826 smd: 1(0,0) 4(0,-8.687)
  rect 0.508x3.2 smd: 2(0,-2.108) 3(0,-6.579)
RB751V40_SC76-2
  rect 0.61x0.61 smd: 1(0,0) 2(2.2,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8237EZQW-2_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
RT8813AGQW_WQFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.515x2.515 smd: 25(1.25,1.975)
RT9610BZQW_WDFN8_2X2
  oval 0.254x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.15) 6(1,2.15) 7(0.5,2.15) 8(0,2.15)
  rect 1.118x0.533 smd: 9(0.75,1.075)
SAMTE_BSH-030-01-L-D-A-TR_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3456DDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI3457BDV-T1-E3_TSOP6
  oval 0.508x1.448 smd: 1(0,0) 2(1,0) 3(2,0) 4(2,2.425) 5(1,2.425) 6(0,2.425)
SI3457CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI4634DY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SINGA_2SJ3095-001111F_6P-T
  oval 1.016x1.905 hole 0.61x1.499: 1(0,0) 2(-9.55,5.5) 3(0,7.8) 4(-9.55,8.4) 5(-9.55,0) 6(-9.55,2.75)
  oval 1.372x2.261 hole 0.61x1.499: 7(0,4.1)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SN74LVC1G06DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SN74LVC1G07DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SW_NTC311-EA1T-A160T_4P
  rect 1.651x1.041 smd: 1(0,0) 2(3.85,0)
  rect 1.651x1.041 hole 0.66: 3(-0.1,-1.525) 4(3.95,-1.525)
SW_TML-3WWW-Q-T-R_6P
  round 0.991 hole 0.991 unplated: (2.288,0)
  rect 1.499x1.397 smd: 1(0,0) 2(7.8,0)
  rect 1.778x0.991 smd: 3(2.288,2) 4(2.288,-2) 5(5.513,2) 6(5.513,-2)
SX34H_SMA2
  rect 2.057x2.057 smd: 1(0,0) 2(3.73,0)
TAI-T_HCB2012KF-121T50_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAIWI_USB019-107CRL-TWD_10P-T
  round 1.219 hole 0.914: 1(0,0)
  round 1.321 hole 0.914: 2(2.5,0) 3(4.5,0) 4(7,0) 5(7.5,1.5) 6(5.5,1.5) 7(3.5,1.5) 8(1.5,1.5) 9(-0.5,1.5)
  round 1.067 hole 0.762: 10(-1.37,0)
  oval 1.372x2.667 hole 0.61x1.905: 11(-2.9,-0.39) 12(-4.4,-10.98) 13(11.4,-10.98) 14(9.9,-0.39)
TAIYO_NRH3010T4R7MN_2P
  rect 0.787x2.692 smd: 1(0,0) 2(2.2,0)
TOKO_FDSD0630-H-1R0M-P3_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TOKO_FDSD0630-H-3R3M-P3_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TOKO_FDUE1040J-H-R36M-P3_4P
  custom 0.876x0.876 smd: 1(0,0) 4(13.411,0)
  rect 2.032x0.508 smd: 2(2.489,0) 3(10.922,0)
TPA3113D2PWPR_HTSSOP28
  oval 0.305x1.6 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(6.5,0) 12(7.15,0) 13(7.8,0) 14(8.45,0) 15(8.45,5.6) 16(7.8,5.6) 17(7.15,5.6) 18(6.5,5.6) 19(5.85,5.6) 20(5.2,5.6) 21(4.55,5.6) 22(3.9,5.6) 23(3.25,5.6) 24(2.6,5.6) 25(1.95,5.6) 26(1.3,5.6) 27(0.65,5.6) 28(0,5.6)
  rect 6.172x2.388 smd: 29(4.225,2.8)
TPC12
  round 0.305 smd: 1(0,0)
TPS2543RTER_QFN16_3X3
  oval 0.254x1.016 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,2.975) 10(1,2.975) 11(0.5,2.975) 12(0,2.975)
  oval 1.016x0.254 smd: 5(2.238,0.738) 6(2.238,1.238) 7(2.238,1.738) 8(2.238,2.238) 13(-0.738,2.238) 14(-0.738,1.738) 15(-0.738,1.238) 16(-0.738,0.738)
  rect 1.702x1.702 smd: 17(0.75,1.488)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TPS51367RVER_QFN28_4P5X3P5
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 15(3.2,3.6) 16(2.8,3.6) 17(2.4,3.6) 18(2,3.6) 19(1.6,3.6) 20(1.2,3.6) 21(0.8,3.6) 22(0.4,3.6) 23(0,3.6)
  oval 0.889x0.203 smd: 10(3.9,1) 11(3.9,1.4) 12(3.9,1.8) 13(3.9,2.2) 14(3.9,2.6) 24(-0.7,2.6) 25(-0.7,2.2) 26(-0.7,1.8) 27(-0.7,1.4) 28(-0.7,1)
  rect 3.099x2.108 smd: 29(1.6,1.8)
unnamed#2
  round 5.994 hole 5.994 unplated: (0,0)
W25Q64FVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25X20AVSNIG_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
Y_FC-135_2P
  rect 0.66x1.295 smd: 1(0,0) 2(2.35,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_X3G025000DA1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
1.35V_B+: PC400.1 PC401.1 PC402.1 PC403.1 PJP400.2 PQ400.5 PR406.1
1.35V_FB: PC412.1 PR405.1 PR408.1 PU400.6
3.3VS_GFX_EN: CZ7.1 QZ1.3 QZ2.3 RZ5.1 RZ8.2
3.3VS_GFX_ON#: QZ2.5 QZ2.6 QZ5.5 QZ17.2 QZ17.5 RZ3.2
3VA_EN: CE322.1 DE303.1 DE304.2 DE305.1 DE306.2 PR340.1
5VA_EN: PR341.2 UE1.B2
+0.675VS: CD17.1 CD18.1 CD19.1 CD20.1 CD39.1 CD40.1 CD41.1 CD42.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJP402.2
+0.675VSP: PC405.1 PC406.1 PJP402.1 PU400.2 PU400.20
+1.2V_5505SWR: CA63.1 CA64.2 CA66.1 CA78.2 CA80.1 CA81.1 CA82.2 CA83.1 CA84.2 LA3.2 U12.1 U12.15 U12.25 U12.37
+1.2V_5505SWR_S: LA3.1 U12.13
+1.5V_RUN_B+: PC600.1 PC601.1 PC603.1 PC610.1 PC620.1 PC621.1 PJP600.2 PU600.15 PU600.16 PU600.17
+1.5V_VSNS: PC611.2 PC612.2 PC613.2 PJP601.1 PJP602.1 PL600.2 PU600.22
+1.05VM_VCCASW: CH65.1 CH69.1 CH70.1 JP19.1 U7.AA18 U7.U18 U7.U20 U7.U22 U7.U24 U7.V18 U7.V20 U7.V22 U7.V24 U7.Y18 U7.Y20 U7.Y22
+1.05VM_VCCSUS1: CH94.1 RH220.1 U7.Y12
+1.05VM_VCCSUS2: CH86.1 RH219.2 U7.Y35
+1.5VS: CV744.1 CV756.1 CV772.1 CV774.1 CV775.1 JP11.2 R56.2 RH21.2 RH28.2 RH99.1 RH113.1 U7.AM45 U7.AW40 U7.BD4 U7.BE16 U7.BE30 U22.12 U22.19 U22.20 U22.31 U22.40
+1.5VS_G9141: CZ601.1 JP11.1 RZ600.1 UZ600.3
+1.05VS_VCCCORE: CH35.1 CH36.1 CH37.1 CH38.1 JP2.1 U7.AA24 U7.AA26 U7.AD20 U7.AD22 U7.AD24 U7.AD26 U7.AD28 U7.AE18 U7.AE20 U7.AE22 U7.AE24 U7.AE26 U7.AG18 U7.AG20 U7.AG22 U7.AG24 U7.Y26
+1.5VSDGPU: CV587.1 CV588.1 CV589.1 CV590.1 CV591.1 CV592.1 CV593.1 CV594.1 CV602.1 CV603.1 CV604.1 CV605.1 CV606.1 CV607.1 CV608.1 CV609.1 CV652.1 CV653.1 CV654.1 CV655.1 CV656.1 CV657.1 CV658.1 CV659.1 CV660.1 CV661.1 CV662.1 CV663.1 CV677.1 CV678.1 CV679.1 CV680.1 CV681.1 CV682.1 CV683.1 CV684.1 CV685.1 CV686.1 CV687.1 CV688.1 CV702.1 CV703.1 CV704.1 CV705.1 CV706.1 CV707.1 CV708.1 CV709.1 CV710.1 CV711.1 CV712.1 CV713.1 CV727.1 CV728.1 CV729.1 CV730.1 CV731.1 CV732.1 CV733.1 CV734.1 CV735.1 CV736.1 CV737.1 CV738.1 PJP601.2 PJP602.2 RV327.2 RV332.2 RV338.2 RV339.2 RV342.1 RV344.1 RV345.1 RV346.1 RV347.1 RV358.1 RV360.1 RV371.1 RV373.1 RV384.1 RV386.1 RV397.1 RV399.1 RV409.2 RV410.2 RZ10.1 UV1.AA27 UV1.AA30 UV1.AB27 UV1.AB33 UV1.AC27 UV1.AD27 UV1.AE27 UV1.AF27 UV1.AG27 UV1.B13 UV1.B16 UV1.B19 UV1.E13 UV1.E16 UV1.E19 UV1.H8 UV1.H9 UV1.H10 UV1.H11 UV1.H12 UV1.H13 UV1.H14 UV1.H15 UV1.H16 UV1.H18 UV1.H19 UV1.H20 UV1.H21 UV1.H22 UV1.H23 UV1.H24 UV1.L27 UV1.M27 UV1.N27 UV1.P27 UV1.R27 UV1.T27 UV1.T30 UV1.T33 UV1.V27 UV1.W27 UV1.W30 UV1.W33 UV1.Y27 UV5.B1 UV5.B3 UV5.B12 UV5.B14 UV5.C5 UV5.C10 UV5.D1 UV5.D3 UV5.D11 UV5.D12 UV5.D14 UV5.E5 UV5.E10 UV5.F1 UV5.F3 UV5.F12 UV5.F14 UV5.G1 UV5.G2 UV5.G4 UV5.G11 UV5.G13 UV5.G14 UV5.H3 UV5.H12 UV5.K3 UV5.K12 UV5.L1 UV5.L2 UV5.L4 UV5.L11 UV5.L13 UV5.L14 UV5.M1 UV5.M3 UV5.M12 UV5.M14 UV5.N5 UV5.N10 UV5.P1 UV5.P3 UV5.P11 UV5.P12 UV5.P14 UV5.R5 UV5.R10 UV5.T1 UV5.T3 UV5.T12 UV5.T14 UV6.B1 UV6.B3 UV6.B12 UV6.B14 UV6.C5 UV6.C10 UV6.D1 UV6.D3 UV6.D11 UV6.D12 UV6.D14 UV6.E5 UV6.E10 UV6.F1 UV6.F3 UV6.F12 UV6.F14 UV6.G1 UV6.G2 UV6.G4 UV6.G11 UV6.G13 UV6.G14 UV6.H3 UV6.H12 UV6.K3 UV6.K12 UV6.L1 UV6.L2 UV6.L4 UV6.L11 UV6.L13 UV6.L14 UV6.M1 UV6.M3 UV6.M12 UV6.M14 UV6.N5 UV6.N10 UV6.P1 UV6.P3 UV6.P11 UV6.P12 UV6.P14 UV6.R5 UV6.R10 UV6.T1 UV6.T3 UV6.T12 UV6.T14 UV9.B1 UV9.B3 UV9.B12 UV9.B14 UV9.C5 UV9.C10 UV9.D1 UV9.D3 UV9.D11 UV9.D12 UV9.D14 UV9.E5 UV9.E10 UV9.F1 UV9.F3 UV9.F12 UV9.F14 UV9.G1 UV9.G2 UV9.G4 UV9.G11 UV9.G13 UV9.G14 UV9.H3 UV9.H12 UV9.K3 UV9.K12 UV9.L1 UV9.L2 UV9.L4 UV9.L11 UV9.L13 UV9.L14 UV9.M1 UV9.M3 UV9.M12 UV9.M14 UV9.N5 UV9.N10 UV9.P1 UV9.P3 UV9.P11 UV9.P12 UV9.P14 UV9.R5 UV9.R10 UV9.T1 UV9.T3 UV9.T12 UV9.T14 UV10.B1 UV10.B3 UV10.B12 UV10.B14 UV10.C5 UV10.C10 UV10.D1 UV10.D3 UV10.D11 UV10.D12 UV10.D14 UV10.E5 UV10.E10 UV10.F1 UV10.F3 UV10.F12 UV10.F14 UV10.G1 UV10.G2 UV10.G4 UV10.G11 UV10.G13 UV10.G14 UV10.H3 UV10.H12 UV10.K3 UV10.K12 UV10.L1 UV10.L2 UV10.L4 UV10.L11 UV10.L13 UV10.L14 UV10.M1 UV10.M3 UV10.M12 UV10.M14 UV10.N5 UV10.N10 UV10.P1 UV10.P3 UV10.P11 UV10.P12 UV10.P14 UV10.R5 UV10.R10 UV10.T1 UV10.T3 UV10.T12 UV10.T14
+1.05VSDGPU: CV580.1 CV581.1 CV582.1 CV583.1 CV584.1 CV585.1 CV586.1 CV595.1 CV596.1 CV597.1 CV598.1 CV599.1 CV600.1 CV601.1 CV613.1 CV3512.1 LV2.2 LV3.1 LV14.2 LV21.1 RZ11.1 UV1.AG13 UV1.AG15 UV1.AG16 UV1.AG18 UV1.AG19 UV1.AG21 UV1.AG22 UV1.AG24 UV1.AG25 UV1.AH15 UV1.AH18 UV1.AH21 UV1.AH25 UV1.AH26 UV1.AH27 UV1.AJ27 UV1.AK27 UV1.AL27 UV1.AM28 UV1.AN28 UZ1.1 UZ1.2 UZ1.3
+1.35V: CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD25.1 CD26.1 CD27.1 CD28.1 CD30.1 CD31.1 CD32.1 CD33.1 CD34.1 CD35.1 CU177.1 CU178.1 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JP3.1 JP4.1 PJP403.2 PJP404.2 RU72.1
