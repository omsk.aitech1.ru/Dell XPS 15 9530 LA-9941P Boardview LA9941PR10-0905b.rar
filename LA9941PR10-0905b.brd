# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PM_DRAM_PWRGD: length 260.5
  IN1 w0.076: v1(133.26,74.1) 132.43,74.1 130.2,76.33 130.2,91.23 131.56,92.59 132.02,92.59 132.69,93.26 132.69,95.61 133.79,96.71 v1(133.79,97.26) ; v4(252.62,17.6) 252.62,17.53 251.6,18.54 251.6,18.98 246.82,23.76 246.82,28.49 245.98,29.33 245.98,34.79 245.4,35.36 245.4,38.13 246.07,38.81 246.07,39.57 233.87,51.77 233.87,53.72 v4(234.28,54.13) ; v1(135.67,113.25) 134.87,113.25 v1(132.56,110.94)
  IN3 w0.13: v1(135.67,113.25) 135.67,113.32 136.08,113.72 137.15,113.72 138.02,112.85 140.99,112.85 141.94,111.9 154.31,111.9 156.03,110.18 163.3,110.18 164,109.48 177.41,109.48 178.37,108.52 178.37,107.91 182.36,103.93 182.36,100.62 184.59,98.38 184.59,88.77 187.88,85.48 187.88,72.86 188.7,72.04 206.66,72.04 209.52,69.17 210.36,69.17 211.36,68.17 211.36,67.04 214.95,63.46 214.95,62.8 219.73,58.02 220.38,58.02 224.21,54.19 234.21,54.19 v4(234.28,54.13)
  IN4 w0.076: v6(271.97,21.79) 270.98,20.8 267.86,20.8 267.78,20.71 265.11,20.71 264.81,20.41 264.52,20.41 ; 263.68,19.66 263.5,19.48 263.01,19.48 262.37,18.84 262.18,18.84 261.24,17.89 254.98,17.89 254.4,17.31 252.91,17.31 v4(252.62,17.6)
  IN4 w0.089: 263.68,19.66 264.43,20.41 264.52,20.41
  GND3 w0.089: v6(271.97,21.79) 271.97,22.17 v7(271.96,22.18)
  BOTTOM w0.089: v7(271.96,22.18) 271.9,22.23 U7.H3
  BOTTOM w0.102: v1(133.79,97.26) 133.59,97.47 133.59,101.68 134.63,102.73 134.63,104.51 134.15,105 v2(134.15,109.43) 134.15,109.74 132.94,110.94 v1(132.56,110.94) ; RU51.1 130.79,71.63 v1(133.26,74.1)
PM_SLP_A#: length 9.3
  BOTTOM w0.089: 277.24,19.66 276.7,20.21 273.96,20.21 272.99,21.18 272.99,21.93 272.76,22.16 U7.F3
  BOTTOM w0.102: 277.24,19.66 278.5,18.41 278.97,18.41 T37.1
PM_SLP_S3#: length 465.8
  TOP w0.076: UE1.J5 165.9,16.66 165.97,16.59
  TOP w0.089: v3(166.65,16.49) 166.56,16.41 166.15,16.41 165.97,16.59
  TOP w0.102: v1(36.08,41.49) 36.71,40.85 36.71,32.57 v1(37.15,32.14) ; v1(226.82,67.44) 225.42,67.44 225.17,67.19 225.17,66.11 223.52,64.46 223.52,50.55 224.53,49.54 230.19,49.54 233.98,45.74 233.98,28.73 233.71,28.45 233.71,24.38 230.63,21.3 230.63,21.26 v1(228.19,18.82) 228.19,13.33 v1(228.46,13.06) ; v3(170.61,15.06) 170.66,15.01 T44.1 172.62,15.01 172.92,14.72 v1(172.92,14.52) ; PR409.1 120.74,18.04 v1(120.66,17.97)
  GND1 w0.089: v4(166.27,16.04) 166.27,16.11 v3(166.65,16.49)
  GND1 w0.102: v4(170.93,14.66) 170.93,14.66 170.61,14.98 v3(170.61,15.06)
  IN1 w0.102: v4(120.23,24.04) 120.48,23.78 120.48,21.29 120.66,21.12 v1(120.66,17.97)
  IN2 w0.089: 270.86,19.66 v4(272.35,21.15)
  IN2 w0.102: v1(172.92,14.52) 174.45,16.05 187.24,16.05 187.51,16.31 198.64,16.31 199.61,17.29 207.58,17.29 207.96,16.91 211.32,16.91 213.57,19.16 220.97,19.16 222.03,18.09 224.68,18.09 224.89,18.3 227.68,18.3 v1(228.19,18.82) 230.12,18.82 232.14,16.79 248.05,16.79 249.32,15.51 251.93,15.51 252.13,15.72 255.25,15.72 255.79,16.26 259.73,16.26 260.05,15.93 270.4,15.93 271.09,16.62 271.09,17 270.49,17.6 270.49,19.29 270.86,19.66 ; v4(120.23,24.04) 120,23.81 108.07,23.81 99.43,32.44 86.75,32.44 85.88,33.31 82.33,33.31 82.02,33.62 65.88,33.62 64.12,35.38 v1(64.12,35.67) ; v1(120.66,17.97) 119.71,18.92 116.56,18.92 115.94,19.53 107.42,19.53 100.96,25.99 96.61,25.99 96.4,25.79 93.41,25.79 91.41,27.78 83.07,27.78 82.86,27.57 74.73,27.57 73.39,28.91 65.11,28.91 63.03,31 63.03,32.98 62.72,33.28 58.2,33.28 57.34,34.15 52.94,34.15 52.27,34.82 44.65,34.82 43.34,33.52 43.34,33.23 42.41,32.29 37.3,32.29 v1(37.15,32.14)
  IN3 w0.076: 168.78,15.31 168.03,15.31 167.26,16.09 166.32,16.09 v4(166.27,16.04)
  IN3 w0.102: v1(120.66,17.97) 120.66,17.97 121.04,18.35 123.82,18.35 124.53,19.06 126.46,19.06 127.04,18.48 128.23,18.48 128.64,18.88 140.29,18.88 143.16,16.01 144.58,16.01 144.92,16.35 146.15,16.35 146.58,15.92 146.58,15.64 146.95,15.26 148.5,15.26 149.09,15.86 153.02,15.86 155.25,13.63 158.21,13.63 158.89,14.31 161.44,14.31 163.19,12.56 165.2,12.56 165.8,13.17 166.68,13.17 167.28,12.56 170.96,12.56 v1(172.92,14.52) ; v4(170.93,14.66) 170.43,15.16 169.68,15.16 169.53,15.31 168.78,15.31 ; v4(244.96,9.89) 245.34,10.27 245.34,11.69 243.24,13.8 235.28,13.8 234.55,13.06 v1(228.46,13.06)
  IN4 w0.102: v6(261.02,10.37) 261.02,10.56 260.67,10.9 258.87,10.9 258.7,10.74 256.43,10.74 256.02,10.32 256.02,10.17 255.73,9.88 252.91,9.88 252.01,10.78 250.23,10.78 249.91,10.46 249.23,10.46 248.84,10.85 247.64,10.85 246.68,9.89 v4(244.96,9.89)
  GND3 w0.089: v7(271.9,21.22) 272.28,21.22 v4(272.35,21.15)
  GND3 w0.102: v6(261.02,10.37) 261.05,10.35 261.55,10.35 v7(261.68,10.22)
  BOTTOM w0.089: U7.H1 v7(271.9,21.22)
  BOTTOM w0.102: RN42.1 39.48,30.68 RN30.1 37.76,31 37.45,31.3 37.45,31.99 37.3,32.14 v1(37.15,32.14) ; UN3.3 64.25,35.06 64.12,35.19 v1(64.12,35.67) ; UZ4.5 35.86,41.71 v1(36.08,41.49) 36.59,41.49 36.79,41.69 36.79,42.22 36.66,42.36 UZ4.3 ; JTB1.48 261.7,10.2 v7(261.68,10.22) ; v1(226.82,67.44) 227.14,67.76 PR503.1
PM_SLP_S4#: length 183.1
  TOP w0.076: UE1.N1 167.79,14.66 v3(168.08,14.37) 168.6,13.86 168.78,13.86
  TOP w0.102: T42.1 169.63,13.96 169.53,13.86 168.78,13.86
  TOP w0.254: PR407.1 120.99,17.43 120.43,17.43 120.17,17.7 120.17,19.33 119.75,19.75 119.75,22.84 v1(120.92,24.01)
  GND1 w0.089: v4(168.51,14.37) v3(168.08,14.37)
  IN2 w0.076: v4(168.51,14.37) 167.78,14.37 167.03,15.12 164.6,15.12 164.2,15.52 164.2,15.93 164.07,16.06 163.02,16.06 162.89,15.93 162.04,15.93 161.67,16.3 160.65,16.3
  IN2 w0.089: v4(273.68,23.19) 273.88,22.99 273.88,20.98 273.51,20.61 273.51,19.66
  IN2 w0.102: 273.51,19.66 273.51,17.69 272.05,16.23 271.5,16.23 270.8,15.53 259.87,15.53 259.55,15.85 255.99,15.85 255.45,15.31 252.3,15.31 252.1,15.11 244.02,15.11 243.1,16.04 241.49,16.04 241.3,15.85 237.42,15.85 236.69,16.58 222.96,16.58 220.59,18.96 213.66,18.96 211.41,16.71 207.96,16.71 207.73,16.47 205.45,16.47 205.14,16.78 203.24,16.78 202.92,16.45 202.56,16.45 201.99,17.03 199.64,17.03 198.72,16.11 187.59,16.11 187.33,15.85 185.23,15.85 183.47,14.09 172.14,14.09 171.16,15.07 170.76,15.07 170.37,14.68 168.82,14.68 v4(168.51,14.37) ; v1(120.92,24.01) 121.2,24.3 131.42,24.3 131.92,24.8 133.2,24.8 133.61,24.39 146.26,24.39 146.98,23.68 150.37,23.68 150.92,23.12 150.92,22.01 152.4,20.53 153.56,20.53 155.77,18.32 156.49,18.32 158.5,16.3 160.65,16.3
  GND3 w0.089: v4(273.68,23.19) 273.79,23.29 v7(274.16,23.29)
  BOTTOM w0.089: v7(274.16,23.29) 274.1,23.35 U7.C6
PM_SLP_S5#: length 108.6
  TOP w0.089: 168.34,18.64 167.8,18.64 UE1.N9
  TOP w0.102: v1(171.17,21.04) 171.17,19.89 T41.1 170.11,18.83 168.77,18.83 168.58,18.64 168.34,18.64
  IN2 w0.089: 262.46,19.66 265.32,22.52 265.32,22.81 266.19,23.69 267.25,23.69 v1(267.58,24.01)
  IN2 w0.102: 262.46,19.66 262.19,19.39 254.18,19.39 253.35,20.22 250.64,20.22 250.15,20.71 237.65,20.71 234.71,23.65 234.11,23.65 233.48,23.02 229.77,23.02 229.29,23.5 228.22,23.5 227.72,23.01 203.9,23.01 203.03,22.13 199.02,22.13 197.51,20.62 193.42,20.62 192.32,19.52 172.69,19.52 v1(171.17,21.04)
  BOTTOM w0.102: U7.Y7 267.41,24.19 v1(267.58,24.01)
PM_SLP_SUS#: length 142.5
  TOP w0.089: UE1.F2 164.03,14.91 164.03,14.2 164.21,14.02 164.21,13.69
  TOP w0.102: T40.1 163.84,12.99 163.98,13.14 v3(163.98,13.29) 163.98,13.46 164.21,13.69
  GND1 w0.102: v5(163.96,12.88) 163.98,12.9 v3(163.98,13.29)
  IN1 w0.102: v5(163.96,12.88) 163.96,13.41 163.67,13.7 163.67,13.99 163.88,14.2 164.44,14.2 164.6,14.04 165.39,14.04 166.1,13.33 166.8,13.33 167.12,13.01 168.41,13.01 168.83,13.43 170.13,13.43 170.24,13.31 v4(171.11,13.31)
  IN2 w0.102: v4(171.11,13.31) 171.27,13.31 171.85,13.89 183.56,13.89 185.32,15.64 187.41,15.64 187.68,15.91 198.97,15.91 199.2,16.14 201.57,16.14 201.89,15.82 202.57,15.82 203.32,16.57 205.06,16.57 205.36,16.27 207.81,16.27 208.05,16.5 211.49,16.5 213.74,18.75 220.34,18.75 224.61,14.49 225.82,14.49 v1(226.41,13.89) 227.71,15.19 241.47,15.19 241.99,14.66 243.61,14.66 243.77,14.5 254.18,14.5 255.11,13.57 258.62,13.57 258.85,13.8 259.83,13.8 260.71,14.68 263.44,14.68 265.09,13.04 266.62,13.04 267,13.41 270.93,13.41 271.37,12.97 274.23,12.97 v4(274.46,12.73)
  GND3 w0.102: v4(274.46,12.73) 275.01,12.73 v7(275.12,12.84)
  BOTTOM w0.089: U7.F1 272.64,21.15 273.91,19.88 276.64,19.88 276.85,19.66
  BOTTOM w0.102: v7(275.12,12.84) v2(275.66,12.84) 278.34,15.53 278.34,18.17 276.85,19.66 ; v1(226.41,13.89) 226.41,12.29 RZ30.1 225.69,11.57 UZ14.3
PM_SYS_PWRGD_BUF: length 7.9
  BOTTOM w0.102: QU7.1 136.88,68.56 137.41,69.1 RU43.1 137.41,69.74 RU60.2 R59.1 134.72,69.35 v2(135.31,68.76) 135.37,68.7 135.37,68.54 135.26,68.43 UU3.4
PM_SYS_PWRGD_BUF_R: length 40.7
  TOP w0.089: v8(147.92,81.57) 148.39,82.04 v1(148.44,82.04)
  IN4 w0.076: v1(133.89,74.13) 135.25,75.48 135.25,82.16 138.44,85.36 138.44,87.56 138.62,87.74 140.12,87.74 140.84,88.46 141.83,88.46 142.17,88.12
  IN4 w0.089: v1(148.44,82.04) 147.94,82.54 147.94,87.89 147.71,88.12 142.17,88.12
  BOTTOM w0.089: v1(148.44,82.04) 148.71,82.3 U6.AP48
  BOTTOM w0.102: v1(133.89,74.13) 136.87,74.13 138.3,72.69 RU56.2 RU43.2
POK: length 320.1
  TOP w0.254: v1(42.94,33.4) 43.05,33.29 PR337.1 ; PR112.1 111.52,14.36 PR110.2 110.72,14.35 110.42,14.64 v2(110.42,15.1) 110.42,15.49 v1(111.06,16.12)
  GND1 w0.102: v5(271.34,18.62) 271.34,18.28 v4(271.51,18.1)
  IN1 w0.076: 271.34,19.06 271.34,19.5 271.24,19.6 271.24,24.18 270.94,24.48 v1(270.94,26.24)
  IN1 w0.102: v5(271.34,18.62) 271.34,19.06
  IN2 w0.102: v4(156.96,11.77) 156.96,12.31 156.47,12.8 155.54,12.8 154.35,13.99 152.46,15.88 149.68,15.88 149.01,16.56 147.59,16.56 147.37,16.34 143.68,16.34 141.17,18.85 128.58,18.85 128.18,18.45 124.1,18.45 124,18.35 122.62,18.35 121.85,19.12 116.64,19.12 116.03,19.73 107.51,19.73 100.99,26.25 96.57,26.25 96.32,25.99 93.49,25.99 91.5,27.99 82.98,27.99 82.76,27.77 74.82,27.77 73.48,29.12 65.2,29.12 63.23,31.08 63.23,33.06 62.81,33.49 58.28,33.49 57.42,34.35 53.03,34.35 52.35,35.02 44.56,35.02 v1(42.94,33.4) ; v4(271.51,18.1) 271.42,18 271.42,16.43 270.71,15.73 259.96,15.73 259.63,16.05 255.87,16.05 255.34,15.51 252.22,15.51 252.02,15.31 244.11,15.31 243.18,16.24 238.69,16.24 v1(238.55,16.38)
  IN3 w0.102: v1(237.12,12.24) 236.75,12.24 236.34,12.65 234.82,12.65 233.4,11.23 221.3,11.23 217.1,15.42 214.37,15.42 211.98,13.03 211.98,12.68 210.77,11.48 191.22,11.48 190.25,12.44 173.98,12.44 172.99,11.46 158.59,11.46 157.9,12.15 157.34,12.15 v4(156.96,11.77) ; v1(111.06,16.12) 111.06,16.82 111.57,17.33 112.56,17.33 112.99,16.9 119.06,16.9 119.26,17.1 121.07,17.1 121.7,17.74 124.07,17.74 124.78,18.45 126.12,18.45 126.71,17.86 128.64,17.86 129.05,18.28 140.04,18.28 143.51,14.8 v4(143.51,14.12)
  IN4 w0.102: v4(156.96,11.77) 157.05,11.86 157.05,12.37 156.46,12.96 155.56,12.96 153.71,14.82 149.06,14.82 147.66,13.42 144.2,13.42 v4(143.51,14.12)
  BOTTOM w0.089: U7.L13 270.85,26.7 270.85,26.32 v1(270.94,26.24)
  BOTTOM w0.102: v1(237.12,12.24) 236.85,12.24 236.54,12.56 236.54,13.41 238.55,15.42 v1(238.55,16.38)
PP: length 3
  TOP w0.102: v2(198.19,15.41) R1.1 198.54,16.23 U1.7
PS_ID: length 136.3
  TOP w0.076: v3(166.64,17.42) 166.38,17.16 UE1.K6
  GND1 w0.076: v4(165.92,17.66) 166.17,17.42 v3(166.64,17.42)
  IN2 w0.076: v4(165.92,17.66) 165.77,17.81 165.77,18.23 165.42,18.59 164.87,18.59 163.94,19.51 163.94,19.95 162.69,21.2 160.65,21.2
  IN2 w0.102: v4(46.24,40.22) 46.79,40.22 47.63,39.38 49.86,39.38 51.13,38.11 53.91,38.11 54.85,37.17 60.55,37.17 60.96,36.76 65.08,36.76 66.03,35.8 68.5,35.8 69.87,34.44 82.5,34.44 82.81,34.12 86.22,34.12 87.05,33.29 99.77,33.29 107.41,25.66 133.21,25.66 133.86,25 146.52,25 147.23,24.29 150.62,24.29 151.53,23.38 151.53,22.26 152.59,21.2 160.65,21.2
  GND3 w0.102: v7(46.95,40.37) 46.8,40.22 v4(46.24,40.22)
  BOTTOM w0.102: v2(48.4,40.17) 48.4,40.44 47.9,40.94 PD100.1
  BOTTOM w0.254: PD100.1 47.51,40.93 v7(46.95,40.37) PR102.2 PR103.2
PSID: length 6.2
  TOP w0.102: v1(28.1,88.22) 28.1,88.2 v2(27.52,87.61)
  TOP w0.254: PL101.1 27.41,88.91 v1(28.1,88.22)
  BOTTOM w0.254: v1(28.1,88.22) 28.01,88.31 27.63,88.31 27.4,88.54 ADP100.4
PSID-1: length 4.9
  BOTTOM w0.102: PR106.1 v2(46.39,49.06)
  BOTTOM w0.254: PR104.2 45.71,45.3 46.45,46.04 PQ101.2 46.39,46.97 PR106.1
PSID-2: length 5
  BOTTOM w0.102: PQ101.1 48.03,45.01 v2(48.6,44.43)
  BOTTOM w0.254: PQ100.2 45.97,43.2 PR105.1 47.1,44.33 PQ101.1
PSID-3: length 2.7
  BOTTOM w0.254: PR101.2 PR103.1 45.01,40.27 PQ100.3
PWR_SRC_ON: length 8.9
  TOP w0.102: QV29.3 84.07,36.47 ; 84.07,36.47 84.56,36.96 86.23,36.96 86.74,37.47 86.74,37.55 CV751.2 RV412.2 88.58,38.06 v2(89.44,38.92) ; 84.07,36.47 84.15,36.39 84.15,35.69 RV413.1
PWRBTN_LED#: length 4.1
  TOP w0.089: v1(161.28,15.15) 161.78,15.65 UE1.A3
  BOTTOM w0.076: v1(161.28,15.15) 160.82,14.69 160.65,14.69
  BOTTOM w0.102: QZ20.2 159.17,14.52 159.35,14.69 v2(160.23,14.69) 160.65,14.69
PWRSHARE_OE#1: length 5.2
  BOTTOM w0.102: US1.9 24.41,54.94 24.32,55.02 23.99,55.02 23.85,54.88 RI19.2 21.45,55.56 v2(20.2,55.56)
PWRSHARE_OE#3: length 1.6
  TOP w0.102: RI30.2 18.55,78.16 US2.9
REF_+1.5V_RUNP: length 4.7
  TOP w0.102: v2(191.96,124.66) 192.29,124.33 PC605.2 193.09,123.71 193.65,124.26 ; 193.65,124.26 193.42,124.49 193.13,124.49 v1(192.9,124.26) ; 193.65,124.26 PR600.1
  BOTTOM w0.203: v1(192.9,124.26) 192.82,124.26 192.38,124.7 PU600.26
REGN: length 22.1
  TOP w0.254: v1(83.44,32.09) 83.44,27.23 PR224.2 81.98,25.77 81.98,23.88 80.96,22.87 78.67,22.87 76.45,25.1 v2(75.22,25.1) v1(74.33,25.1)
  BOTTOM w0.254: PR217.1 82.12,34.38 82.42,34.68 83.35,34.68 83.58,34.45 83.58,32.23 v1(83.44,32.09)
REXT_SATA: length 6.7
  BOTTOM w0.102: UN1.20 36.28,37.65 36.51,37.88 v2(39.13,37.88) 39.56,37.88 RN40.1 39.66,39.71 RN16.1
RF_+V1.05V: length 3.3
  BOTTOM w0.102: PR505.1 229.84,70.66 v2(230.39,71.2)
  BOTTOM w0.254: PU500.5 229.5,68.89 229.17,69.22 229.17,69.5 PR505.1
RI#: length 16.7
  TOP w0.102: v3(270.91,14.7) 272.25,14.7 272.81,15.26 273.76,15.26 v2(274.51,16.01) 274.79,16.29 RPH4.6
  GND1 w0.102: v3(270.91,14.7) 270.69,14.7 v5(270.47,14.92)
  IN1 w0.076: v1(270.51,23.29) 270.05,22.83 270.05,20.75 270.42,20.38 270.42,19.66
  IN1 w0.102: 270.42,19.66 270.42,18.48 270.3,18.36 270.3,17.8 271.05,17.06 271.05,15.49 v5(270.47,14.92)
  BOTTOM w0.089: v1(270.51,23.29) 270.21,22.99 U7.N4
RING2: length 27.9
  TOP w0.203: U15.31 20.89,41.59 20.71,41.77 20.54,41.77
  TOP w0.508: v1(17.69,45.35) 17.72,45.38 CA34.1
  IN2 w1.016: 15.17,45.96 15.17,45.6 16.83,43.95 17.11,43.95 ; 13.37,47.79 10.02,47.79 9.76,48.04 5.37,48.04 4.47,47.13 JHP2.3
  IN4 w1.016: JHP2.3 4.47,47.13 5.37,48.04 9.76,48.04 10.02,47.79 13.37,47.79 ; 15.15,45.91 15.15,45.63 16.9,43.87 17.11,43.87
  vias: v1(14.08,46.87) v1(14.64,46.62) v1(17.74,43.27) v1(18.33,43.27) v2(18.88,43.37)
ROM_CS_GPU: length 43
  TOP w0.102: v1(214.22,73.1) 214.71,73.1 v2(214.77,73.05)
  IN1 w0.102: v1(224.7,82.69) 224.3,82.69 222.64,81.03 222.64,78.85 221.73,77.94 221.73,75.42 222.21,74.94 v4(222.21,73.24)
  IN2 w0.102: v4(222.21,73.24) 221.82,73.63 214.75,73.63 v1(214.22,73.1)
  IN4 w0.102: v1(214.22,73.1) 213.78,73.55 212.9,73.55 209.47,70.11 209.47,66.2 206.73,63.45 v6(199.3,63.45)
  GND3 w0.102: v6(199.3,63.45) 198.81,63.45 v7(198.72,63.36)
  BOTTOM w0.089: UV1.H6 224.26,82.25 v1(224.7,82.69)
ROM_CS_GPU_R: length 4.2
  BOTTOM w0.102: U23.1 197.46,61.87 RV506.2 RV507.2 199.4,62.44 v2(199.71,62.75)
ROM_SCLK_GPU: length 41.2
  TOP w0.102: v2(224.59,74.24) 224.19,73.85 v3(223.58,73.85) RV313.2
  GND1 w0.102: v3(223.58,73.85) 223.71,73.85 v4(224.17,74.3)
  IN2 w0.102: v4(224.17,74.3) 223.69,73.82 222.66,73.82 222.45,74.03 210.14,74.03 207.86,71.75 196.59,71.75 v1(195.87,72.47)
  IN4 w0.102: v6(224.32,79.92) 224.32,74.45 v4(224.17,74.3)
  GND3 w0.089: v7(224.6,80.2) 224.6,80.2 v6(224.32,79.92)
  BOTTOM w0.102: UV1.H4 v7(224.6,80.2) ; v1(195.87,72.47) 194.98,71.58 RV509.1
ROM_SCLK_GPU_R: length 4.7
  BOTTOM w0.102: U23.6 194.92,70.04 RV509.2 195.2,70.1 195.59,70.49 195.59,71.36 v2(196.51,72.27)
ROM_SI_GPU: length 43.3
  TOP w0.102: RV312.2 v3(222.69,73.85) 221.61,73.85 v2(221.56,73.9)
  GND1 w0.102: v3(222.69,73.85) 223.2,74.35 v4(223.59,74.35)
  IN2 w0.102: v1(195.87,73.1) 197.02,71.95 207.77,71.95 210.06,74.24 223.47,74.24 v4(223.59,74.35)
  IN4 w0.102: v4(223.59,74.35) 223.38,74.56 223.38,79.76 v6(224.34,80.73)
  GND3 w0.089: v7(224.6,81) 224.6,80.98 v6(224.34,80.73)
  BOTTOM w0.102: v1(195.87,73.1) 195.24,72.47 195.16,72.47 RV508.1 ; UV1.H5 v7(224.6,81)
ROM_SI_GPU_R: length 3.2
  BOTTOM w0.102: U23.5 193.65,70.04 RV508.2 192.68,70.1 v2(192.44,70.34)
ROM_SO_GPU: length 50
  TOP w0.102: RV311.2 RV303.1 224.13,68.95 v1(224.66,69.48) 224.94,69.48 v2(225.53,68.89)
  IN2 w0.102: v1(224.66,69.48) 223.08,67.89 218.29,67.89 215.18,64.78 v1(196.57,64.78)
  IN4 w0.102: v1(224.66,69.48) 224.03,70.11 224.03,73.68 224.18,73.83 224.64,73.83 224.95,74.15 224.95,81.62 v6(224.27,82.3)
  GND3 w0.089: v6(224.27,82.3) 224.22,82.3 v7(223.85,82.67)
  BOTTOM w0.102: UV1.H7 224.2,83.1 223.85,82.75 v7(223.85,82.67) ; U23.2 196.19,64.4 v1(196.57,64.78)
S5_1.35V: length 1.6
  TOP w0.203: PU400.8 122.47,17.44 PR407.2
SATA_APRE0: length 3.4
  BOTTOM w0.102: RN6.1 RN3.1 33.92,31.58 v2(34.3,31.96) 34.3,32.09 34.78,32.57 UN1.9
SATA_APRE1: length 4.2
  BOTTOM w0.102: RN15.2 RN11.2 37.14,38.08 36.1,38.08 35.78,37.76 UN1.19
SATA_BPRE0: length 3.2
  BOTTOM w0.102: UN1.8 35.28,31.51 RN4.1 RN20.1
SATA_BPRE1: length 2.9
  BOTTOM w0.102: UN1.17 34.78,37.85 35.22,38.29 RN14.2 RN10.2
SATA_PRX_DTX_N0: length 238.2
  IN4 w0.089: v1(55.89,30.1) 56.46,30.1 57.14,29.42 57.67,29.42 58.33,30.09 62.09,30.09 62.43,29.75 66.93,29.75 67.51,29.17 71.54,29.17 73.71,27 83.18,27 83.92,27.73 90.42,27.73 93.23,24.92 96.76,24.92 97.73,25.9 102.07,25.9 109.92,18.04 112.44,18.04 113.25,17.23 123.21,17.23 124.42,18.44 125.85,18.44 126.27,18.02 141.56,18.02 144.28,15.3 148.03,15.3 148.61,15.89 154.14,15.89 156.01,14.02 156.9,14.02 159.44,11.48 184.26,11.48 184.85,12.07 196.37,12.07 198.58,14.28 201.66,14.28 206.34,18.96 209.24,18.96 211.34,21.06 244.8,21.06 249.85,26.12 255.64,26.12 256.14,25.62 v6(256.14,25.2)
  GND3 w0.089: v7(256.04,24.84) 256.14,24.95 v6(256.14,25.2)
  BOTTOM w0.089: U7.BC8 257.29,24.76 256.83,24.76 256.62,24.56 256.32,24.56 v7(256.04,24.84)
  BOTTOM w0.102: v1(55.89,30.1) 55.7,29.91 55.51,29.91 53.22,32.2 53.22,32.67 52.64,33.25 49.99,33.25 49.03,34.22 v9(43.24,34.22) 40.4,34.22 CN10.1
SATA_PRX_DTX_N0_C: length 2.2
  BOTTOM w0.102: CN10.2 38.84,34.25 38.43,34.25 38.26,34.42 38.07,34.42 37.93,34.56 UN1.4
SATA_PRX_DTX_N0_RC: length 2.3
  BOTTOM w0.102: CN9.1 31.66,34.12 31.85,34.12 32.15,34.42 32.49,34.42 32.64,34.56 UN1.12
SATA_PRX_DTX_N0_RC1: length 6
  BOTTOM w0.102: JHDD.5 28.3,30.86 28.42,30.74 28.93,30.74 29.43,31.24 v9(29.43,32.32) 29.43,33.87 29.65,34.09 30.1,34.09 CN9.2
SATA_PRX_DTX_N1: length 43.9
  IN4 w0.089: v6(281.36,27.24) 281.22,27.1 281.07,27.1 280.99,27.19 280.99,28.26 278.8,30.44 278.59,30.44 277.5,31.53 275.04,31.53 274.25,30.74 272.59,30.74 272.17,30.31 272.17,30.06 271.89,29.78 269.68,29.78 269.05,29.16 264.29,29.16 263.78,28.65 263.78,27.48 262.87,26.58 262.87,22.99 262.21,22.33 260.23,22.33 259.94,22.04 258.27,22.04 256.28,24.03 254.47,24.03 253.78,24.72 253.78,24.85 253.89,24.96 254,24.96 254.06,24.89 v6(254.08,24.89)
  GND3 w0.102: v6(281.36,27.24) 281.46,27.24 v7(281.62,27.4) ; v6(254.08,24.89) 253.88,25.09 253.88,25.27 v7(254,25.39)
  BOTTOM w0.089: U7.BC10 256.94,25.68 256.66,25.4 256.29,25.4 256.16,25.53
  BOTTOM w0.102: 256.16,25.53 255.69,26 255.41,26 255.41,25.98 254.67,25.98 254.65,26 254.22,26 253.9,25.68 253.9,25.48 v7(254,25.39)
SATA_PRX_DTX_P0: length 238.2
  IN4 w0.089: v6(255.71,25.2) 255.72,25.2 255.96,25.44 255.96,25.55 255.57,25.94 249.93,25.94 244.88,20.88 211.41,20.88 209.31,18.78 206.42,18.78 201.74,14.1 198.66,14.1 196.44,11.89 184.93,11.89 184.34,11.3 159.37,11.3 156.82,13.84 155.93,13.84 154.06,15.71 148.69,15.71 148.1,15.12 144.2,15.12 141.49,17.84 126.19,17.84 125.77,18.26 124.49,18.26 123.29,17.05 113.18,17.05 112.37,17.86 109.85,17.86 101.99,25.71 97.81,25.71 96.83,24.74 93.15,24.74 90.35,27.55 84,27.55 83.26,26.81 73.63,26.81 71.46,28.99 67.43,28.99 66.85,29.57 62.35,29.57 62.01,29.9 58.41,29.9 57.74,29.24 57.06,29.24 56.38,29.92 56.27,29.92 55.89,29.53 v1(55.89,29.52)
  GND3 w0.089: v7(255.53,24.88) 255.71,25.06 v6(255.71,25.2)
  BOTTOM w0.089: U7.BE8 256.59,24.97 256.59,25.16 256.54,25.21 256.16,25.21 256.08,25.29 255.94,25.29 v7(255.53,24.88)
  BOTTOM w0.102: v1(55.89,29.52) 55.7,29.7 55.42,29.7 53.02,32.11 53.02,32.59 52.56,33.04 49.91,33.04 48.94,34.01 43.56,34.01 43.52,33.97 42.98,33.97 42.94,34.01 40.4,34.01 CN11.1
SATA_PRX_DTX_P0_C: length 2.2
  BOTTOM w0.102: CN11.2 38.77,34.04 38.34,34.04 38.17,34.21 38.07,34.21 37.93,34.06 UN1.5
SATA_PRX_DTX_P0_RC: length 2.4
  BOTTOM w0.102: UN1.11 32.64,34.06 32.49,34.21 32.23,34.21 31.94,33.92 31.73,33.92 CN8.1
SATA_PRX_DTX_P0_RC1: length 6.1
  BOTTOM w0.102: JHDD.6 28.3,30.36 28.48,30.53 29.04,30.53 v9(29.31,30.8) 29.63,31.13 29.63,32.02 29.65,32.04 29.65,32.59 29.63,32.61 29.63,33.78 29.74,33.88 30.1,33.88 CN8.2
SATA_PRX_DTX_P1: length 43.9
  IN4 w0.089: v6(253.47,24.93) 253.6,24.8 253.6,24.64 254.39,23.85 256.2,23.85 258.19,21.86 260.01,21.86 260.31,22.15 262.29,22.15 263.05,22.92 263.05,26.5 263.96,27.41 263.96,28.57 264.37,28.98 269.13,28.98 269.75,29.6 271.97,29.6 272.35,29.98 272.35,30.23 272.67,30.55 274.32,30.55 275.12,31.35 277.43,31.35 278.52,30.26 278.73,30.26 280.8,28.18 280.8,27.11 281,26.92 281.25,26.92 v6(281.36,26.81)
  GND3 w0.102: v7(281.62,26.6) 281.62,26.6 281.41,26.81 v6(281.36,26.81) ; v7(253.56,25.39) 253.7,25.25 253.7,25.16 v6(253.47,24.93)
  BOTTOM w0.089: 256.05,25.93 256.13,25.86 256.21,25.86 256.5,26.15 256.58,26.15 256.68,26.05 256.68,25.87 U7.BE10
  BOTTOM w0.102: v7(253.56,25.39) 253.7,25.53 253.7,25.77 254.14,26.21 v9(255.03,26.21) 255.78,26.21 256.05,25.93
SATA_PTX_DRX_N0: length 245.6
  IN4 w0.089: v1(56.81,30.43) 57,30.62 62.43,30.62 62.83,30.23 67.36,30.23 67.95,29.64 71.73,29.64 73.9,27.47 82.7,27.47 83.44,28.2 90.62,28.2 93.42,25.39 96.56,25.39 97.56,26.39 102.4,26.39 110.29,18.51 114.14,18.51 114.72,17.93 116.56,17.93 117.07,18.43 120.76,18.43 121.26,17.93 123.08,17.93 124.06,18.91 126.04,18.91 126.46,18.49 141.8,18.49 143.93,16.36 149.35,16.36 149.8,16.81 154.05,16.81 155.59,15.27 156.31,15.27 159.64,11.95 183.78,11.95 184.87,13.04 196.68,13.04 198.39,14.75 201.47,14.75 206.14,19.43 208.98,19.43 211.08,21.53 244.61,21.53 249.67,26.6 255.47,26.6 257.82,24.25 258.08,24.25 v6(258.21,24.11)
  GND3 w0.089: v6(258.21,24.11) 258.27,24.17 258.55,24.17 258.83,24.45 258.83,24.6 v7(259.03,24.8)
  BOTTOM w0.102: v1(56.81,30.43) 56.62,30.62 55.8,30.62 55.43,30.99 55.43,35.46 52.69,38.2 51.62,38.2 51.31,37.89 51.31,37.08 48.93,34.7 41.73,34.7 40.65,35.79 40.4,35.79 CN18.1
SATA_PTX_DRX_N0_C: length 2.2
  BOTTOM w0.102: UN1.2 37.93,35.56 38.11,35.75 38.84,35.75 CN18.2
SATA_PTX_DRX_N0_RC: length 2.2
  BOTTOM w0.102: CN13.1 31.75,35.71 32.49,35.71 32.64,35.56 UN1.14
SATA_PTX_DRX_N0_RC1: length 6.1
  BOTTOM w0.102: CN13.2 30.1,35.66 29.74,35.66 29.47,35.39 29.47,35.36 29.07,34.97 29.04,34.97 28.89,34.81 v9(28.89,33.79) 28.89,32.29 28.61,32.01 28.39,32.01 28.24,31.86 JHDD.3
SATA_PTX_DRX_N1: length 5.5
  TOP w0.089: CH18.1 255.62,24.99 v9(256.6,24.99) 257.11,24.99 257.93,25.8 258.81,25.8 259.08,25.54 259.08,25.44 v1(259.3,25.22)
  BOTTOM w0.089: v1(259.3,25.22) 259.62,25.54 U7.AV10
SATA_PTX_DRX_N1_C: length 38.1
  GND1 w0.089: 254.47,25.33 254.57,25.33 v4(254.86,25.04)
  GND1 w0.102: v3(254.36,25.33) 254.47,25.33
  IN4 w0.089: v4(254.86,25.04) 255.37,24.54 256.3,24.54 258.42,22.42 259.79,22.42 260.07,22.71 262.05,22.71 262.5,23.15 262.5,28.39 263.75,29.64 268.81,29.64 269.46,30.29 269.62,30.29 270.2,30.87 271.64,30.87 272.15,31.37 273.74,31.37 274.36,32 276.26,32 276.72,32.46 277.56,32.46 278.85,31.17 279.9,31.17 280.9,30.17 v6(280.9,29.52)
  GND3 w0.102: v6(280.9,29.52) 280.78,29.63 280.78,29.94 v7(280.72,30.01)
  BOTTOM w0.102: v7(280.72,30.01) 280.72,29.99 280.91,29.8 JSSD.31
SATA_PTX_DRX_P0: length 245.6
  IN4 w0.089: v6(258.21,24.54) 258.1,24.43 257.9,24.43 255.54,26.78 249.6,26.78 244.53,21.72 211,21.72 208.9,19.61 206.07,19.61 201.39,14.94 198.31,14.94 196.6,13.23 184.79,13.23 183.7,12.13 159.71,12.13 156.39,15.46 155.66,15.46 154.12,16.99 149.73,16.99 149.28,16.54 144,16.54 141.87,18.67 126.54,18.67 126.12,19.09 123.98,19.09 123,18.12 121.34,18.12 120.83,18.62 116.99,18.62 116.49,18.11 114.8,18.11 114.21,18.69 110.36,18.69 102.48,26.58 97.49,26.58 96.49,25.58 93.5,25.58 90.69,28.38 83.36,28.38 82.63,27.65 73.98,27.65 71.81,29.82 68.03,29.82 67.43,30.41 62.9,30.41 62.51,30.8 57.02,30.8 v1(56.81,31.01)
  GND3 w0.089: v7(258.43,24.8) 258.48,24.85 258.56,24.85 258.65,24.75 258.65,24.52 258.48,24.34 258.41,24.34 258.21,24.53 v6(258.21,24.54)
  BOTTOM w0.102: v1(56.81,31.01) 56.62,30.83 55.89,30.83 55.64,31.08 55.64,35.55 52.78,38.41 51.53,38.41 51.1,37.98 51.1,37.17 48.84,34.91 41.82,34.91 40.73,35.99 40.4,35.99 CN19.1
SATA_PTX_DRX_P0_C: length 2.2
  BOTTOM w0.102: CN19.2 38.76,35.96 38.03,35.96 37.93,36.06 UN1.1
SATA_PTX_DRX_P0_RC: length 2.2
  BOTTOM w0.102: CN12.1 31.65,35.92 32.49,35.92 32.64,36.06 UN1.15
SATA_PTX_DRX_P0_RC1: length 6.1
  BOTTOM w0.102: CN12.2 30.1,35.87 29.65,35.87 v9(29.11,35.33) 28.68,34.9 28.68,34.09 28.66,34.07 28.66,33.51 28.68,33.49 28.68,32.37 28.53,32.22 28.38,32.22 28.24,32.36 JHDD.2
SATA_PTX_DRX_P1: length 5.2
  TOP w0.089: CH17.1 255.62,24.79 256.38,24.79 256.38,24.79 256.83,24.79 256.83,24.79 257.19,24.79 258.01,25.61 258.73,25.61 258.88,25.46 258.88,25.37 v1(258.7,25.19)
  BOTTOM w0.089: U7.AW10 259.03,25.52 v1(258.7,25.19)
SATA_PTX_DRX_P1_C: length 38.3
  GND1 w0.089: 254.47,24.42 v4(254.75,24.42)
  GND1 w0.102: v3(254.36,24.44) 254.38,24.42 254.47,24.42
  IN4 w0.089: v6(280.47,29.52) 280.47,29.66 280.71,29.91 280.71,30.09 279.83,30.98 278.78,30.98 277.48,32.28 276.8,32.28 276.33,31.81 274.44,31.81 273.81,31.19 272.22,31.19 271.72,30.69 270.28,30.69 269.7,30.11 269.54,30.11 268.89,29.46 263.83,29.46 262.68,28.31 262.68,23.07 262.13,22.52 260.15,22.52 259.87,22.24 258.34,22.24 256.23,24.35 254.81,24.35 v4(254.75,24.42)
  GND3 w0.102: v7(280.27,30.01) 280.27,29.71 v6(280.47,29.52)
  BOTTOM w0.102: JSSD.33 280.82,30.6 280.27,30.06 v7(280.27,30.01)
SATA_RCOMP: length 5.1
  TOP w0.089: RH21.1 256.07,23.43 256.86,24.22 v2(257.83,24.22) 259.11,24.22 v1(259.15,24.25)
  BOTTOM w0.089: v1(259.15,24.25) 259.15,23.48 U7.AY5
SATA_TEST: length 3.1
  BOTTOM w0.102: UN1.18 35.28,38 RN12.2 36.99,38.82 RN13.2
SCLK: length 5.1
  TOP w0.102: PR706.2 v2(124.12,120.9)
  TOP w0.254: PR706.2 PR702.2 122.17,119.64 v1(122.11,119.58)
  BOTTOM w0.203: PU700.1 123.2,118.49 v1(122.11,119.58)
SDA: length 4
  TOP w0.254: v1(121.09,118.88) PR700.2
  BOTTOM w0.203: PU700.31 122.05,117.22 121.35,117.92 v2(121.35,118.07) 121.35,118.63 v1(121.09,118.88)
  BOTTOM w0.254: PR703.2 121.09,118.88 v1(121.09,118.88)
SENSE_B#: length 2.2
  TOP w0.203: RA22.1 v2(20.8,40.6) 21.22,40.6 21.41,40.79 U15.33
SERIRQ: length 120.3
  TOP w0.089: v3(168.39,15.69) 168.37,15.72 168.3,15.72 168.11,15.91 167.53,15.91 UE1.M3 ; v2(257.35,28.37) 257.35,28.37 ; 257.35,28.37 258.04,27.68 259.29,27.68 259.97,27 261.14,27 261.62,26.53 261.62,26.11 v1(262.06,25.67) ; 257.35,28.37 256.46,29.26 255.87,29.26 255.79,29.33 RH75.2
  TOP w0.102: U1.27 202.61,19.48 v1(201.86,18.74)
  GND1 w0.089: v4(167.89,15.98) 168.17,15.69 v3(168.39,15.69)
  IN1 w0.102: v4(233.14,24.2) 232.76,23.81 v4(232.76,20.38)
  IN2 w0.089: v1(262.06,25.67) 261.55,25.17 261.55,23.21 260.23,21.89 258.73,21.89 258.18,21.35 257.28,21.35 256.89,21.73 254.47,21.73
  IN2 w0.102: 254.47,21.73 254.14,21.73 254.08,21.79 242.27,21.79 242.01,21.53 238.42,21.53 235.3,24.65 233.59,24.65 v4(233.14,24.2) ; v1(201.86,18.74) 202.77,19.65 212.3,19.65 213.04,20.38 223.8,20.38 224.31,19.86 232.24,19.86 v4(232.76,20.38)
  IN4 w0.076: v4(167.89,15.98) 168.1,15.76 168.78,15.76
  IN4 w0.102: v1(201.86,18.74) 201.46,18.33 200.47,18.33 199.63,17.5 197.36,17.5 196.44,16.57 194.68,16.57 194.02,15.91 179.51,15.91 179.28,16.14 174.48,16.14 174.11,15.76 168.78,15.76
  BOTTOM w0.089: U7.AL11 262.37,25.98 v1(262.06,25.67)
SKIN_TEMP0: length 269.4
  TOP w0.089: UE1.E7 163.78,17.68 164.08,17.97 164.44,17.97 v1(164.67,17.74)
  TOP w0.102: v1(137.48,62.16) v2(137.48,63)
  IN1 w0.076: 161.61,21.72 161.61,21.53 162.19,20.95 162.19,19.12 162.37,18.93 162.37,18.01 162.72,17.66 163.07,17.66 163.26,17.85 163.26,18.3 163.38,18.42 163.89,18.42 164.57,17.74 v1(164.67,17.74)
  IN1 w0.102: v1(137.48,62.16) 138.03,61.6 138.11,61.6 148.91,50.8 148.91,34.44 153.24,30.11 153.24,24.72 151.9,23.38 151.9,22.31 152.35,21.86 159.83,21.86 160.43,22.47 161.12,22.47 161.61,21.98 161.61,21.72
  IN2 w0.102: v1(192.82,126.82) 194.61,126.82 195.61,127.82 205.03,127.82 205.83,127.02 214.75,127.02 215.54,127.82 221.22,127.82 221.85,127.2 224.93,127.2 225.25,126.88 229.2,126.88 231.46,124.62 231.46,110.3 234.22,107.54 234.22,85.06 232.95,83.79 232.95,79.22 231.36,77.63 223.22,77.63 221.98,76.39 215.71,76.39 213,79.09 197.77,79.09 195.54,81.32 192.44,81.32 188.02,76.9 188.02,71.19 177.28,60.45 139.19,60.45 v1(137.48,62.16)
  BOTTOM w0.102: RT6.1 HT2.1 191.8,127.35 192.32,126.82 v1(192.82,126.82)
SKIN_TEMP1: length 166.5
  TOP w0.089: v3(162.88,17.48) 163.05,17.66 UE1.D7
  TOP w0.102: HT4.1 RT1.1 191.92,80.4 194.35,80.4 196.34,78.41 196.34,70.11 199.13,67.32 199.13,49.66 200.98,47.82 229.91,47.82 232.07,45.66 232.07,30.4 231.77,30.11 231.77,26.26 231.43,25.92 v2(231.43,25.5) v1(231.43,24.78)
  GND1 w0.089: v3(162.88,17.48) 163.18,17.79 163.33,17.79 v4(163.6,18.06)
  IN4 w0.076: v4(163.6,18.06) 164.29,18.06 164.79,18.56 165.86,18.56 166.65,17.78 167.37,17.78 168.01,18.41 168.78,18.41
  IN4 w0.102: v1(231.43,24.78) 230.82,25.39 208.04,25.39 202.81,20.16 201.09,20.16 199.04,18.11 196,18.11 195.26,17.37 172.01,17.37 170.97,18.41 168.78,18.41
SLEEVE: length 9.8
  TOP w0.203: U15.32 20.62,41.19 20.56,41.25
  TOP w0.508: CA37.1 17.65,37.12 RA19.2 17.46,36.28 16.98,35.8 16.98,35.77 DA3.2 ; v1(15.02,34.3) 15.51,34.3 DA3.2 ; DA3.2 15.78,35.29 15.78,36.34 v1(15.6,36.52) 15.03,36.52 v1(15,36.56)
  BOTTOM w0.254: QA3.6 15.48,37.17 15.6,37.04 v1(15.6,36.52)
  vias: v1(17.77,42.68) v1(18.35,42.68) v2(19.77,41.56)
SLP_LAN#: length 1.1
  TOP w0.089: T38.1 272.73,22.61 v1(273.1,22.98)
  BOTTOM w0.089: U7.G5 272.88,22.98 v1(273.1,22.98)
SLP_WLAN#: length 1.7
  TOP w0.089: v1(273.16,22.35) 273.47,22.35 T170.1
  BOTTOM w0.089: v1(273.16,22.35) 273.22,22.29 U7.D2
SM_INTRUDER#: length 4.7
  TOP w0.102: v1(277.42,23.52) 277.89,23.52 RH2.2
  BOTTOM w0.089: 277.14,25.09 277.09,25.15 276.63,25.15 276.19,24.71 275.28,24.71 U7.A8
  BOTTOM w0.102: v1(277.42,23.52) 277.38,23.56 v2(277.38,24.57) 277.38,24.86 277.14,25.09
SM_RCOMP0: length 7.6
  TOP w0.381: RU58.1 141.37,77.53 142.43,76.47 v2(144.45,76.47) 146.55,76.47 v1(146.62,76.4)
  BOTTOM w0.254: v1(146.62,76.4) 146.82,76.6 U6.BB51
SM_RCOMP1: length 6
  TOP w0.508: v1(144.81,77.07) 143.96,77.92 v2(143.58,77.92) 142.47,77.92 141.77,78.62 RU59.1
  BOTTOM w0.254: v1(144.81,77.07) 144.93,76.95 U6.BB53
SM_RCOMP2: length 8.8
  TOP w0.381: RU61.1 140.73,76.45 142.29,74.89 v2(143.9,74.89) 146.02,74.89 146.25,75.11 v1(146.25,75.85)
  BOTTOM w0.254: v1(146.25,75.85) 146.17,75.93 146.17,76.57 146.12,76.61 U6.BB52
SMBCLK: length 41.9
  TOP w0.089: 271.19,19.66 271.19,21.19 271.47,21.47 v2(271.47,22.23) 271.47,22.32 271.18,22.62 270.59,22.62 270.14,23.07 270.14,24.06 270,24.2 270,24.71 v1(269.54,25.16)
  TOP w0.102: 271.19,19.66 271.19,18.64 271.61,18.22 272.64,18.22 273.21,17.65 RH448.1 ; v3(247.95,18.28) QH2.6
  GND1 w0.102: v3(247.95,18.28) 248.44,18.28 v4(248.93,17.79)
  IN2 w0.089: v1(269.54,25.16) 269.55,25.16 270.09,24.62 270.09,22.66 269.96,22.54 269.96,22.04 269.54,21.63 269.54,19.66
  IN2 w0.102: 269.54,19.66 269.54,18.97 268.17,17.6 265.04,17.6 264.87,17.43 262.23,17.43 261.87,17.07 258,17.07 257.87,17.2 252.15,17.2 251.96,17.39 250.91,17.39 250.49,16.96 249.76,16.96 v4(248.93,17.79)
  BOTTOM w0.089: U7.R10 269.33,25.38 v1(269.54,25.16)
SMBDATA: length 37.6
  TOP w0.089: 270.98,19.66 270.98,21.82 269.95,22.86 269.95,23.82 269.4,24.37 v2(269.4,24.7) 269.05,25.05 269.05,25.15 v1(268.56,25.64)
  TOP w0.102: RH456.1 270.98,18.14 270.98,19.66
  GND1 w0.102: v3(249.25,16.93) 249.25,17.04 v4(249.76,17.55)
  IN2 w0.089: 263.32,19.66 265.63,21.97 267.9,21.97 268.6,22.67 268.6,23.36 268.93,23.69 268.93,25.27 v1(268.56,25.64)
  IN2 w0.102: v4(249.76,17.55) 249.72,17.59 249.72,17.95 251.36,19.58 252.67,19.58 253.5,18.75 258.38,18.75 258.74,18.4 260.18,18.4 260.44,18.13 261.49,18.13 262.12,18.75 262.41,18.75 263.32,19.66
  BOTTOM w0.102: U7.U11 268.22,25.98 v1(268.56,25.64)
SML0CLK: length 194.9
  TOP w0.102: RH724.1 270.52,17.23 v3(270.39,17.36) ; v1(241.87,17.38) 241.87,17.1 v2(241.49,16.72) ; DN2.2 243.84,12.59 v1(243.69,12.45)
  GND1 w0.102: v3(270.39,17.36) 270.59,17.16 v4(270.59,16.76)
  IN1 w0.076: v1(267.57,24.61) 267.21,24.25 267.21,23.57 266.93,23.29 266.93,20.49 266.71,20.28 266.71,19.66
  IN1 w0.102: v4(265.1,16.39) 265.1,17.14 266.71,18.75 266.71,19.66
  IN2 w0.102: v4(270.59,16.76) 270.05,17.3 268.73,17.3 268.23,16.8 265.5,16.8 v4(265.1,16.39) 264.84,16.14 260.14,16.14 259.81,16.46 255.7,16.46 255.17,15.92 252.5,15.92 252.09,16.33 248.8,16.33 248.13,16.99 242.26,16.99 v1(241.87,17.38)
  IN3 w0.102: v1(243.69,12.45) 242.67,11.43 234.61,11.43 234,10.82 221.13,10.82 216.93,15.02 214.54,15.02 212.38,12.86 212.38,12.51 210.94,11.07 191.05,11.07 190.08,12.03 174.15,12.03 173.16,11.05 156.2,11.05 152.41,14.84 149.52,14.84 148.2,13.52 144.08,13.52 143.95,13.65 143.95,14.65 140.12,18.48 128.94,18.48 128.54,18.07 126.81,18.07 126.23,18.65 124.7,18.65 123.99,17.94 121.55,17.94 120.94,17.34 120.37,17.34 v1(119.67,18.03)
  BOTTOM w0.089: U7.U8 267.74,24.78 v1(267.57,24.61)
  BOTTOM w0.102: v1(241.87,17.38) 241.39,17.86 239.43,17.86 239,17.43 239,15.2 239.66,14.54 239.66,11.56 240.07,11.16 243.17,11.16 243.69,11.69 v1(243.69,12.45) ; JNFC1.8 119.3,18.4 v1(119.67,18.03)
SML0DATA: length 188.8
  TOP w0.089: v1(269.55,23.67) 269.55,22.51 v8(269.93,22.12) 270.78,21.27 270.78,19.66
  TOP w0.102: 270.78,19.66 270.78,19.15 270.12,18.49 ; 270.12,18.49 271.42,17.19 RH725.1 ; 270.12,18.49 269.61,17.98 269.61,14.56 270.95,13.22 272.62,13.22 v3(272.83,13) ; v1(246.56,10.35) 246.25,10.66 DN2.3
  GND1 w0.102: v3(272.83,13) v4(272.83,12.51)
  IN2 w0.102: v1(246.56,10.35) 245.28,11.63 236.81,11.63 235.79,12.65 234.82,12.65 233.81,11.64 221.47,11.64 217.08,16.03 213.9,16.03 211.45,13.58 210.77,13.58 v4(210.77,13.58)
  IN4 w0.102: v4(272.83,12.51) 271.87,13.47 269.17,13.47 268.51,12.81 265.25,12.81 264.96,12.51 264.96,11.77 263.74,10.55 261.33,10.55 260.74,11.13 258.81,11.13 258.62,10.94 256.44,10.94 256.16,11.22 253.19,11.22 252.96,10.99 250.14,10.99 249.82,10.66 249.31,10.66 248.93,11.05 247.27,11.05 v1(246.56,10.35) ; v4(210.77,13.58) 210.55,13.8 209.75,13.8 208.47,12.52 206.1,12.52 204.99,13.62 198.85,13.62 196.64,11.41 185.12,11.41 184.53,10.82 159.17,10.82 156.63,13.36 155.73,13.36 153.87,15.22 148.89,15.22 148.31,14.64 143.97,14.64 141.31,17.31 128.59,17.31 128.26,16.98 126.68,16.98 126,16.29 119.77,16.29 v1(119.56,16.5)
  BOTTOM w0.089: U7.R7 269.05,24.17 269.54,23.67 v1(269.55,23.67)
  BOTTOM w0.102: JNFC1.9 118.8,18.29 119.56,17.52 v1(119.56,16.5)
SML1CLK: length 33
  TOP w0.102: RPH14.1 252.27,17.69 v3(251.97,17.39)
  GND1 w0.102: v4(251.73,16.74) 251.97,16.98 v3(251.97,17.39)
  IN2 w0.089: 269.95,19.66 269.95,21.28 v4(271.6,22.93)
  IN2 w0.102: v4(251.73,16.74) 251.91,16.56 252.94,16.56 253.36,16.14 255.08,16.14 255.61,16.66 259.9,16.66 260.22,16.34 264.47,16.34 265.29,17.15 268.3,17.15 269.95,18.8 269.95,19.66
  GND3 w0.089: v7(271.14,23.25) 271.29,23.25 v4(271.6,22.93)
  GND3 w0.102: v4(251.73,16.74) 251.73,17.12 v7(251.51,17.34)
  BOTTOM w0.089: v7(271.14,23.25) 271,23.39 U7.K6
  BOTTOM w0.102: QH3.6 248.52,18.95 248.98,18.49 v2(249.31,18.49) 250.36,18.49 v7(251.51,17.34)
SML1DATA: length 35.4
  TOP w0.102: v3(252.29,18.75) 251.77,18.23 RPH14.2
  GND1 w0.102: v4(252.49,19.18) 252.49,19.17 252.49,18.95 v3(252.29,18.75)
  IN2 w0.089: 269.34,19.66 269.34,21.76 269.13,21.97 269.13,22.48 269.29,22.64 269.51,22.86 269.51,23.17 269.12,23.56 269.12,26.53 269.34,26.75 269.72,26.75 v4(270.14,26.33)
  IN2 w0.102: v4(252.49,19.18) 252.49,19.17 252.49,19.14 254.17,17.46 258.01,17.46 258.2,17.27 261.78,17.27 262.15,17.64 263.43,17.64 263.69,17.89 268.15,17.89 269.34,19.08 269.34,19.66
  GND3 w0.089: v4(270.14,26.33) 270.48,25.99 v7(270.48,25.98)
  GND3 w0.102: v4(252.49,19.18) 252.49,19.18 252.49,19.21 252.26,19.44 v7(252.12,19.44)
  BOTTOM w0.089: U7.N11 v7(270.48,25.98)
  BOTTOM w0.102: v7(252.12,19.44) 251.82,19.14 v2(251.45,19.14) 250.82,19.14 250.32,19.64 250.32,21.09 249.82,21.58 QH3.3
SNUB_1.35V: length 3.3
  BOTTOM w0.102: PC409.1 132.9,19.34 132.27,19.97 131.91,19.97 v2(131.89,20)
  BOTTOM w0.508: PC409.1 132.92,18.63 PR403.2
SNUB_3V: length 1.8
  BOTTOM w0.102: v2(36.97,28.63) 37.38,28.22 PR309.2
SNUB_5V: length 2.2
  BOTTOM w0.102: PR310.2 v2(49,27.84)
SPK_L+: length 2.3
  BOTTOM w0.61: JSPK1.1 9.08,7.55 DA4.2
  vias: v2(5.45,13.7)
SPK_L-: length 2.8
  BOTTOM w0.61: JSPK1.2 8.08,6.75 DA4.3
  vias: v2(2.7,16.14)
SPK_LC+: length 30.6
  TOP w0.102: v2(28.54,36.1) 28.79,36.36 v1(29.03,36.36) 29.34,36.05 29.34,35.26 29.6,35 31.15,35 CA30.1
  IN1 w0.102: v4(7.43,30.31) 7.89,30.77 14.04,30.77 15.56,32.28 15.56,34.04 16.57,35.06 26.38,35.06 27.67,36.36 v1(29.03,36.36)
  GND3 w0.102: v4(7.43,30.31) v7(6.97,30.31) v7(6.97,29.88)
SPK_LC-: length 1
  BOTTOM w0.102: v2(8.93,30.41) CA58.2
SPK_OUT_L+:
  vias: v2(5.22,18.68)
SPK_OUT_L-: length 0.8
  TOP w0.102: v2(5.98,19.74) v1(6.51,19.21)
  vias: v1(2.81,20.51) v1(3.39,20.51) v1(7.02,19.52)
SPK_OUT_R+:
  vias: v2(12.23,21.29)
SPK_OUT_R-:
  vias: v2(10.86,21.22)
SPK_R+: length 15.8
  TOP w1.016: 13.39,14.43 v2(11.74,12.79) 9.65,10.69 CA56.1 9.65,7.2 8.13,5.67 DA5.3 8.13,3.87 7.88,3.63 v1(7.08,3.63)
  BOTTOM w0.61: JSPK1.3 v1(7.08,3.63)
  vias: v1(14.7,15.1) v1(15.28,15.1)
SPK_R-: length 13.7
  TOP w1.016: 7.92,12.34 7.11,11.53 CA57.1 5.73,10.24 4.86,9.37 4.86,6.8 6.2,5.47 DA5.2 5.46,4.2 v1(5.46,3.69)
  BOTTOM w0.61: v1(5.46,3.69) 6.08,4.31 JSPK1.4
  vias: v1(9.05,12.71) v1(9.65,12.71) v2(8.98,12.05)
SPK_RC+: length 3.1
  BOTTOM w0.102: CA59.2 13.52,30.06 13.98,29.6 14.09,29.6 15.46,28.23 v2(15.56,28.23)
SPKL+: length 4.2
  BOTTOM w0.102: v2(4.18,20.2) 4.79,20.81 CA61.1 5.23,20.9 5.99,21.66 6.41,21.66 6.92,22.17 UA5.26
SPKL-: length 1.9
  BOTTOM w0.102: CA62.1 9.52,20.91 UA5.22
SPKR+: length 5.1
  BOTTOM w0.102: v2(14.13,19.24) 14.13,19.9 14.67,20.43 CA72.1 14.67,21.03 14.54,21.15 13.56,21.15 12.77,21.94 UA5.17
SPKR-: length 3.1
  BOTTOM w0.102: UA5.21 10.17,20.12 CA73.1
SRN: length 1.9
  BOTTOM w0.254: PU200.12 80.04,26.56 79.97,26.49 79.97,25.74 PR221.1
SRP: length 1.8
  BOTTOM w0.254: PR218.1 79.62,25.62 79.62,26.5 79.54,26.58 PU200.13
STRAP0: length 8.5
  BOTTOM w0.102: RV308.1 RV316.2 222.76,72.45 v2(222.76,76.69) 222.76,78.16 223.4,78.8 UV1.J2
STRAP1: length 18.8
  TOP w0.102: RV307.1 RV315.2 219.31,69.22 219.73,69.22 v2(220.36,69.85) 221.13,70.62 v1(222.57,70.62)
  IN4 w0.102: v6(223.4,82.3) 222.72,81.62 222.72,70.77 v1(222.57,70.62)
  GND3 w0.089: v6(223.4,82.3) 223.3,82.3 v7(222.95,82.65)
  BOTTOM w0.102: UV1.J7 223.4,83.1 v7(222.95,82.65)
STRAP2: length 16.4
  TOP w0.102: RV314.2 RV306.1 220.97,69.1 221.52,69.1 v2(222.1,69.67) 222.41,69.98 v1(222.57,69.98)
  IN4 w0.102: v1(222.57,69.98) 222.97,70.39 222.97,80.96 v6(223.43,81.41)
  GND3 w0.089: v6(223.43,81.41) 223.8,81.78 v7(223.8,81.8)
  BOTTOM w0.102: UV1.J6 223.4,82.2 v7(223.8,81.8)
STRAP3: length 15.6
  TOP w0.102: RV310.2 RV302.1 222.57,68.92 v1(222.57,69.35) 222.58,69.35 v2(223.39,70.16)
  IN4 w0.102: v1(222.57,69.35) 223.18,69.96 223.18,80.37 v6(223.45,80.65)
  GND3 w0.089: v6(223.45,80.65) 223.8,81 v7(223.8,81)
  BOTTOM w0.102: UV1.J5 v7(223.8,81)
STRAP4: length 8.4
  BOTTOM w0.102: UV1.J3 223.4,79.5 223,79.1 223,78.78 222.22,78 222.22,76.79 221.63,76.2 v2(221.63,75.9) 221.63,75.38 RV309.2 221.74,74.25 221.74,73.36 RV301.1
SUSACK#: length 133.2
  TOP w0.089: UE1.M13 167.28,21.72
  TOP w0.102: 167.28,21.72 167.28,21.74 T176.1 167.88,22.33 174.5,22.33 176.28,24.11 183.7,24.11 187.62,20.2 187.62,11.42 v1(187.2,11.01)
  IN1 w0.076: 269.61,17.76 269.68,17.84 269.68,18.6 269.81,18.73 269.81,19.92 269.48,20.24 269.48,21.77 269.18,22.07 269.18,22.97 v1(269.13,23.02)
  IN1 w0.102: 269.61,17.76 268.64,16.8 268.64,15.31 265.54,12.21 v4(265.54,11.26)
  IN2 w0.102: v1(187.2,11.01) 188.02,11.83 190.41,11.83 190.63,11.61 210.05,11.61 214.06,15.62 216.92,15.62 221.31,11.23 234.05,11.23 234.65,11.84 236.32,11.84 236.72,11.43 244.91,11.43 246.51,9.83 248.13,9.83 v4(248.49,10.19)
  IN4 w0.102: v4(248.49,10.19) 248.62,10.05 250.07,10.05 250.4,10.38 251.84,10.38 252.74,9.47 263.82,9.47 264.58,10.23 264.58,11.1 264.89,11.41 265.39,11.41 v4(265.54,11.26)
  BOTTOM w0.089: v1(269.13,23.02) 269.05,23.1 U7.R6
SUSCLK_R: length 126.4
  TOP w0.089: v1(267.56,23.44) 267.47,23.44 266.97,22.94 T39.1
  GND1 w0.102: v5(167,11.64) 166.72,11.36 v3(166.72,11.19)
  IN1 w0.076: v1(267.56,23.44) 267.83,23.18 267.83,19.23 267.73,19.13
  IN1 w0.102: 267.73,19.13 266.43,17.84 266.43,16.08 266.03,15.68 265.2,15.68 264.57,15.06 264.57,13.22 265.14,12.66 265.14,11.08 v4(264.98,10.93) 264.98,9.74 264.37,9.13 246.7,9.13 244.89,10.93 235.85,10.93 235.35,11.43 233.96,11.43 233.35,10.82 219.23,10.82 218.67,11.38 218.67,13.24 216.89,15.02 214.47,15.02 210.63,11.17 195.4,11.17 194.93,11.64 190.72,11.64 190.13,12.23 185.21,12.23 184.42,11.43 167.21,11.43 v5(167,11.64)
  IN4 w0.102: v6(267.02,10.68) 266.89,10.8 265.11,10.8 v4(264.98,10.93)
  GND3 w0.102: v7(267.02,10.19) v6(267.02,10.68)
  BOTTOM w0.102: JTB1.22 266.9,10.08 v7(267.02,10.19) ; U7.Y6 267.23,23.44 v1(267.56,23.44)
SW_1.35V: length 3.1
  IN1 w1.016: 129.12,14.9 129.53,14.49 130.94,14.49
  BOTTOM w0.508: PC404.1 126.97,14.68 v9(127.67,15.38)
  vias: v2(136.17,15.92) v9(128.31,15.38) v9(131.92,14.49) v9(132.55,14.52) v9(135.55,14.87) v9(135.55,14.11) v9(135.55,13.35) v9(135.55,12.59) v9(135.55,11.82) v9(136.31,14.87) v9(136.31,14.11) v9(136.31,13.35) v9(136.31,12.59) v9(136.31,11.82) v9(137.07,14.87) v9(137.07,14.11) v9(137.07,13.35) v9(137.07,12.59) v9(137.07,11.82)
SW_+1.5VRUN: length 1.8
  TOP w0.102: v2(187.64,118.65) 187.96,118.97 PR607.2
  vias: v1(188.63,121.68)
SW_+V1.05V: length 13.5
  TOP w0.102: PC504.2 236.1,67.25 v2(236.28,67.43)
  IN2 w1.016: 245.96,65.29 245.18,64.5 239.27,64.5 237.3,66.48 235.01,66.48
  vias: v9(233.92,68) v9(234.58,68) v9(246.87,65.57) v9(247.51,65.57)
SYS_PWROK: length 41.4
  TOP w0.089: v8(266.1,23.86) 266.05,23.91 v1(265,23.91) 265,22.85 RH130.2
  TOP w0.102: v1(237.73,12.24) 238.14,12.24 238.3,12.09 UH3.4
  IN1 w0.076: v4(262.9,14.21) 262.9,15.71 263.57,16.37 263.57,17.58 263.61,17.63 263.61,18.25 263.5,18.36 263.5,20.3 264.86,21.66 264.86,23.77 v1(265,23.91)
  IN4 w0.076: v1(237.73,12.24) 237.9,12.07 240.47,12.07 241.4,13 243.62,13 243.98,13.36 252.82,13.36 253.46,14 254.54,14 254.96,13.58 262.28,13.58 v4(262.9,14.21)
  BOTTOM w0.089: v1(265,23.91) 265.27,24.19 U7.AD7
SYSTEM_FAN2_FB: length 110.2
  TOP w0.089: 168.78,21.23 168.78,19.96 168.48,19.66 UE1.N11
  TOP w0.102: v1(170.59,21.04) 169.84,21.79 v2(169.35,21.79) 169.19,21.79 168.78,21.38 168.78,21.23
  IN3 w0.102: v1(170.59,21.04) 171.26,20.37 171.26,17.91 171.72,17.46 174.22,17.46 175.67,16.01 185.33,16.01 186.64,17.32 187.3,17.32 189.79,14.83 189.79,14.47 190.4,13.86 193.85,13.86 195.22,12.49 200.61,12.49 201.43,13.32 204.34,13.32 205.37,12.29 210.44,12.29 211.16,13.02 211.16,13.37 214.64,16.84 220.98,16.84 222.45,15.37 233.66,15.37 234.2,14.84 236.65,14.84 237.17,15.37 240.57,15.37 241.15,14.79 244.22,14.79 245.27,13.74 249.9,13.74 251.18,12.45 252.05,12.45 252.35,12.76 258.1,12.76 259.5,11.36 261.38,11.36 v4(261.5,11.23)
  GND3 w0.102: v7(261.86,10.88) v4(261.5,11.23)
  BOTTOM w0.102: JTB1.44 262.5,10.24 v7(261.86,10.88)
SYSTEM_FAN2_PWM: length 111
  TOP w0.089: 168.34,18.91 167.55,18.91 167.29,19.16 UE1.M10
  TOP w0.102: 168.34,18.91 168.34,18.91 168.55,19.12 169.11,19.12 v2(169.22,19.23) 169.42,19.43 v1(169.42,21.04)
  IN3 w0.102: v1(169.42,21.04) 170.93,19.53 170.93,17.96 171.63,17.25 174.14,17.25 175.59,15.81 185.41,15.81 186.72,17.12 187.22,17.12 189.59,14.75 189.59,14.39 190.32,13.66 193.76,13.66 195.13,12.29 201.92,12.29 202.74,13.11 204.25,13.11 205.28,12.09 210.52,12.09 211.37,12.93 211.37,13.28 214.72,16.64 220.89,16.64 222.46,15.07 233.68,15.07 234.14,14.61 236.7,14.61 237.26,15.16 240.48,15.16 241.06,14.59 244.14,14.59 245.19,13.53 249.81,13.53 251.1,12.25 252.13,12.25 252.44,12.56 258.02,12.56 259.41,11.16 260.92,11.16 261.25,10.83 261.83,10.83 v4(262.24,11.23)
  GND3 w0.102: v4(262.24,11.23) 262.42,11.06 v7(262.42,10.78)
  BOTTOM w0.102: v7(262.42,10.78) 262.9,10.3 JTB1.42
SYSTEM_FAN_FB: length 217.4
  TOP w0.089: UE1.M11 167.53,19.91 168.08,19.91 168.21,20.04
  TOP w0.102: v3(185.13,21.7) 184.75,22.09 v2(184.75,22.35) 184.75,22.78 183.62,23.91 176.36,23.91 174.59,22.13 169.06,22.13 168.52,21.6 168.52,20.35 168.21,20.04
  GND1 w0.102: v3(185.13,21.7) 185.46,22.03 v4(185.46,22.1)
  IN2 w0.102: v1(30.44,68.81) 31.66,67.59 31.66,62.02 32.15,61.52 32.15,55.82 39.57,48.39 42.01,48.39 48.74,41.66 53.87,41.66 55.88,39.66 61.58,39.66 61.99,39.25 66.11,39.25 67.06,38.29 69.53,38.29 70.39,37.43 72.17,37.43 73.12,38.38 74.14,38.38 74.46,38.06 91.1,38.06 93.56,40.52 98.84,40.52 104.22,35.14 167.26,35.14 171.53,30.88 171.53,25.99 172.85,24.67 175.48,24.67 176.89,26.08 178.38,26.08 179.44,25.03 182.64,25.03 185.46,22.2 v4(185.46,22.1)
  BOTTOM w0.102: CE27.1 25.36,70.88 RE51.2 26.31,70.76 DE4.2 26.6,69.61 27.24,70.24 29.01,70.24 v1(30.44,68.81)
SYSTEM_FAN_PWM: length 137.3
  TOP w0.089: UE1.N10 168,19.38 168.34,19.38
  TOP w0.102: 168.34,19.38 168.62,19.38 169.01,19.77 169.01,21.21 169.25,21.45 169.6,21.45 v1(170,21.04) 170,20.55 v2(169.91,20.45)
  IN2 w0.102: v1(170,21.04) 167.67,23.37 154.05,23.37 153.21,24.21 153.21,25.08 152.27,26.02 134.28,26.02 133.63,26.67 107.88,26.67 99.68,34.87 92.33,34.87 91.77,34.31 90.64,34.31 88.97,35.98 76.57,35.98 76.14,35.55 69.61,35.55 68.75,36.41 66.29,36.41 65.33,37.37 61.21,37.37 60.8,37.78 55.1,37.78 53.54,39.34 51.89,39.34 v4(51.47,38.92)
  GND3 w0.102: v7(51.82,37.71) 51.47,38.06 v4(51.47,38.92)
  BOTTOM w0.102: v7(51.82,37.71) 51.82,36.65 51.1,35.93 JFAN1.1
THM_ALERT#: length 5.8
  BOTTOM w0.089: UV1.M2 221.29,78.61 221.29,77.32
  BOTTOM w0.102: 221.29,77.32 221.29,76.87 220.23,75.81 v2(220.23,75.47) 220.23,74.44 220.34,74.33 RPH33.3
THM_OVERT#: length 87.2
  TOP w0.102: v1(186.18,24.52) 187.18,24.52 v2(187.34,24.37) 191.4,20.3 RE322.1 ; v1(218.97,75.84) 218.79,75.84 218.31,75.36 QV40.1
  IN4 w0.102: v1(218.97,75.84) 218.53,75.4 218.53,69.34 220.09,67.78 220.09,66.37 219.9,66.17 219.9,61.67 219.57,61.34 219.57,54.38 206.2,41.02 188.04,41.02 185.94,38.91 185.94,31.69 186.69,30.94 186.69,25.03 v1(186.18,24.52)
THM_OVERT#_R: length 8.6
  TOP w0.102: v1(219.77,74.73) 219.28,74.24 QV40.3 220.6,72.89 v2(220.89,72.6)
  BOTTOM w0.089: 220.41,77.32 220.41,77.71 UV1.M1
  BOTTOM w0.102: RPH33.2 219.84,74.67 v1(219.77,74.73) 219.77,75.88 220.41,76.52 220.41,77.32
TMDS_L_TX0N: length 35
  TOP w0.102: JHDMI.9 12.18,108.29 12.55,108.29 12.79,108.05 12.79,107.54 12.89,107.44 14.04,107.44 14.18,107.58 DV4.4 DV4.7 16.04,107.58 16.19,107.44 16.65,107.44 v9(17.14,107.93) 17.53,108.32 17.53,108.8 17.78,109.05 18.29,109.05 18.42,109.18 18.42,109.6 18.29,109.73 17.78,109.73 17.53,109.98 17.53,110.58 17.78,110.83 18.61,110.83 18.94,111.17 20,111.17 20.12,111.3 20.12,111.91 19.99,112.05 19.1,112.05 18.81,112.34 18.81,112.9 20.15,114.24 21.56,114.24 22.98,112.82 22.98,111.24 23.11,111.11 23.61,111.11 23.73,111.24 23.73,112.9 22.05,114.58 22.05,114.95 22.51,115.41 22.83,115.41 23.76,114.48 23.91,114.48 24.16,114.73 24.16,114.88 23.26,115.78 23.26,116.16 23.52,116.42 24.15,116.42 24.49,116.76 LV8.2
TMDS_L_TX0P: length 35
  TOP w0.102: LV8.3 24.44,115.91 24.14,116.21 23.61,116.21 23.47,116.07 23.47,115.87 24.37,114.97 24.37,114.61 v9(24.17,114.41) 24.03,114.27 23.67,114.27 23.07,114.87 22.74,115.2 22.59,115.2 22.26,114.87 22.26,114.67 23.94,112.99 23.94,111.15 23.69,110.9 23.02,110.9 22.77,111.15 22.77,112.74 21.48,114.03 20.24,114.03 19.02,112.81 19.02,112.42 19.18,112.26 20.07,112.26 20.33,112 20.33,111.21 20.08,110.96 19.03,110.96 18.69,110.62 17.87,110.62 17.74,110.5 17.74,110.07 17.87,109.94 18.38,109.94 18.63,109.69 18.63,109.09 18.38,108.84 17.87,108.84 17.74,108.72 17.74,108.24 17.49,107.99 17.49,107.96 17.1,107.57 17.07,107.57 16.73,107.23 16.19,107.23 16.04,107.08 DV4.6 DV4.5 14.18,107.08 14.04,107.23 12.8,107.23 12.58,107.45 12.58,107.97 12.47,108.08 12.15,108.08 JHDMI.7
TMDS_L_TX1N: length 19.1
  TOP w0.102: LV9.2 18.37,99.62 18.22,99.48 17.61,99.48 17.4,99.69 v9(17.4,101.07) 17.4,103.72 17.42,103.74 17.42,104.3 17.4,104.32 17.4,104.73 16.41,105.72 DV5.5 DV5.6 14.24,105.72 13.68,106.28 13.27,106.28 v1(13.19,106.37)
  IN4 w0.089: v1(13.19,106.37) 12.99,106.17 12.71,106.17 12.45,105.91 12.45,104.28 12.03,103.86 11.37,103.86 11.19,104.04 11.19,104.76 11.29,105.02 11.31,105.16 arc(11.31,105.32) 11.26,105.48 11.21,105.6 11.17,105.71 11.18,105.85 arc(11.03,106.6) JHDMI.6
TMDS_L_TX1P: length 19.1
  TOP w0.102: v1(13.19,105.78) 13.48,106.07 13.59,106.07 14.14,105.52 14.14,105.35 14.28,105.22 DV5.7 DV5.4 15.94,105.22 16.19,105.47 16.36,105.47 17.19,104.64 v9(17.19,104.02) 17.19,101.37 17.17,101.35 17.17,100.8 17.19,100.78 17.19,99.6 17.52,99.27 18.15,99.27 18.27,99.15 18.27,98.87 18.37,98.77 LV9.3
  IN4 w0.089: v1(13.19,105.78) 12.99,105.98 12.78,105.98 12.63,105.83 12.63,104.2 12.11,103.68 11.29,103.68 11.01,103.96 11.01,104.8 11.11,105.06 11.13,105.18 arc(11.12,105.3) 11.09,105.41 arc(11.08,105.44) 11.07,105.46 10.99,105.68 JHDMI.4
TMDS_L_TX2N: length 22.7
  TOP w0.102: LV10.2 18.48,97.91 18.11,97.53 v9(17.77,97.53) 17.5,97.53 16.6,98.43 16.6,99.66 16.37,99.89 13.8,99.89 13.69,99.99 13.69,100.43 13.8,100.53 16.37,100.53 16.6,100.76 16.6,101.35 16.37,101.58 14.89,101.58 14.79,101.68 14.79,102.05 14.89,102.15 15.51,102.15 15.53,102.13 16.09,102.13 16.11,102.15 16.37,102.15 16.6,102.37 16.6,103.85 16.37,104.07 16.19,104.07 16.04,104.22 DV5.2 DV5.8 14.23,104.22 14.1,104.08 13.65,104.08 12.44,105.29 12.18,105.29 JHDMI.3
