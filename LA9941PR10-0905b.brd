# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_RST_5505_R: length 8.5
  TOP w0.102: v3(20.31,32.55) 20.31,32.8 20.97,33.46 v2(21.52,33.46)
  GND1 w0.102: v3(20.31,32.55) v5(20.31,32.09) ; v3(25.41,29.22) v5(24.98,29.22)
  IN1 w0.102: v5(24.98,29.22) 24.34,29.85 22.83,29.85 20.59,32.09 v5(20.31,32.09)
HDA_RST_AUDIO#: length 326.9
  TOP w0.102: RA58.1 24.26,29.22 v1(23.68,28.65) 23.37,28.65 22.95,28.23 U12.11
  GND1 w0.102: v4(279.17,32.8) 279.12,32.84 v3(278.71,32.84)
  IN3 w0.13: v4(279.17,32.8) 279.21,32.8 279.69,32.31 279.69,31.52 279.3,31.13 279.3,29.77 279.59,29.48 279.59,21.08 280.12,20.55 280.12,19.76 277.99,17.62 269.17,17.62 268.44,16.9 264.91,16.9 264.55,17.26 262.44,17.26 262.22,17.04 259.67,17.04 259.22,17.49 255.78,17.49 254.71,18.55 253.01,18.55 252.87,18.42 250.25,18.42 249.67,19 247.72,19 247.04,19.67 238.36,19.67 237.79,19.1 231.42,19.1 230.85,19.67 226.49,19.67 225.89,19.08 224.97,19.08 224.38,19.67 220.19,19.67 219.65,20.22 213.28,20.22 212.37,19.3 204.05,19.3 202.71,17.96 198.16,17.96 195.17,20.95 195.17,22.45 194.73,22.89 194.33,22.89 193.31,23.92 193.31,24.51 192.81,25 180.42,25 174.3,31.13 171.83,31.13 168.29,34.67 166.68,34.67 165.95,35.4 165.95,37.66 164.56,39.05 158.59,39.05 157.87,39.77 111.6,39.77 110.38,38.55 110.38,35.52 109.44,34.59 106.09,34.59 105.13,33.63 76.75,33.63 75.83,32.71 66.55,32.71 66.21,33.05 64.09,33.05 62.78,34.36 52.7,34.36 51.2,35.86 48.24,35.86 47.18,36.92 45.82,36.92 42.58,40.16 36.77,40.16 29.57,32.95 29.57,28.2 29.22,27.86 26.1,27.86 25.31,28.65 v1(23.68,28.65) 23.62,28.58 14.62,28.58 14.18,29.02 14.18,29.75 14.51,30.08 15.63,30.08 15.78,30.23 15.78,30.61 16.93,31.76 18.41,31.76 19.7,33.05 v1(19.7,33.66)
  BOTTOM w0.102: RA101.1 17.46,34.3 18.1,33.66 v1(19.7,33.66) v2(20.23,33.66)
HDA_SDIN0: length 289.1
  TOP w0.102: RA81.1 29.09,27.93 v1(28.75,28.28)
  IN1 w0.076: v1(271.07,30.24) 271.59,29.73 271.59,29.03 272.1,28.52 272.1,27.67 271.1,26.68 270.75,26.68 270.57,26.5 270.57,25.9 270.76,25.71 270.76,24.4 271.06,24.11 271.06,20.37 271.01,20.32 271.01,18.21 v4(270.91,18.1)
  IN3 w0.13: v1(28.75,28.28) 28.31,28.28 27.78,28.82 27.78,31.63 36.64,40.49 42.72,40.49 45.96,37.25 47.31,37.25 48.37,36.19 51.33,36.19 52.83,34.7 62.92,34.7 64.23,33.38 66.34,33.38 66.69,33.04 75.69,33.04 76.61,33.96 104.87,33.96 105.91,35 109.37,35 110.05,35.67 110.05,38.69 111.46,40.1 158.01,40.1 158.73,39.38 164.7,39.38 166.28,37.8 166.28,35.66 166.94,35 169.15,35 172.69,31.46 174.44,31.46 180.56,25.33 193.21,25.33 196.31,22.23 196.31,20.28 198.3,18.3 202.57,18.3 203.91,19.63 212.14,19.63 213.06,20.55 219.79,20.55 220.33,20.01 224.52,20.01 225.11,19.41 225.75,19.41 226.35,20.01 230.99,20.01 231.56,19.43 237.65,19.43 238.23,20.01 247.18,20.01 247.8,19.39 249.84,19.39 250.48,18.75 252.73,18.75 252.87,18.88 254.93,18.88 255.99,17.82 259.09,17.82 259.36,17.82 259.81,17.37 262.09,17.37 262.31,17.59 264.69,17.59 265.02,17.25 268.33,17.25 269.18,18.1 v4(270.91,18.1)
  BOTTOM w0.089: v1(271.07,30.24) 270.8,30.52 U7.L22
HDA_SDIN0_C: length 8.1
  TOP w0.102: v2(30.03,26.58) RA81.2 28.89,26.37 25.89,26.37 25.74,26.22 24.78,26.22 24.37,26.63 RA56.1 24.24,26.8 23.35,26.8 23.27,26.73 U12.8
HDA_SDIN_5505: length 23.2
  TOP w0.102: RA24.1 32.29,39.15 v2(32.19,39.05) 31.99,38.84 v1(31.71,38.84) ; RA64.2 18.53,31.43 v1(18.07,30.97) 17.89,30.79 17.89,30.17 17.67,29.95 U12.21
  IN3 w0.102: v1(31.71,38.84) 31.68,38.84 30.13,37.29 30.13,35.32 28.94,34.12 26.7,34.12 24.41,31.83 20.66,31.83 19.09,30.26 18.27,30.26 17.99,30.54 17.99,30.89 v1(18.07,30.97)
HDA_SDIN_5505_R: length 10.2
  GND1 w0.102: v3(18.53,32.6) v5(18.53,32.19) ; v3(25.28,26.68) v5(24.88,26.68)
  IN1 w0.102: v5(18.53,32.19) 18.53,31.83 18.83,31.53 20.58,31.53 22.97,29.13 22.97,28.13 23.63,27.47 24.09,27.47 v5(24.88,26.68)
HDA_SDIN_R: length 5.2
  TOP w0.102: RA24.2 31.84,41.41 30.67,41.41 30.54,41.54 30.54,41.87 29.96,42.45 v2(29.44,42.45) 29.38,42.39 U15.8
HDA_SDO: length 147.3
  TOP w0.089: v3(162.56,14.1) 162.56,14.26 162.78,14.48 UE1.C1
  TOP w0.102: v1(280.54,31.11) 280.43,31 RH11.1
  GND1 w0.076: v3(162.56,14.1) 162.56,13.98 v5(162.37,13.79)
  IN1 w0.076: v5(162.37,13.79) 162.37,13.13 163.11,12.39 165.05,12.39 165.7,13.04 166.68,13.04 167,12.72 168.3,12.72 168.51,12.51 171.22,12.51 171.82,13.1 173.12,13.1 173.5,12.72 184.18,12.72 184.58,13.12 194.99,13.12 195.85,12.25 204.77,12.25 206.15,13.62 206.15,17.43 v4(206.96,18.23)
  IN3 w0.13: v4(206.96,18.23) 207.11,18.23 208.04,17.31 212.15,17.31 214.06,19.22 218.98,19.22 219.53,18.68 221.4,18.68 222.36,17.72 228.13,17.72 228.8,17.06 235.78,17.06 236.5,17.78 240.8,17.78 241.99,16.59 250.98,16.59 251.55,17.16 251.97,17.16 253.5,15.63 256.74,15.63 256.8,15.69 258.56,15.69 258.76,15.9 259.99,15.9 260.79,15.09 270.16,15.09 271.37,16.3 279.99,16.3 281.56,17.87 281.56,30.09 v1(280.54,31.11)
HDA_SDOUT: length 6.5
  TOP w0.089: 276.98,31.88 277.14,31.88 ; 276.98,31.88 v1(276.98,31.9) ; 276.98,31.88 276.31,31.88 RH23.2 276.29,32.55 v2(276.59,32.85)
  TOP w0.102: 277.14,31.88 277.78,31.88 CH2.2 278.67,31.9 RH15.2 RH11.2
  BOTTOM w0.089: U7.A24 276.47,31.37 276.67,31.57 276.67,31.57 276.98,31.88 v1(276.98,31.9)
HDA_SDOUT_5505: length 27
  TOP w0.102: U12.24 16.17,30.27 v1(16.32,30.41) 16.62,30.72 RA68.2 ; v1(29.86,40.38) 29.09,40.38 28.68,40.79 U15.4
  IN3 w0.102: v1(29.86,40.38) 29.52,40.04 29.52,35.66 28.61,34.76 27.67,34.76 27.57,34.86 27.57,35.85 27.47,35.95 27.27,35.95 27.16,35.85 27.16,34.86 27.06,34.76 26.47,34.76 24.16,32.44 19.54,32.44 18.54,31.44 17.27,31.44 16.32,30.49 v1(16.32,30.41)
  BOTTOM w0.102: v1(29.86,40.38) 30,40.38 v2(30.29,40.09)
HDA_SDOUT_5505_R: length 17.4
  TOP w0.102: v3(28.1,23.88) 28.61,23.38 v2(28.97,23.38)
  GND1 w0.102: v3(16.62,32.11) v5(16.62,31.71) ; v3(28.1,23.88) v5(27.72,23.88)
  IN1 w0.102: v5(16.62,31.71) 16.95,31.38 16.95,30.36 17.51,29.8 20.61,29.8 23.68,26.73 23.86,26.73 24.22,26.37 24.22,25.33 24.9,24.65 26.48,24.65 27.24,23.88 v5(27.72,23.88)
HDA_SDOUT_AUDIO: length 311.3
  TOP w0.102: U12.5 23.05,25.23 v1(23.54,25.72) 23.54,25.6 23.73,25.41 23.73,24.52 v2(23.84,24.42) 24.06,24.19 25.58,24.19 CA95.1 26.5,24.82 26.6,24.72 26.6,24.47 RA63.1 ; v3(280.24,32.44) 280.15,32.44 RH15.1
  GND1 w0.102: v3(280.24,32.44) 280.26,32.42 280.8,32.42 v4(280.91,32.54)
  IN3 w0.13: v4(280.91,32.54) 281.54,32.54 282.23,31.85 282.23,17.59 280.04,15.41 272.13,15.41 271.16,14.43 269.99,14.43 268.58,13.02 264.72,13.02 264.17,13.57 260.6,13.57 260,14.17 258.87,14.17 258.07,14.97 245.83,14.97 244.88,15.92 241.61,15.92 240.42,17.12 236.78,17.12 236.06,16.39 228.28,16.39 227.62,17.05 222.08,17.05 221.13,18.01 219.25,18.01 218.71,18.55 214.57,18.55 212.59,16.57 207.78,16.57 207.06,17.3 203.95,17.3 203.11,16.46 202.51,16.46 202.32,16.65 198.06,16.65 191.88,22.83 190.34,22.83 190.11,22.61 188.23,22.61 187.42,23.41 184.25,23.41 183.66,24 180.01,24 175.34,28.67 172.87,28.67 167.87,33.67 165.79,33.67 164.76,34.7 111.39,34.7 110.19,33.5 106.64,33.5 105.78,32.63 89.57,32.63 88.09,31.15 85.02,31.15 83.55,32.62 77.58,32.62 76.67,31.71 74.65,31.71 74.1,31.16 71.72,31.16 71.22,31.66 66.19,31.66 65.79,32.05 61.01,32.05 59.71,33.35 52.29,33.35 50.81,34.84 46.27,34.84 41.95,39.16 37.49,39.16 30.57,32.25 30.57,27.8 29.63,26.86 27.6,26.86 26.46,25.72 v1(23.54,25.72)
HDA_SPKR: length 264.3
  TOP w0.089: v1(262.12,25.1) 262.07,25.1 261.43,25.74 261.43,26.39 261.01,26.81 259.89,26.81 259.25,27.45 257.57,27.45 256.6,28.42 RH17.2 254.79,27.95 254.47,27.95
  TOP w0.102: RA10.2 30.54,36.65 31.46,36.65 32.14,37.33 v1(32.14,37.35) ; 254.47,27.95 249.17,27.95 v2(248.66,27.43) 247.67,26.44 v1(247.67,20.11)
  IN3 w0.13: v1(32.14,37.35) 33.02,37.35 34.66,38.99 34.66,38.99 36.5,40.83 42.98,40.83 46.18,37.62 47.41,37.62 48.51,36.53 51.47,36.53 52.97,35.03 63.06,35.03 64.37,33.71 66.48,33.71 66.82,33.37 75.55,33.37 76.47,34.3 104.73,34.3 105.77,35.33 109.2,35.33 109.54,35.67 109.54,38.9 111.07,40.43 158.22,40.43 158.94,39.71 165.04,39.71 166.61,38.14 166.61,35.79 167.07,35.33 169.28,35.33 172.82,31.79 174.58,31.79 180.7,25.67 193.35,25.67 196.65,22.37 196.65,21.31 198.75,19.21 202.75,19.21 203.51,19.97 209.7,19.97 210.61,20.88 219.92,20.88 220.47,20.34 224.65,20.34 225.25,19.74 225.61,19.74 226.21,20.34 231.12,20.34 231.53,19.93 237.68,19.93 238.09,20.34 247.44,20.34 v1(247.67,20.11)
  BOTTOM w0.089: v1(262.12,25.1) 262.4,25.38 U7.AL10
HDA_SYNC: length 5
  BOTTOM w0.089: 277.14,30.56 276.17,30.56 276.16,30.57 275.62,30.57 275.61,30.56 275.12,30.56 U7.A22
  BOTTOM w0.102: 277.14,30.56 v2(277.23,30.56) 277.68,30.56 277.69,30.55 RH8.2 ; RH7.2 RH8.2 ; RH8.2 RH32.2
HDA_SYNC_5505: length 26.9
  TOP w0.102: RA65.2 19.32,31.68 18.58,30.95 v1(18.58,30.67) 18.67,30.57 U12.19 ; U15.9 28.59,42.79 28.71,42.67 29.04,42.67 v1(29.49,43.11)
  IN3 w0.102: v1(29.49,43.11) 29.49,41.7 30.27,40.92 30.27,39.88 30.16,39.78 29.83,39.78 29.73,39.68 29.73,39.48 29.83,39.37 30.16,39.37 30.27,39.27 30.27,39.07 30.16,38.97 29.83,38.97 29.72,38.86 29.72,35.51 28.74,34.53 26.53,34.53 24.24,32.24 19.92,32.24 18.58,30.9 v1(18.58,30.67)
HDA_SYNC_5505_R: length 9.3
  TOP w0.102: v2(20.2,33.49) 20.15,33.49 19.42,32.75 v3(19.42,32.6)
  GND1 w0.102: v3(25.41,28.2) v5(25,28.2) ; v3(19.42,32.6) v5(19.42,32.16)
  IN1 w0.102: v5(25,28.2) 23.76,29.45 22.95,29.45 20.66,31.73 19.85,31.73 v5(19.42,32.16)
HDA_SYNC_AUDIO: length 299.1
  TOP w0.102: CA93.1 25.82,28.76 24.88,28.76 24.5,28.38 RA57.1 24.32,28.02 v1(23.71,28.02) 23.25,28.02 22.96,27.73 U12.10
  IN3 w0.13: v4(279.75,30.13) 280.82,29.05 280.82,26.2 280.19,25.57 280.19,20.96 280.46,20.69 280.46,19.62 278.12,17.29 270.35,17.29 269.01,15.95 262.67,15.95 261.91,16.7 259.51,16.7 259.07,17.15 255.64,17.15 255.49,17.31 254.29,17.31 253.38,18.22 253.15,18.22 253.01,18.08 250.11,18.08 249.53,18.67 247.58,18.67 246.9,19.34 238.5,19.34 237.93,18.77 231.28,18.77 230.71,19.34 226.62,19.34 226.03,18.75 224.84,18.75 224.24,19.34 220.05,19.34 219.51,19.88 213.56,19.88 212.65,18.97 204.18,18.97 202.85,17.63 198.02,17.63 194.22,21.44 194.22,22.54 192.68,24.08 184.53,24.08 183.94,24.67 180.29,24.67 175.62,29.33 173.15,29.33 168.15,34.33 166.2,34.33 165.08,35.46 111.07,35.46 109.87,34.25 106.23,34.25 105.27,33.3 76.89,33.3 75.97,32.38 66.41,32.38 66.07,32.72 63.27,32.72 62.73,33.26 60.85,33.26 60.08,34.03 52.56,34.03 51.06,35.53 48.1,35.53 47.04,36.59 45.68,36.59 42.44,39.83 36.91,39.83 29.91,32.83 29.91,28.08 29.36,27.52 25.89,27.52 25.39,28.02 v1(23.71,28.02)
  GND3 w0.102: v4(279.75,30.13) 279.73,30.13 279.2,29.6 v7(279.16,29.6)
HDD_DETECT#: length 311.4
  TOP w0.089: v1(268.56,26.2) 268.08,25.73 v2(268.08,24.79) 267.96,24.66 267.96,22.47 267.34,21.86 267.34,19.81 267.49,19.66
  TOP w0.102: RPH7.7 270.56,13 268.94,14.62 268.94,18.4 268.29,19.05 268.1,19.05 267.49,19.66
  IN2 w0.089: 262.75,19.66 265.5,22.42 267.51,22.42 267.97,22.87 267.97,25.61 v1(268.56,26.2)
  IN2 w0.102: v1(240.74,18.76) 241.49,19.5 249.77,19.5 250.27,20 252.83,20 253.64,19.18 262.27,19.18 262.75,19.66
  IN3 w0.102: v4(157.67,11.75) 158.16,11.25 173.08,11.25 174.06,12.24 190.17,12.24 191.13,11.27 210.86,11.27 212.18,12.59 212.18,12.95 214.45,15.22 217.02,15.22 221.21,11.02 233.92,11.02 234.53,11.63 235.31,11.63 235.62,11.95 v1(235.62,12.24)
  IN4 w0.102: v1(41.16,38.64) 41.48,38.64 45.12,35 48.19,35 51.94,31.25 51.94,25.83 52.77,25 58.13,25 60.9,27.77 61.53,27.77 62.85,29.09 66.55,29.09 68.26,27.38 69.95,27.38 70.37,27.8 71.97,27.8 73.52,26.25 75.69,26.25 79.72,22.22 104.67,22.22 109.51,17.38 111.99,17.38 112.8,16.57 117.8,16.57 118.31,16.06 126.11,16.06 126.83,16.78 128.43,16.78 128.73,17.08 141.2,17.08 143.97,14.32 143.97,13.95 144.29,13.63 147.58,13.63 148.97,15.02 153.79,15.02 155.65,13.16 156.54,13.16 157.67,12.03 v4(157.67,11.75)
  BOTTOM w0.089: v1(268.56,26.2) 268.44,26.2 U7.U12
  BOTTOM w0.102: v1(235.62,12.24) 235.62,13.39 236.64,14.41 236.64,18.04 237.78,19.18 240.32,19.18 v1(240.74,18.76) ; JHDD.12 26.3,27.36 25.59,28.07 25.59,33.03 26.3,33.74 27.52,33.74 28.2,34.42 28.2,36.1 28.89,36.79 30.31,36.79 31.1,37.57 31.1,39.13 32.25,40.28 34.1,40.28 34.72,40.9 40.32,40.9 41.03,40.19 41.03,38.77 v1(41.16,38.64)
HDMI_A0N_VGA: length 241.7
  TOP w0.102: v3(30.73,93.73) 30.62,93.84 30.62,94.08 CV760.2
  GND1 w0.102: v5(30.79,94.66) 30.79,94.61 30.64,94.47 30.64,93.82 v3(30.73,93.73)
  IN1 w0.089: v1(165.34,102.9) 165.61,102.9 165.7,102.98 165.7,103.24 165.65,103.29 165.2,103.29 165.15,103.34 165.15,106.23 163.8,107.58 149.7,107.58 144.99,112.29 136.54,112.29 133.04,108.78 133.04,101.99 131.69,100.64 131.69,99.13 127.67,95.11 127.67,67.72 119.51,59.56 119.51,56.64 106.37,43.5 98.16,43.5 96.79,42.13 90.85,42.13 90.06,41.34 72.91,41.34 72.66,41.09 59.06,41.09 56.6,43.54 50.79,43.54 42.58,51.75 37.23,51.75 34.12,54.86 34.12,65.9 33.56,66.47 33.56,69.14 33.95,69.53 33.95,83.25 35.05,84.36 35.05,91.49 34.33,92.21 34.33,92.39 32.47,94.25 30.59,94.25 30.54,94.3 30.54,94.39 30.79,94.63 v5(30.79,94.66)
  BOTTOM w0.089: v1(165.34,102.9) 165,103.24 U6.C24
HDMI_A0P_VGA: length 241.6
  TOP w0.102: v3(30.3,93.73) 30.41,93.84 30.41,94.08 CV761.2
  GND1 w0.102: v3(30.3,93.73) 30.3,93.77 30.46,93.93 30.46,94.48 30.35,94.58 v5(30.35,94.66)
  IN1 w0.089: v5(30.35,94.66) 30.35,94.23 30.52,94.06 32.4,94.06 34.15,92.31 34.15,92.13 34.87,91.41 34.87,84.43 33.76,83.33 33.76,69.6 33.37,69.22 33.37,66.39 33.94,65.83 33.94,54.79 37.16,51.57 42.5,51.57 50.71,43.36 56.53,43.36 58.98,40.9 72.73,40.9 72.99,41.16 90.14,41.16 90.93,41.94 96.87,41.94 98.24,43.31 106.44,43.31 119.69,56.56 119.69,59.48 127.85,67.65 127.85,95.04 131.87,99.05 131.87,100.56 133.22,101.91 133.22,108.71 136.62,112.11 144.91,112.11 149.62,107.4 163.73,107.4 164.97,106.15 164.97,102.49 v1(165.3,102.17)
  BOTTOM w0.089: U6.D24 164.92,102.54 v1(165.3,102.17)
HDMI_A1N_VGA: length 242.5
  TOP w0.102: CV762.2 28.85,94.08 28.85,93.83 v3(28.96,93.71)
  GND1 w0.102: v5(28.96,93.09) 28.83,93.22 28.83,93.59 v3(28.96,93.71)
  IN1 w0.089: v5(28.96,93.09) 28.96,93.07 28.71,92.82 28.71,92.24 28.97,91.97 30.01,91.97 30.11,92.07 30.11,93.35 30.34,93.59 30.85,93.59 31.08,93.35 31.08,92.06 31.17,91.97 32.63,91.97 33.36,91.24 33.36,85.09 32.61,84.33 32.61,71.19 31.8,70.38 31.8,65.63 32.25,65.18 32.25,54.89 38.26,48.88 41.79,48.88 46.32,44.35 46.32,42.75 47.15,41.92 53.71,41.92 55.85,39.78 73.2,39.78 73.45,40.03 78.38,40.03 78.58,39.84 78.58,39.71 78.7,39.58 78.9,39.58 79.02,39.71 79.02,39.84 79.22,40.03 90.61,40.03 91.39,40.82 97.71,40.82 99.08,42.19 106.91,42.19 121.01,56.29 121.01,59.22 128.98,67.18 128.98,94.2 129.81,95.03 130.24,95.03 131.9,96.69 131.9,97.28 134.34,99.72 134.34,108.24 137.08,110.98 143.73,110.98 145.33,109.38 146.04,109.38 149.15,106.27 161.77,106.27 162.67,105.37 163.12,104.92 163.16,104.88 163.33,104.71 163.51,104.71 163.71,104.91 v1(163.71,104.99)
  BOTTOM w0.089: v1(163.71,104.99) 164.06,104.64 U6.A25
HDMI_A1P_VGA: length 242.7
  TOP w0.102: v3(28.52,93.71) 28.64,93.83 28.64,94.08 CV763.2
  GND1 w0.102: v5(28.52,93.09) 28.65,93.22 28.65,93.59 v3(28.52,93.71)
  IN1 w0.089: v1(163.67,104.26) 163.67,104.27 163.43,104.5 163.28,104.5 163.03,104.75 162.54,105.24 161.69,106.09 149.07,106.09 145.96,109.2 145.25,109.2 143.65,110.8 137.16,110.8 134.53,108.17 134.53,99.65 132.08,97.2 132.08,96.61 130.32,94.85 129.88,94.85 129.16,94.13 129.16,67.1 121.19,59.14 121.19,56.22 106.99,42.01 99.15,42.01 97.78,40.64 91.47,40.64 90.68,39.85 79.29,39.85 79.21,39.76 79.21,39.63 78.97,39.4 78.63,39.4 78.39,39.63 78.39,39.76 78.31,39.85 73.53,39.85 73.27,39.6 55.77,39.6 53.63,41.73 47.08,41.73 46.14,42.67 46.14,44.27 41.72,48.69 38.18,48.69 32.07,54.81 32.07,65.1 31.62,65.55 31.62,70.46 32.42,71.26 32.42,84.41 33.18,85.16 33.18,91.17 32.56,91.79 31.1,91.79 30.9,91.99 30.9,93.28 30.77,93.4 30.42,93.4 30.29,93.28 30.29,92 30.08,91.79 28.9,91.79 28.52,92.16 v5(28.52,93.09)
  BOTTOM w0.089: v1(163.67,104.26) 163.99,103.94 U6.B25
HDMI_A2N_VGA: length 242.4
  TOP w0.102: CV764.2 27.07,94.08 27.07,93.95 v3(27.18,93.84)
  GND1 w0.102: v5(27.18,93.42) 27.06,93.55 27.06,93.72 v3(27.18,93.84)
  IN1 w0.089: v1(164.51,103.63) 164.51,103.42 164.36,103.28 163.35,103.28 162.04,104.58 159.62,104.58 158.58,105.62 147.29,105.62 142.58,110.33 137.36,110.33 135,107.97 135,99.39 132.59,96.98 132.59,96.32 131.18,94.9 131.18,93.03 129.63,91.48 129.63,66.91 121.66,58.94 121.66,56.02 107.18,41.54 99.38,41.54 98.01,40.17 91.66,40.17 90.29,38.8 72.95,38.8 72.11,37.96 67.19,37.96 66.02,39.13 55.46,39.13 53.43,41.16 46.98,41.16 45.58,42.55 45.58,43.89 41.26,48.22 38,48.22 31.6,54.61 31.6,64.84 31.15,65.29 31.15,74.1 31.95,74.9 31.95,84.82 32.65,85.52 32.65,90.74 32.15,91.24 28.59,91.24 26.93,92.91 26.93,93.15 27.18,93.4 v5(27.18,93.42)
  BOTTOM w0.089: U6.C25 164.12,103.24 v1(164.51,103.63)
HDMI_A2P_VGA: length 242.4
  TOP w0.102: v3(26.75,93.84) 26.86,93.95 26.86,94.08 CV765.2
  GND1 w0.102: v5(26.75,93.42) 26.87,93.55 26.87,93.72 v3(26.75,93.84)
  IN1 w0.089: v1(164.5,102.88) 164.29,103.09 163.27,103.09 161.97,104.4 159.55,104.4 158.51,105.44 147.21,105.44 142.5,110.15 137.43,110.15 135.18,107.9 135.18,99.31 132.78,96.91 132.78,96.24 131.36,94.83 131.36,92.95 129.81,91.4 129.81,66.83 121.85,58.87 121.85,55.95 107.26,41.36 99.45,41.36 98.08,39.99 91.74,39.99 90.37,38.61 73.02,38.61 72.18,37.77 67.12,37.77 65.95,38.94 55.39,38.94 53.36,40.97 46.9,40.97 45.4,42.47 45.4,43.82 41.18,48.03 37.92,48.03 31.42,54.54 31.42,64.76 30.97,65.21 30.97,74.18 31.77,74.98 31.77,84.9 32.46,85.59 32.46,90.67 32.07,91.06 28.52,91.06 26.75,92.83 v5(26.75,93.42)
  BOTTOM w0.089: U6.D25 164.11,102.54 164.45,102.88 v1(164.5,102.88)
HDMI_A3N_VGA: length 241.7
  TOP w0.102: CV758.2 32.4,94.08 32.4,93.76 v3(32.51,93.65)
  GND1 w0.102: v5(32.51,93.22) 32.39,93.34 32.39,93.53 v3(32.51,93.65)
  IN1 w0.089: v5(32.51,93.22) 32.45,93.16 32.45,92.82 32.52,92.75 32.85,92.75 34.4,91.2 34.4,84.98 33.26,83.85 33.26,70.82 32.46,70.02 32.46,66.5 33.47,65.48 33.47,54.59 38.49,49.57 43.06,49.57 46.99,45.63 46.99,43 47.12,42.88 47.31,42.88 47.44,43 47.44,44.56 47.67,44.79 48.01,44.79 48.25,44.56 48.25,42.69 48.34,42.6 48.6,42.6 48.69,42.69 48.69,43.24 48.93,43.48 49.27,43.48 49.89,42.86 54.04,42.86 56.47,40.43 72.93,40.43 73.18,40.69 90.33,40.69 91.12,41.47 97.22,41.47 98.59,42.84 106.64,42.84 120.36,56.56 120.36,59.49 128.32,67.45 128.32,94.69 133.69,100.06 133.69,108.51 136.81,111.64 144.72,111.64 149.43,106.93 162.72,106.93 164.15,105.5 164.25,105.39 164.32,105.39 164.54,105.61 164.64,105.61 164.71,105.55 164.71,105.23 v1(164.48,105)
  BOTTOM w0.089: U6.A24 164.83,104.64 v1(164.48,105)
HDMI_A3P_VGA: length 242.1
  TOP w0.102: v3(32.08,93.65) 32.19,93.76 32.19,94.08 CV759.2
  GND1 w0.102: v5(32.08,93.22) 32.2,93.34 32.2,93.53 v3(32.08,93.65)
  IN1 w0.089: v1(164.5,104.26) 164.1,104.67 164.1,105.29 164.02,105.37 162.64,106.74 149.35,106.74 144.64,111.45 136.89,111.45 133.87,108.44 133.87,99.98 128.51,94.61 128.51,67.37 120.54,59.41 120.54,56.49 106.72,42.66 98.66,42.66 97.29,41.29 91.2,41.29 90.41,40.5 73.26,40.5 73,40.25 56.39,40.25 53.97,42.67 49.81,42.67 49.19,43.29 49,43.29 48.88,43.17 48.88,42.61 48.68,42.41 48.26,42.41 48.07,42.61 48.07,44.48 47.94,44.61 47.75,44.61 47.62,44.48 47.62,42.93 47.39,42.69 47.04,42.69 46.81,42.93 46.81,45.56 42.98,49.39 38.42,49.39 33.29,54.52 33.29,65.41 32.27,66.42 32.27,70.1 33.08,70.9 33.08,83.92 34.21,85.06 34.21,91.13 32.77,92.57 32.44,92.57 32.26,92.75 32.26,93.01 32.08,93.2 v5(32.08,93.22)
  BOTTOM w0.089: U6.B24 164.98,104.01 164.98,104.16 164.82,104.33 164.56,104.33 v1(164.5,104.26)
HDMI_BUF: length 5.7
  TOP w0.102: U22.14 32.88,99.3 v1(32.92,99.34)
  BOTTOM w0.102: v2(33.92,98.94) 33.52,99.34 v1(32.92,99.34) 32.51,99.74 32.51,100.48 33.08,101.05 RV430.1 RV431.2
HDMI_CEC: length 10.5
  TOP w0.089: JHDMI.13 11.35,111.12 11.35,111.3 arc(11.28,111.41) 11.23,111.53 arc(11.21,111.66) 11.22,111.79 arc(11.24,111.85) 11.25,111.92 11.29,112.04 11.29,112.05 arc(11.3,112.25) 11.26,112.44 11.24,112.52 arc(11.23,112.56) 11.22,112.59 arc(11.2,112.69) 11.21,112.79 11.25,112.9 arc(11.27,112.98) 11.29,113.05 arc(11.31,113.21) 11.29,113.37 11.2,113.65 11.2,114.04 11.21,114.06
  TOP w0.102: CV796.2 13.89,110.94 12.95,110.94 12.57,111.32 12.57,114.37 12.38,114.56 11.56,114.56 11.21,114.22 11.21,114.06
HDMI_DDB_CTRLCLK: length 357.2
  TOP w0.089: v1(270.9,41.52) 270.9,42 271.11,42.2
  TOP w0.102: v1(26.11,98.55) 26.46,98.9 U22.38 ; 271.11,42.2 v8(271.72,42.82) 271.9,43 272.78,43 272.85,43.06 RPH16.1
  IN4 w0.076: v1(26.11,98.55) 26.15,98.5 26.15,97.77 25.25,96.86 22.92,96.86 22.29,97.49 12.78,97.49 12.04,96.74 12.04,90.51 21.55,81 24.55,81 25.44,80.11 25.44,74.3 24.32,73.19 24.32,71.38 26.32,69.39 26.32,67.76 26.88,67.2 26.88,64.22 27.54,63.55 27.54,62.62 28.99,61.18 28.99,55.77 29.37,55.38 29.37,52.28 29.81,51.85 29.81,49.55 34.71,44.65 40.77,44.65 45.6,39.82 47.55,39.82 48.96,38.41 48.96,37.71 51.62,35.05 53.01,35.05 54.79,33.26 56.8,33.26 58.52,31.55 62.98,31.55 63.35,31.17 66.61,31.17 67.11,31.67 71.67,31.67 72.3,31.03 86.66,31.03 87.64,32.01 91.97,32.01 92.94,31.03 100.22,31.03 110.7,20.55 117.45,20.55 117.81,20.2 122.39,20.2 122.88,20.69 128.11,20.69 128.5,20.29 148.28,20.29 149.19,19.39 156.63,19.39 157.65,20.42 167.07,20.42 168.5,18.99 171.77,18.99 172.08,18.68 198.8,18.68 200.9,20.77 202.61,20.77 207.92,26.08 207.92,35.86 213.47,41.41 254.07,41.41 254.49,41.84 258.65,41.84 260.31,40.18 264.64,40.18 265.47,39.35 267.82,39.35 268.21,38.96 268.21,38.58 268.6,38.2 269.2,38.2 v6(269.35,38.35)
  IN4 w0.089: v6(269.35,38.35) 269.55,38.15 270.72,38.15 271.32,38.75 271.32,39.23 272.48,40.39 272.48,41.06 271.81,41.73 271.11,41.73 v1(270.9,41.52)
  GND3 w0.089: v7(269.05,38.35) v6(269.35,38.35)
HDMI_DDB_CTRLDATA: length 359.3
  TOP w0.089: 272.14,42.2 v1(270.9,40.97)
  TOP w0.102: RPH16.2 272.5,42.56 272.14,42.2 ; U22.39 26.64,98.5 26.07,97.93 v1(25.76,97.93)
  IN4 w0.076: v1(25.76,97.93) 25.6,97.77 12.61,97.77 11.72,96.88 11.72,90.38 21.39,80.72 24.44,80.72 25.16,79.99 25.16,74.42 24.04,73.3 24.04,71.26 26.04,69.27 26.04,67.65 26.6,67.08 26.6,64.1 27.27,63.43 27.27,61.63 28.71,60.19 28.71,55.65 29.09,55.27 29.09,52.15 29.53,51.72 29.53,49.44 34.59,44.37 40.65,44.37 45.48,39.54 47.43,39.54 48.68,38.29 48.68,37.59 51.51,34.77 52.89,34.77 54.68,32.98 56.68,32.98 58.4,31.27 62.86,31.27 63.23,30.89 66.73,30.89 67.22,31.39 71.55,31.39 72.19,30.75 84.34,30.75 84.34,30.75 86.78,30.75 87.76,31.73 91.85,31.73 92.83,30.75 100.1,30.75 110.58,20.27 117.11,20.27 117.46,19.92 122.51,19.92 123,20.41 128,20.41 128.39,20.02 148.17,20.02 149.1,19.08 156.93,19.08 157.98,20.14 166.89,20.14 168.32,18.71 171.09,18.71 172.14,17.66 176.24,17.66 176.97,18.4 198.92,18.4 200.97,20.45 202.69,20.45 208.2,25.96 208.2,35.74 213.59,41.14 254.27,41.14 254.78,41.64 258.6,41.64 260.24,40 264.57,40 265.4,39.18 267.72,39.18 268.02,38.88 268.02,38.5 268.52,38.01 269.1,38.01 v6(269.35,37.75)
  IN4 w0.089: v1(270.9,40.97) 270.5,41.37 270.5,41.69 270.72,41.92 271.89,41.92 272.67,41.14 272.67,40.31 271.51,39.15 271.51,38.67 270.8,37.96 269.56,37.96 v6(269.35,37.75)
  GND3 w0.089: v7(269.05,37.75) v6(269.35,37.75)
HDMI_EQ: length 6.1
  TOP w0.102: U22.17 32.67,100.5 32.7,100.53 33.33,100.53 33.5,100.36 35.05,100.36 v3(35.18,100.49) 35.62,100.49 v2(35.83,100.29)
  GND1 w0.102: v4(35.05,101.26) 35.18,101.13 v3(35.18,100.49)
  GND3 w0.102: v4(35.05,101.26) 34.84,101.05 v7(34.67,101.05)
  BOTTOM w0.102: RV448.2 v7(34.67,101.05)
HDMI_HPLUG: length 24
  TOP w0.102: v3(28.57,103.12) U22.28 ; v1(13.59,112.4) CV768.2 14.34,113.19 v2(14.67,113.52)
  GND1 w0.102: v4(28.26,103.58) 28.57,103.27 v3(28.57,103.12)
  IN4 w0.102: v4(28.26,103.58) 28.19,103.58 26.6,105.16 22.13,105.16 16.24,111.06 14.93,111.06 v1(13.59,112.4) 13.07,112.4 JHDMI.19
HDMI_ISET: length 4.9
  TOP w0.102: v2(22.67,100.03) 22.91,99.79 23.44,99.79 24,100.35 RV460.2 RV459.1 25.48,100.62 26.42,100.62 26.54,100.5 U22.34
HDMI_PCH_HPD: length 330.7
  TOP w0.102: U22.3 28.57,96.53 28.07,96.03 v1(28.07,95.96)
  IN2 w0.102: v1(28.07,95.96) 25.48,93.37 23.24,93.37 20.59,90.71 20.59,88.07 23.81,84.84 29.29,84.84 32.29,81.84 32.29,71.15 31.86,70.72 31.86,62.1 32.35,61.61 32.35,55.9 39.45,48.8 41.89,48.8 48.83,41.87 53.96,41.87 55.96,39.86 61.67,39.86 62.07,39.45 69.7,39.45 71.51,37.64 72.08,37.64 73.03,38.59 74.23,38.59 74.54,38.27 91.02,38.27 93.47,40.72 98.93,40.72 104.31,35.35 167.35,35.35 171.73,30.96 171.73,26.08 172.93,24.87 175.4,24.87 176.81,26.28 178.79,26.28 179.77,25.3 245.67,25.3 247.37,27 247.37,31.19 248.2,32.02 v4(248.2,40.63)
  IN4 w0.089: 254.47,40.2 257.36,40.2 257.81,40.65 259.33,40.65 260.16,39.82 264.49,39.82 266.64,37.67 267.92,37.67 268.5,37.09 270.01,37.09 270.29,37.37 270.79,37.37 v4(271.54,38.12)
  IN4 w0.102: 254.47,40.2 248.63,40.2 v4(248.2,40.63)
  GND3 w0.089: v4(271.54,38.12) 271.51,38.15 v7(270.64,38.15)
  BOTTOM w0.089: U7.K40 270.84,38.35 v7(270.64,38.15)
HDMI_PD#: length 4.2
  TOP w0.102: T118.1 23.48,98.88 25.43,98.88 26.26,99.7 U22.36
HDMI_PRE: length 7.7
  TOP w0.102: v2(35.77,98.18) 35.77,99.75 35.45,100.08 v3(35.3,100.08) 35.22,100.16 33.42,100.16 33.25,100.33 32.78,100.33 32.55,100.1 U22.16
  GND1 w0.102: v4(35.68,100.4) 35.35,100.08 v3(35.3,100.08)
  GND3 w0.102: v7(35.56,101.05) 35.56,100.52 v4(35.68,100.4)
  BOTTOM w0.102: RV450.2 v7(35.56,101.05)
HDMI_RESERVED: length 10.4
  TOP w0.089: JHDMI.14 11.05,111.84 arc(11.07,111.9) 11.08,111.96 11.12,112.08 11.12,112.09 arc(11.13,112.24) 11.1,112.39 11.07,112.47 arc(11.06,112.5) 11.05,112.53 arc(11.02,112.69) 11.04,112.84 11.08,112.95 arc(11.1,113.03) 11.12,113.1 arc(11.13,113.21) 11.12,113.32 11.02,113.63 11.02,113.8 10.91,113.91 10.91,114.06
  TOP w0.102: CV795.2 14.13,111.25 13.08,111.25 12.88,111.45 12.88,114.5 12.51,114.87 11.43,114.87 10.91,114.35 10.91,114.06
HP2_OUTL: length 5.2
  TOP w0.203: 18.3,44.84 18.68,44.84 18.85,45 20.25,45 v2(20.6,44.65) 20.93,44.33 20.93,44.06 21.4,43.59 U15.26
  TOP w0.254: 18.3,44.84 18.15,44.69 RA18.1
HP2_OUTL_R: length 22.9
  TOP w0.102: CA38.1 v2(15.05,46.97)
  TOP w0.254: CA38.1 15.14,45.89 LA5.2 14.97,44.67 RA92.2 RA93.2 14.97,42.24 v1(14.77,42.03)
  IN4 w0.254: v1(16.57,43.06) 14.31,45.32 14.31,45.91 13.58,46.64 JHP2.1
  BOTTOM w0.254: UA2.A1 12.18,35.6 12.79,36.2 RA2.1 15.02,37.75 15.02,39.66 14.57,40.11 14.57,41.83 v1(14.77,42.03) 14.77,42.73 DA2.2 16.31,43.32 v1(16.57,43.06)
HP2_OUTR: length 15.4
  TOP w0.203: v1(19.14,44.41) 19.33,44.6 20.1,44.6 20.55,44.15 20.55,43.96 21.32,43.19 U15.27
  TOP w0.254: RA17.1 18.26,37.78 v1(18.26,36.9)
  IN1 w0.254: v1(19.14,44.41) 18.94,44.41 18.68,44.16 18.68,43.6 19.11,43.17 19.11,38.71 18.26,37.86 v1(18.26,36.9)
  BOTTOM w0.102: v2(19.77,36.36) 18.65,36.36 18.26,36.75 v1(18.26,36.9)
HP2_OUTR_R: length 17
  TOP w0.102: RA94.2 14.72,40.65 14.72,41.26 15,41.54 v8(15.15,41.54)
  TOP w0.254: v3(14.21,34.93) 14.21,36.57 CA33.1 15.13,37.49 LA6.2 15.13,39.28 RA95.1 RA94.2
  GND1 w0.254: v3(14.21,34.93) 14.23,35.16 v5(14.46,35.39)
  IN1 w0.254: v5(14.46,35.39) 14.41,35.34 v4(13.9,35.34)
  IN4 w0.254: v6(11.29,35.34) v4(13.9,35.34)
  GND3 w0.254: v7(10.78,35.52) 11.11,35.52 v6(11.29,35.34)
  BOTTOM w0.254: UA2.A3 v7(10.78,35.52) 10.01,35.52 RA3.1 9.28,36.26 8.74,36.26 7.91,37.09 JHP2.2
HWPG: length 12.6
  TOP w0.089: UE1.F1 164.28,14.41
  TOP w0.102: v1(156.46,14.42) 156.61,14.27 v2(156.61,13.51) 156.44,13.33 RE29.2 RE27.2 ; 164.28,14.41 164.42,14.28 v3(164.42,14.23)
  GND1 w0.076: v4(164.02,13.85) 164.41,14.23 v3(164.42,14.23)
  IN3 w0.076: 160.65,14.52 160.65,14.51 160.66,14.5 162.27,14.5 162.77,14.01 163.86,14.01 v4(164.02,13.85)
  IN3 w0.102: 160.65,14.52 156.56,14.52 v1(156.46,14.42)
I2C_EN8723: length 1.9
  TOP w0.102: RI6.1 30.88,61.55 UI5.6
I2CA_SCL: length 21.4
  TOP w0.102: RPH13.1 219.25,66.16 v1(219.45,66.37) ; v2(219.92,62.09) 219.52,62.49 v1(219.45,62.49)
  IN4 w0.089: v6(218.45,80.02) 218.32,79.89 218.32,77.32
  IN4 w0.102: 218.32,77.32 218.32,67.5 v1(219.45,66.37) v1(219.45,62.49)
  GND3 w0.089: v7(218.76,80.24) 218.67,80.24 v6(218.45,80.02)
  BOTTOM w0.089: UV1.R4 v7(218.76,80.24)
  BOTTOM w0.102: v1(219.45,62.49) 219.25,62.69 RPH15.1
I2CA_SDA: length 21.9
  TOP w0.102: v1(218.81,66.38) 218.75,66.32 RPH13.2
  IN4 w0.089: 218.12,77.32 218.12,79.74 217.89,79.97 v6(217.89,80.75)
  IN4 w0.102: 218.12,77.32 218.12,67.06 v1(218.81,66.38) v1(218.81,62.49)
  GND3 w0.089: v7(217.99,81.18) 217.89,81.08 v6(217.89,80.75)
  BOTTOM w0.089: UV1.R5 218.21,81.4 v7(217.99,81.18)
  BOTTOM w0.102: RPH15.2 218.75,62.55 v1(218.81,62.49) ; v1(218.81,66.38) 218.81,66.61 218.96,66.76 219.09,66.76 v2(219.16,66.84)
I2CB_SCL: length 23.8
  TOP w0.102: v1(218.17,66.35) 218.25,66.27 RPH13.3 ; v2(217.89,62.97) 218.17,62.7 v1(218.17,62.49)
  IN4 w0.089: v1(217.45,82.53) 217.59,82.38 217.59,79.92 217.92,79.6 217.92,77.32
  IN4 w0.102: v1(218.17,62.49) v1(218.17,66.35) 217.92,66.61 217.92,77.32
  BOTTOM w0.089: v1(217.45,82.53) 217.83,82.53 UV1.R7
  BOTTOM w0.102: RPH15.3 218.25,62.57 v1(218.17,62.49)
I2CB_SDA: length 23.3
  TOP w0.102: RPH13.4 217.75,66.19 v1(217.59,66.35)
  IN4 w0.089: v6(217.3,81.21) 217.3,79.9 217.71,79.48 217.71,77.32
  IN4 w0.102: 217.71,77.32 217.71,66.48 v1(217.59,66.35) v1(217.59,62.49)
  GND3 w0.089: v6(217.3,81.21) 217.3,81.54 v7(217.16,81.68)
  BOTTOM w0.089: UV1.R6 217.7,82.25 217.16,81.7 v7(217.16,81.68)
  BOTTOM w0.102: v1(217.59,62.49) 217.75,62.66 RPH15.4 ; v2(217.82,66.94) 217.59,66.71 v1(217.59,66.35)
I2CC_SCL: length 7
  BOTTOM w0.102: RV299.1 RV319.1 216.71,74.39 216.71,75.28 v2(217.16,75.73) 218.05,76.62 218.05,78.35 218.4,78.71 UV1.R2
I2CC_SDA: length 9.2
  BOTTOM w0.089: 218.74,77.32 218.74,79.46 UV1.R3
  BOTTOM w0.102: 218.74,77.32 218.74,76.7 v2(218.67,76.63) 216.91,74.87 216.91,73.73 216.15,72.97 RV300.1 RV331.1
IBAT1: length 5.2
  TOP w0.254: R23.1 21.94,15.74 v2(21.42,16.26) 20.86,16.82 18.53,16.82 18.47,16.76 Q19.3
IBAT2: length 2
  BOTTOM w0.102: R16.1 v2(24.83,18.52)
  BOTTOM w0.254: Q17.3 25.48,17.98 25.08,17.58 R16.1
IBAT3: length 6
  BOTTOM w0.254: Q16.3 22.63,16.58 22.01,15.96 21.46,15.96 21.21,16.21 21.21,16.28 20.91,16.57 19.47,16.57 18.98,16.09 v2(18.76,16.09) 18.1,16.09 R19.1
IBAT4: length 1.1
  TOP w0.254: Q18.3 25.55,17.19 R22.1
IBAT5: length 3.7
  BOTTOM w0.102: Q15.3 19.73,18.41 20.81,19.49 v2(20.81,19.49)
  BOTTOM w0.254: R10.1 18.17,18.04 18.54,18.41 Q15.3
ILIM_HI1: length 2.8
  BOTTOM w0.102: R48.1 28.1,52.1 v2(27.85,52.1) US1.16
ILIM_HI3: length 2.6
  TOP w0.102: v2(23.79,74.52) R51.1 22.35,74.87 US2.16
ILIM_LO1: length 1.7
  BOTTOM w0.102: US1.15 27.71,52.6 R47.1
ILIM_LO3: length 1.4
  TOP w0.102: US2.15 21.85,74.62 R52.1
IMON: length 3.7
  BOTTOM w0.203: PU700.4 v2(124.4,119.61) 123.97,120.05 PC709.2
  BOTTOM w0.254: PR718.2 123.96,120.84 PC709.2
IMVP_VR_PG: length 237.7
  TOP w0.089: 161.54,14.23 161.78,14.47 UE1.A1
  TOP w0.102: UH3.2 v1(238.95,14.55) ; 161.54,14.23 161.26,13.95 161.26,13.7 v1(161.12,13.56) ; RU36.2 144.89,111.98 v2(144.68,111.77) 144.22,111.31 142.66,111.31 140.89,109.55 JXDP.47 138.75,109.55 137.66,108.46 v1(137.66,108.41)
  IN1 w0.102: v1(137.66,108.41) 136.4,107.15 136.4,103.64 137.26,102.78 138.74,102.78 140.18,101.34 140.18,97.57 134.78,92.17 134.78,85.94 135.81,84.91 135.81,77.63 135.22,77.04 135.22,53.55 145.45,43.32 145.45,27.3 147.05,25.7 147.05,21.29 149.58,18.77 155.02,18.77 159.58,14.21 160.48,14.21 v1(161.12,13.56)
  IN2 w0.102: v1(161.12,13.56) 161.62,13.56 162.82,12.36 165.1,12.36 165.71,12.97 166.42,12.97 167.04,12.36 171.48,12.36 172.4,13.28 183.81,13.28 185.57,15.03 187.67,15.03 187.93,15.3 198.39,15.3 199.16,14.52 207.2,14.52 207.92,15.25 211.1,15.25 213.3,17.45 220.53,17.45 224.11,13.88 224.71,13.88 225.51,13.08 226.91,13.08 227.67,13.85 228.58,13.85 229.17,13.26 233.42,13.26 234.71,14.55 v1(238.95,14.55)
  IN3 w0.102: v1(137.66,108.41) 131.66,114.42 131.66,119.6 129.35,121.91 124.92,121.91 123.32,123.5 v1(122.85,123.5)
  BOTTOM w0.254: v1(122.85,123.5) 122.85,123.24 122.23,122.62 PR711.2 PR719.1
IN+: length 2.1
  TOP w0.254: PR283.1 116.08,15.51 PC251.1 116.07,16.38 PU202.4
IN-: length 3.3
  TOP w0.102: PR284.1 116.97,17.7 v2(117.46,18.19)
  TOP w0.254: PU202.5 115.81,17.03 PC251.2 PR284.1
INV_PWM: length 17.1
  TOP w0.102: DV21.1 85.35,32.32 v1(85.58,32.09)
  BOTTOM w0.102: v1(85.58,32.09) 85.82,32.33 DV10.1 86.55,33.03 86.56,33.05 RV408.1 86.14,33.95 86.14,34.95 85.73,35.36 85.52,35.36 v2(85.38,35.51) 83.61,37.28 79.67,37.28 78.05,38.9 JEDP1.29
ISEN1: length 21.9
  TOP w0.254: PC732.1 129.3,117.61 v2(128.95,117.95) v1(128.29,118.61)
  IN1 w0.254: v1(128.29,118.61) 128.29,117.45 129.01,116.74 129.01,114.69 126.49,112.18 126.49,107.58 127.25,106.81 v1(127.51,106.81)
  BOTTOM w0.203: v1(128.29,118.61) 128.29,117.5 127.22,116.42 PU700.12
  BOTTOM w0.254: PR742.2 127.07,106.18 PR744.2 127.13,106.43 v1(127.51,106.81)
ISEN2: length 21.8
  TOP w0.254: PC733.1 127.7,118.13 v1(127.7,118.69)
  IN1 w0.254: v1(127.5,108.04) 127.23,108.04 126.85,108.43 126.85,112.03 129.36,114.54 129.36,116.89 128.78,117.47 128.78,118.88 128.4,119.26 128.01,119.26 127.7,118.94 v1(127.7,118.69)
  BOTTOM w0.102: PR721.2 129.49,107.97 v2(129.91,107.55)
  BOTTOM w0.203: PU700.11 127.08,116.82 127.7,117.43 v1(127.7,118.69)
  BOTTOM w0.254: PR721.2 128.58,108.04 v1(127.5,108.04) 127.17,108.04 126.49,108.72 PR715.2
ISUMN: length 62.2
  TOP w0.254: v1(130.55,113.99) 130.55,114.24 130.36,114.43 v2(129.97,114.43) 128.97,114.43 128.38,115.02 PC732.2 127.82,116.59 PC733.2 127.81,117.11 PC738.1 ; v1(121.14,79.46) 122.01,78.6 124.22,78.6 127.93,82.3 127.93,104.5 128.15,104.73 128.15,107.12 127.82,107.45 v1(127.51,107.45)
  IN4 w0.254: v1(127.51,107.45) 127.19,107.45 126.87,107.77 126.87,109.74 130.55,113.42 v1(130.55,113.99)
  BOTTOM w0.254: v1(130.55,113.99) 130.74,114.18 PR739.2 130.73,114.76 PR734.2 PC729.1 PR748.1 130.62,112.24 PR747.1 ; v1(121.14,79.46) 121.27,79.33 123.1,79.33 123.64,79.87 124.88,79.87 PH701.1 ; PR745.2 128.05,106.13 PR717.2 128.01,107.32 127.89,107.45 v1(127.51,107.45)
ISUMP: length 18.5
  TOP w0.102: v1(124.01,106.75) v2(123.23,106.75)
  IN4 w0.254: v1(128.22,111.87) 127.68,111.87 124.27,108.47 v1(124.27,108.02) 124.27,107.01 v1(124.01,106.75)
  BOTTOM w0.203: PC729.2 127.62,115.22 PU700.15
  BOTTOM w0.254: PR714.1 124.75,108.51 v1(124.27,108.02) ; PC731.2 PC730.2 ; PC731.2 127.37,111.2 PR749.2 ; PC731.2 v1(128.22,111.87) 128.22,112.78 128.42,112.98 PR748.2 PC729.2 ; PR741.1 124.58,106.18 v1(124.01,106.75)
JACK_PLUG#: length 7.2
  TOP w0.102: RA70.1 11.11,34.7 v3(10.96,34.86) 10.87,34.95 QA4.5
  GND1 w0.102: v3(10.96,34.86) 10.98,34.83 v5(10.98,34.17)
  IN1 w0.102: JHP2.6 9.52,34.52 9.87,34.17 v5(10.98,34.17)
JACK_PLUG#_DL: length 12.4
  TOP w0.102: QA4.6 10.78,35.6 RA98.2 11.77,35.77 RA54.2 12.25,35.29 13.04,35.29 13.32,35.01 13.32,34.4 13.14,34.22 13.14,32.75 12.57,32.17 QA5.2 9.74,32.17 CA31.2 9.24,31.77 v2(9.71,31.3)
JACK_PLUG#_DL_R: length 15
  TOP w0.254: RA22.2 18.54,40.97 18.54,41.83 v2(18.28,42.1) v1(17.77,42.1) ; v3(11.67,33.08) 11.16,33.08 10.91,32.82 QA5.1
  GND1 w0.254: v5(12.03,33.64) 11.67,33.28 v3(11.67,33.08)
  IN1 w0.254: v5(12.03,33.64) 12.08,33.69 12.08,34.32 17.31,39.55 17.31,41.64 v1(17.77,42.1)
KB_BL_DET: length 54.2
  IN3 w0.089: 254.47,26.67 255.26,26.67 256.96,24.97 256.96,23.63 258.38,22.22 260.56,22.22 260.79,21.98 267.91,21.98 268.14,22.22 271.45,22.22 272.16,22.93 272.16,25.38 273.08,26.3 273.08,26.71 v4(273.15,26.78)
  IN3 w0.102: v1(230.8,24.78) 232.69,26.67 254.47,26.67
  GND3 w0.089: v4(273.15,26.78) 273.15,26.78 273.15,26.77 273.33,26.6 273.37,26.6 273.61,26.36 v7(273.73,26.36)
  BOTTOM w0.089: v7(273.73,26.36) 273.76,26.32 273.76,26.31 273.72,26.36 273.72,26.47 273.82,26.57 273.82,26.87 U7.D13
  BOTTOM w0.102: R31.1 R30.1 229.67,23.75 v2(229.81,23.9) 230.69,24.78 v1(230.8,24.78)
KB_BL_PWM: length 2.8
  BOTTOM w0.305: JKBL.1 232.8,22.13
  BOTTOM w0.508: Q11.1 v2(233.01,22.61) 232.8,22.41 232.8,22.13
KB_CAPS_LED: length 6.1
  BOTTOM w0.102: v2(177.96,23.68) 177.56,23.27 175.69,23.27 175.27,22.86 175.27,22.08 174.97,21.78 RE84.2 174.81,20.79 174.77,20.74 JKB.27
KB_DET#: length 104.8
  TOP w0.089: 277.14,38.43 276.54,38.43 275.84,39.12 274.51,39.12 273.18,37.79 v1(273.14,37.79)
  TOP w0.102: v1(202.07,23.15) 202.98,23.15 v2(203.49,22.64) ; RH98.1 277.14,38.43
  IN4 w0.089: 272.9,42.2 273.82,41.28 273.82,40.52 274.69,39.66 274.69,38.97 273.51,37.79 v1(273.14,37.79) ; 269.66,42.2 269.53,42.07 266.88,42.07 266.75,42.2
  IN4 w0.102: v1(202.07,23.15) 202.35,23.15 205.62,26.42 205.62,36.41 213.23,44.01 265.21,44.01 266.27,42.95 266.27,42.68 266.75,42.2 ; 269.66,42.2 270.32,42.86 272.25,42.86 272.9,42.2
  BOTTOM w0.089: U7.F38 273.14,37.19 v1(273.14,37.79)
  BOTTOM w0.102: JKB.1 200.77,20.96 200.72,21.01 CE29.1 201.51,21.65 202.07,22.21 v1(202.07,23.15)
KB_LED_PWM: length 72.9
  TOP w0.089: UE1.M9 167.53,18.41 167.97,18.41
  TOP w0.102: v2(174,18.78) 173.48,18.26 v1(173.35,18.26) 172.5,19.11 170.89,19.11 170.41,18.63 168.89,18.63 168.66,18.39 167.99,18.39 167.97,18.41
  IN2 w0.102: v1(234.54,23.24) 233.44,22.13 221.37,22.13 221.11,22.4 204.36,22.4 203.43,21.47 200.2,21.47 198.74,20.01 193.67,20.01 192.57,18.91 174,18.91 v1(173.35,18.26)
  BOTTOM w0.102: v1(234.54,23.24) 234.57,23.26 Q11.2
KB_RST#: length 108.8
  TOP w0.089: v3(167.3,14.31) 167.23,14.31 167.03,14.51 167.03,14.91 UE1.L2 ; RH175.1 255.71,19.82 256.18,20.29 256.18,21.46 257.87,23.14 v2(258.71,23.14) 259.11,23.14 259.55,23.59 v1(260.13,23.59)
  TOP w0.102: v1(254.86,16.78) 255.22,17.13 RH175.1
  GND1 w0.076: v3(167.3,14.31) 167.3,14.49 v5(167.04,14.75)
  IN1 w0.076: v4(211.86,20.05) 211.86,19.57 211.49,19.2 205.83,19.2 205.23,18.6 205.23,14.47 204.41,13.64 195.77,13.64 195.38,14.03 184.2,14.03 183.81,13.64 173.88,13.64 173.41,14.11 171.87,14.11 171.72,14.27 170.76,14.27 170.68,14.35 169.85,14.35 169.49,14.71 169.47,14.71 169.46,14.72 169.45,14.72 169.4,14.78 167.07,14.78 v5(167.04,14.75)
  IN4 w0.076: v1(254.86,16.78) 254.79,16.85 252.42,16.85 251.91,16.34 251.42,16.34 251.02,15.95 243.18,15.95 242.78,16.34 241.83,16.34 241.24,16.94 228.89,16.94 228.51,17.32 223.27,17.32 221.12,19.46 212.07,19.46 211.86,19.67 v4(211.86,20.05)
  BOTTOM w0.089: U7.AT6 v1(260.13,23.59)
KC3810_RST#: length 3.8
  TOP w0.102: UE36.3 150.41,18.55 CE20.2 RE20.2 150.48,16.86 v2(150.23,16.61)
KSI0: length 38.2
  TOP w0.089: UE1.D9 163.21,18.59 v1(162.72,18.59)
  TOP w0.102: v2(193.97,20.02) v3(193.97,20.53)
  GND1 w0.102: v5(193.43,20.53) v3(193.97,20.53)
  IN1 w0.089: 168.78,20.37 168,20.37 167.47,20.9 165.53,20.9 164.32,19.69 164.32,19.58 163.32,18.59 v1(162.72,18.59)
  IN1 w0.102: v5(193.43,20.53) 192.87,21.09 v4(192.59,21.09) 192.19,21.5 187.19,21.5 186.18,20.48 183.12,20.48 182.44,21.16 181.23,21.16 180.62,20.55 180.62,20.26 179.72,19.36 176.9,19.36 176.27,19.99 174.62,19.99 174.24,20.37 168.78,20.37
  GND3 w0.102: v4(192.59,21.09) 192.76,21.26 v7(192.76,21.64)
  BOTTOM w0.102: JKB.9 192.77,21.63 v7(192.76,21.64)
KSI1: length 44.1
  TOP w0.089: 163.51,21.46 163.53,21.44 163.53,20.55 163.78,20.3 UE1.E12
  TOP w0.102: 163.51,21.46 163.18,21.79 163.18,21.99 v3(162.88,22.3) 162.88,23.86 v2(163.71,24.7)
  GND1 w0.102: v5(162.43,22.74) v3(162.88,22.3)
  IN1 w0.102: v5(162.43,22.74) 162.43,22.99 165.09,25.65 171.39,25.65 172.38,26.64 175.11,26.64 175.35,26.4 175.35,26.14 177.05,24.45 183.89,24.45 184.54,23.79 191.5,23.79 192.58,22.72 194.27,22.72 v4(194.75,22.23)
  GND3 w0.102: v7(194.75,21.65) v4(194.75,22.23)
  BOTTOM w0.102: v7(194.75,21.65) 194.77,21.63 JKB.7
KSI2: length 41.6
  TOP w0.089: 163.71,21.72 163.71,20.73 UE1.E13
  TOP w0.102: v2(163.56,22.69) 163.32,22.45 163.32,22.14 163.38,22.08 163.38,21.87 163.52,21.74 v3(163.7,21.74) 163.71,21.72
  GND1 w0.089: v5(163.98,21.59) 163.85,21.59 163.71,21.72
  GND1 w0.102: 163.71,21.72 v3(163.7,21.74)
  IN1 w0.089: v5(163.98,21.59) 163.98,21.72
  IN1 w0.102: 163.98,21.72 163.98,21.81 164.34,22.17 164.34,23.17 164.73,23.55 166.5,23.55 166.71,23.76 171.17,23.76 171.5,24.09 175.65,24.09 177.11,22.63 177.11,22.31 177.42,22 179.2,22 180.18,22.98 187.8,22.98 188.43,22.35 190.19,22.35 190.54,22.69 191.43,22.69 192.22,21.9 192.83,21.9 193.62,21.12 v4(195.82,21.12)
  GND3 w0.102: v4(195.82,21.12) 196.25,21.12 v7(196.29,21.15)
  BOTTOM w0.102: JKB.5 196.78,20.09 CE46.1 v7(196.29,21.15)
KSI3: length 40.9
  TOP w0.102: v3(163.05,19.78) 163.28,20.01 UE1.D12 ; v3(194.22,21.45) v2(194.22,22)
  GND1 w0.089: v5(162.91,20.19) 162.91,19.92 v3(163.05,19.78)
  GND1 w0.102: v5(193.81,21.45) v3(194.22,21.45)
  IN1 w0.089: v5(162.91,20.19) 163.06,20.19 163.63,20.76 163.63,21.72
  IN1 w0.102: 163.63,21.72 163.63,23.03 164.56,23.96 166.34,23.96 166.54,24.16 171,24.16 171.34,24.49 175.85,24.49 176.75,23.59 177.37,23.59 177.76,23.2 177.76,22.85 178.24,22.37 179.28,22.37 180.74,23.84 183.64,23.84 184.29,23.19 187.88,23.19 188.51,22.56 190.11,22.56 190.45,22.9 191.52,22.9 192.31,22.11 193.2,22.11 v4(193.46,21.84) 193.46,21.74 193.76,21.45 v5(193.81,21.45)
  GND3 w0.102: v4(193.46,21.84) 193.66,21.65 v7(193.8,21.65)
  BOTTOM w0.102: JKB.8 193.77,21.62 v7(193.8,21.65)
KSI4: length 44.7
  TOP w0.089: v3(163.18,21.28) 163.28,21.18 UE1.D13
  TOP w0.102: v3(197.5,22.46) v8(196.94,22.46)
  GND1 w0.089: v3(163.18,21.28) 163.18,21.61 v5(163.23,21.66)
  GND1 w0.102: v3(197.5,22.46) 197.48,22.47 v5(197.08,22.47)
  IN1 w0.089: 163.3,21.72 v5(163.23,21.66)
  IN1 w0.102: 163.3,21.72 163.42,21.85 163.42,23.11 164.47,24.16 166.05,24.16 166.25,24.37 170.92,24.37 171.25,24.7 175.93,24.7 176.83,23.79 177.54,23.79 177.96,23.37 177.96,22.93 178.32,22.58 179.19,22.58 180.66,24.04 183.72,24.04 184.38,23.39 187.97,23.39 188.6,22.76 190.03,22.76 190.37,23.1 191.61,23.1 192.4,22.31 193.62,22.31 194.31,21.62 197.03,21.62 v4(197.08,21.67) v5(197.08,22.47)
  GND3 w0.102: v4(197.08,21.67) 197.33,21.42 v7(197.33,21.1)
  BOTTOM w0.102: JKB.4 197.77,20.76 197.8,20.79 CE41.1 197.33,21.18 v7(197.33,21.1)
KSI5: length 43.9
  TOP w0.076: v3(162.32,21.37) 162.32,21.39 161.99,21.72
  TOP w0.089: 162.53,20.88 162.53,20.41 UE1.C12
  TOP w0.102: 161.99,21.72 161.94,21.78 161.94,21.98 v8(161.89,22.03) ; v3(162.32,21.37) 162.33,21.35 162.33,21.08 162.53,20.88
  GND1 w0.089: v5(161.96,21.66) 162.26,21.37 v3(162.32,21.37)
  IN1 w0.089: 162.56,21.72 162.49,21.66 v5(161.96,21.66)
  IN1 w0.102: v4(195.77,22.17) 195.43,21.83 194.39,21.83 193.71,22.51 192.49,22.51 191.69,23.3 190.28,23.3 189.94,22.96 188.68,22.96 188.05,23.59 184.46,23.59 183.81,24.24 180.57,24.24 179.11,22.78 178.41,22.78 178.17,23.02 178.17,23.45 177.62,24 176.92,24 176.02,24.9 171.28,24.9 170.94,25.24 166.84,25.24 165.97,24.37 164.39,24.37 163.22,23.2 163.22,22.39 162.56,21.72
  GND3 w0.102: v7(195.77,21.65) v4(195.77,22.17)
  BOTTOM w0.102: JKB.6 195.77,20.08 v7(195.77,21.65)
KSI6: length 47.4
  TOP w0.089: UE1.C13 162.78,20.91
  TOP w0.102: v8(161.68,24.09) 162.27,23.5 162.27,21.92 v3(162.38,21.8) 162.38,21.8 162.39,21.8 162.65,21.54 162.65,21.04 162.78,20.91
  GND1 w0.102: v5(161.92,22.23) 162.35,21.8 v3(162.38,21.8)
  IN1 w0.102: v4(198.29,21.98) 197.35,22.92 192.66,22.92 191.59,24 184.63,24 183.98,24.65 177.34,24.65 176.94,25.05 176.94,25.09 175.19,26.84 172.3,26.84 171.31,25.85 165.01,25.85 161.92,22.77 v5(161.92,22.23)
  GND3 w0.102: v4(198.29,21.98) 198.44,21.98 198.77,21.65 v7(198.82,21.65)
  BOTTOM w0.102: JKB.3 198.77,21.6 v7(198.82,21.65)
KSI7: length 46.5
  TOP w0.089: UE1.D10 162.94,19.5 v3(162.78,19.5)
  TOP w0.102: v3(199.83,22.41) 199.45,22.41 v8(199.35,22.51)
  GND1 w0.089: v3(162.78,19.5) 162.62,19.66 v5(162.62,19.92)
  GND1 w0.102: v5(199.43,22.41) v3(199.83,22.41)
  IN1 w0.089: v5(162.62,19.92) 163.16,19.92 163.32,20.07 164,20.07 165.32,21.39 166.11,21.39 166.13,21.41
  IN1 w0.102: v5(199.43,22.41) 199.08,22.07 v4(199.08,21.22) 198.55,20.68 193.76,20.68 192.75,21.7 192.14,21.7 191.34,22.49 190.62,22.49 190.28,22.15 188.62,22.15 188.17,21.7 187.11,21.7 186.09,20.68 183.21,20.68 182.53,21.36 180.99,21.36 180.59,20.96 180.17,20.96 179.79,20.58 178.75,20.58 178.14,19.97 177.15,19.97 176.52,20.6 175.98,20.6 174.65,21.93 167.47,21.93 166.95,21.41 166.13,21.41
  GND3 w0.102: v7(199.77,21.65) 199.34,21.22 v4(199.08,21.22)
  BOTTOM w0.102: v7(199.77,21.65) 199.77,21.65 JKB.2
KSO0: length 24.8
  TOP w0.089: UE1.J13 165.78,20.97
  TOP w0.102: v2(176.44,20.45) v3(176.44,21.17) ; 165.78,20.97 166.11,21.3 166.11,21.74 v3(165.79,22.07)
  GND1 w0.102: v3(165.79,22.07) 165.75,22.1 v5(165.75,22.41) ; v5(176.44,21.55) v3(176.44,21.17)
  IN1 w0.102: v4(183.89,22.17) 183.47,21.74 183.01,21.74 182.78,21.97 180.31,21.97 179.54,21.19 177.08,21.19 176.72,21.55 v5(176.44,21.55) 176.18,21.55 174.99,22.74 167.13,22.74 166.82,22.43 165.77,22.43 v5(165.75,22.41)
  GND3 w0.102: v7(183.74,21.64) 183.74,22.02 v4(183.89,22.17)
  BOTTOM w0.102: JKB.18 183.77,21.62 v7(183.74,21.64)
KSO1: length 27
  TOP w0.089: UE1.J12 166.03,20.41 166.03,20.93
  TOP w0.102: v3(183.81,21.14) v2(183.81,20.71) ; v3(166.18,22.36) 166.32,22.22 166.32,21.22 166.03,20.93
  GND1 w0.102: v5(166.53,21.9) 166.53,22.01 v3(166.18,22.36) ; v5(183.81,21.5) v3(183.81,21.14)
  IN1 w0.102: v4(185.71,21.09) 185.31,21.5 v5(183.81,21.5) 182.97,21.5 182.7,21.77 180.4,21.77 179.62,20.99 178.58,20.99 177.97,20.38 177.32,20.38 176.69,21.01 176.15,21.01 174.82,22.33 167.3,22.33 166.86,21.9 v5(166.53,21.9)
  GND3 w0.102: v7(185.71,21.64) v4(185.71,21.09)
  BOTTOM w0.102: JKB.16 185.77,21.58 v7(185.71,21.64)
KSO2: length 25.5
  TOP w0.089: 165.53,21.01 165.53,20.41 UE1.H12
  TOP w0.102: v3(180.55,21.8) v2(180.1,21.8) ; 165.53,21.01 165.78,21.26 v3(165.78,21.41)
  GND1 w0.089: 166.05,21.72 165.78,21.46 v3(165.78,21.41)
  GND1 w0.102: 166.05,21.72 v5(166.11,21.79) ; v3(180.55,21.8) 180.55,21.79 v5(180.55,21.4)
  IN1 w0.076: 166.98,21.72 166.83,21.58 166.32,21.58 166.18,21.72
  IN1 w0.102: 166.98,21.72 167.38,22.13 174.73,22.13 176.06,20.8 176.61,20.8 177.23,20.18 178.05,20.18 178.66,20.78 179.7,20.78 180.17,21.25 180.39,21.25 v5(180.55,21.4) 180.71,21.56 182.61,21.56 183.09,21.09 v4(184.76,21.09) ; 166.18,21.72 v5(166.11,21.79)
  GND3 w0.102: v7(184.76,21.64) v4(184.76,21.09)
  BOTTOM w0.102: JKB.17 184.77,21.63 v7(184.76,21.64)
KSO3: length 29.2
  TOP w0.089: UE1.H13 165.28,21.04
  TOP w0.102: v3(164.72,23.36) 165.17,23.36 165.34,23.2 v8(165.34,22.31) 165.38,22.27 165.38,21.14 165.28,21.04
  GND1 w0.102: v3(164.72,23.36) 165.06,23.02 v5(165.06,22.95)
  IN1 w0.102: v4(186.18,22.11) 185.71,22.58 180.34,22.58 179.37,21.6 177.25,21.6 176.7,22.14 176.7,22.46 175.48,23.68 171.67,23.68 171.34,23.35 166.87,23.35 166.67,23.15 165.26,23.15 v5(165.06,22.95)
  GND3 w0.102: v7(186.73,21.64) 186.64,21.64 v4(186.18,22.11)
  BOTTOM w0.102: v7(186.73,21.64) 186.77,21.6 JKB.15
KSO4: length 33
  TOP w0.089: v1(165.14,19.64) 165.14,19.3 UE1.H10
  TOP w0.102: v3(190.54,21.67) v2(190.54,22.13)
  GND1 w0.102: v5(190.54,21.14) v3(190.54,21.67)
  IN1 w0.089: v1(165.14,19.64) 165.14,20.28 165.59,20.73 167.41,20.73 167.97,20.17 168.78,20.17
  IN1 w0.102: 168.78,20.17 174.05,20.17 174.43,19.79 176.15,19.79 176.79,19.15 179.79,19.15 180.82,20.18 180.82,20.46 181.31,20.95 182.36,20.95 183.04,20.28 186.26,20.28 187.28,21.29 190.38,21.29 v5(190.54,21.14) 190.59,21.09 v4(191.13,21.09)
  GND3 w0.102: v7(190.79,21.64) 190.79,21.43 v4(191.13,21.09)
  BOTTOM w0.102: JKB.11 190.77,21.62 v7(190.79,21.64)
KSO5: length 34
  TOP w0.089: UE1.H9 165.53,18.91 165.53,19.52 v1(165.71,19.69)
  TOP w0.102: v3(191.81,20.63) v2(191.81,20.2)
  GND1 w0.102: v5(192.21,20.63) v3(191.81,20.63)
  IN1 w0.089: 168.78,19.97 167.94,19.97 167.34,20.57 166.48,20.57 165.71,19.8 v1(165.71,19.69)
  IN1 w0.102: 168.78,19.97 173.96,19.97 174.35,19.58 176.06,19.58 176.7,18.95 179.88,18.95 181.02,20.09 181.02,20.38 181.4,20.75 182.27,20.75 182.95,20.07 186.34,20.07 187.36,21.09 189.67,21.09 190.08,20.68 191.31,20.68 v4(191.72,21.09) 191.76,21.09 v5(192.21,20.63)
  GND3 w0.102: v7(191.81,21.64) 191.81,21.18 v4(191.72,21.09)
  BOTTOM w0.102: JKB.10 191.77,21.61 v7(191.81,21.64)
KSO6: length 31
  TOP w0.089: v3(164.62,18.23) 164.78,18.4 UE1.G9
  TOP w0.102: v2(184.06,19.01) 184.19,18.88 v3(184.59,18.88)
  GND1 w0.089: v3(164.62,18.23) 164.77,18.38 v5(164.77,18.66)
  GND1 w0.102: v5(184.59,19.36) v3(184.59,18.88)
  IN1 w0.089: 168.78,19.36 167.85,19.36 167.13,20.07 166.69,20.07 166.48,19.86 166.48,19.42 165.72,18.66 v5(164.77,18.66)
  IN1 w0.102: 168.78,19.36 173.71,19.36 174.1,18.97 175.81,18.97 176.45,18.34 180.24,18.34 181.26,19.36 v5(184.59,19.36) 186.73,19.36 187.74,20.38 v4(188.21,20.38)
  GND3 w0.102: v4(188.21,20.38) v7(188.21,20.84)
  BOTTOM w0.102: v7(188.21,20.84) 188.21,21.09 CE33.1 188.77,21.63 JKB.13
KSO7: length 32.7
  TOP w0.089: UE1.G10 164.78,19.38 v3(164.59,19.57)
  TOP w0.102: v3(186.57,20.23) v2(186.12,20.23)
  GND1 w0.089: v5(164.53,19.18) 164.53,19.5 v3(164.59,19.57)
  GND1 w0.102: v5(187.01,20.23) v3(186.57,20.23)
  IN1 w0.089: v5(164.53,19.18) 165.77,19.18 166.15,19.56 166.15,20 166.55,20.4 167.27,20.4 167.91,19.77 168.78,19.77
  IN1 w0.102: 168.78,19.77 173.88,19.77 174.27,19.38 175.98,19.38 176.62,18.74 179.96,18.74 181.23,20.01 181.23,20.3 181.48,20.55 182.19,20.55 182.87,19.87 186.65,19.87 v5(187.01,20.23) 187.56,20.78 188.83,20.78 v4(189.23,20.39)
  GND3 w0.102: v4(189.23,20.39) v7(189.23,20.84)
  BOTTOM w0.102: CE31.1 189.77,21.64 ; 189.77,21.64 189.23,21.09 v7(189.23,20.84) ; 189.77,21.64 JKB.12
KSO8: length 30.8
  TOP w0.089: UE1.G13 164.76,20.69 164.76,21.09
  TOP w0.102: v2(187.06,22.26) 186.85,22.46 v3(186.85,22.94) ; 164.76,21.09 164.76,21.81 v3(164.4,22.17)
  GND1 w0.102: v5(186.85,22.51) v3(186.85,22.94) ; v3(164.4,22.17) v5(164.72,22.49)
  IN1 w0.102: v5(164.72,22.49) 164.72,23.07 165,23.35 166.59,23.35 166.79,23.55 171.26,23.55 171.59,23.88 175.57,23.88 176.91,22.54 176.91,22.23 177.33,21.8 179.28,21.8 180.26,22.78 186.59,22.78 v5(186.85,22.51) v4(187.26,22.11)
  GND3 w0.102: v7(187.74,21.64) 187.72,21.64 v4(187.26,22.11)
  BOTTOM w0.102: v7(187.74,21.64) 187.77,21.62 JKB.14
KSO9: length 19
  TOP w0.089: 165.03,21.22 165.03,20.41 UE1.G12
  TOP w0.102: v3(177.51,21.24) v2(177.51,21.88) ; 165.03,21.22 165.03,21.29 v3(165.1,21.36)
  GND1 w0.089: v3(165.1,21.36) 165.12,21.38 v5(165.12,21.67)
  GND1 w0.102: v5(177.3,20.86) 177.3,21.04 v3(177.51,21.24)
  IN1 w0.089: v5(165.12,21.67) 165.49,21.67 165.54,21.72
  IN1 w0.102: v4(177.8,20.78) 177.38,20.78 v5(177.3,20.86) 177.12,20.86 176.77,21.21 176.23,21.21 174.9,22.54 167.21,22.54 166.9,22.23 166.05,22.23 165.54,21.72
  GND3 w0.102: v7(177.8,21.65) v4(177.8,20.78)
  BOTTOM w0.102: v7(177.8,21.65) 177.77,21.62 JKB.24
