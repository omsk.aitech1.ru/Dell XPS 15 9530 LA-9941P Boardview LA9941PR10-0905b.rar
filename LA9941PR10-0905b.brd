# Allegro board LA9941PR10-0905b.brd (continued)
## Nets (continued)
FBA_D52: UV1.AM33 UV6.N11
FBA_D53: UV1.AL31 UV6.N13
FBA_D54: UV1.AK33 UV6.M11
FBA_D55: UV1.AK32 UV6.M13
FBA_D56: UV1.AD34 UV6.U4
FBA_D57: UV1.AD32 UV6.U2
FBA_D58: UV1.AC30 UV6.T4
FBA_D59: UV1.AD33 UV6.T2
FBA_D60: UV1.AF31 UV6.N4
FBA_D61: UV1.AG34 UV6.N2
FBA_D62: UV1.AG32 UV6.M4
FBA_D63: UV1.AG33 UV6.M2
FBA_DBI0: UV1.P30 UV5.D2
FBA_DBI1: UV1.F31 UV5.D13
FBA_DBI2: UV1.F34 UV5.P13
FBA_DBI3: UV1.M32 UV5.P2
FBA_DBI4: UV1.AD31 UV6.D2
FBA_DBI5: UV1.AL29 UV6.D13
FBA_DBI6: UV1.AM32 UV6.P13
FBA_DBI7: UV1.AF34 UV6.P2
FBA_EDC0: UV1.M31 UV5.C2
FBA_EDC1: UV1.G31 UV5.C13
FBA_EDC2: UV1.E33 UV5.R13
FBA_EDC3: UV1.M33 UV5.R2
FBA_EDC4: UV1.AE31 UV6.C2
FBA_EDC5: UV1.AK30 UV6.C13
FBA_EDC6: UV1.AN33 UV6.R13
FBA_EDC7: UV1.AF33 UV6.R2
FBA_SEN0: RV353.2 UV5.J10
FBA_SEN2: RV366.2 UV6.J10
FBA_WCK01: UV1.K31 UV5.D4
FBA_WCK01#: UV1.L30 UV5.D5
FBA_WCK23: UV1.H34 UV5.P4
FBA_WCK23#: UV1.J34 UV5.P5
FBA_WCK45: UV1.AG30 UV6.D4
FBA_WCK45#: UV1.AG31 UV6.D5
FBA_WCK67: UV1.AJ34 UV6.P4
FBA_WCK67#: UV1.AK34 UV6.P5
FBB_CMD0: UV1.D13 UV9.G12
FBB_CMD1: UV1.E14 UV9.H10
FBB_CMD2: UV1.F14 UV9.H11
FBB_CMD3: UV1.A12 UV9.K11
FBB_CMD4: UV1.B12 UV9.K10
FBB_CMD5: UV1.C14 UV9.L12
FBB_CMD6: UV1.B14 UV9.K4
FBB_CMD7: UV1.G15 UV9.K5
FBB_CMD8: UV1.F15 UV9.J4
FBB_CMD9: UV1.E15 UV9.J5
FBB_CMD10: UV1.D15 UV9.H4
FBB_CMD11: UV1.A14 UV9.H5
FBB_CMD12: UV1.D14 UV9.G3
FBB_CMD13: RV418.1 UV1.A15 UV9.J2
FBB_CMD14: RV410.1 UV1.B15 UV9.J3
FBB_CMD15: UV1.C17 UV9.L3
FBB_CMD16: UV1.D18 UV10.G12
FBB_CMD17: UV1.E18 UV10.H10
FBB_CMD18: UV1.F18 UV10.H11
FBB_CMD19: UV1.A20 UV10.K11
FBB_CMD20: UV1.B20 UV10.K10
FBB_CMD21: UV1.C18 UV10.L12
FBB_CMD22: UV1.B18 UV10.K4
FBB_CMD23: UV1.G18 UV10.K5
FBB_CMD24: UV1.G17 UV10.J4
FBB_CMD25: UV1.F17 UV10.J5
FBB_CMD26: UV1.D16 UV10.H4
FBB_CMD27: UV1.A18 UV10.H5
FBB_CMD28: UV1.D17 UV10.G3
FBB_CMD29: RV414.1 UV1.A17 UV10.J2
FBB_CMD30: RV409.1 UV1.B17 UV10.J3
FBB_CMD31: UV1.E17 UV10.L3
FBB_D0: UV1.G9 UV9.A4
FBB_D1: UV1.E9 UV9.A2
FBB_D2: UV1.G8 UV9.B4
FBB_D3: UV1.F9 UV9.B2
FBB_D4: UV1.F11 UV9.E4
FBB_D5: UV1.G11 UV9.E2
FBB_D6: UV1.F12 UV9.F4
FBB_D7: UV1.G12 UV9.F2
FBB_D8: UV1.G6 UV9.A11
FBB_D9: UV1.F5 UV9.A13
FBB_D10: UV1.E6 UV9.B11
FBB_D11: UV1.F6 UV9.B13
FBB_D12: UV1.F4 UV9.E11
FBB_D13: UV1.G4 UV9.E13
FBB_D14: UV1.E2 UV9.F11
FBB_D15: UV1.F3 UV9.F13
FBB_D16: UV1.C2 UV9.U11
FBB_D17: UV1.D4 UV9.U13
FBB_D18: UV1.D3 UV9.T11
FBB_D19: UV1.C1 UV9.T13
FBB_D20: UV1.B3 UV9.N11
FBB_D21: UV1.C4 UV9.N13
FBB_D22: UV1.B5 UV9.M11
FBB_D23: UV1.C5 UV9.M13
FBB_D24: UV1.A11 UV9.U4
FBB_D25: UV1.C11 UV9.U2
FBB_D26: UV1.D11 UV9.T4
FBB_D27: UV1.B11 UV9.T2
FBB_D28: UV1.D8 UV9.N4
FBB_D29: UV1.A8 UV9.N2
FBB_D30: UV1.C8 UV9.M4
FBB_D31: UV1.B8 UV9.M2
FBB_D32: UV1.F24 UV10.A4
FBB_D33: UV1.G23 UV10.A2
FBB_D34: UV1.E24 UV10.B4
FBB_D35: UV1.G24 UV10.B2
FBB_D36: UV1.D21 UV10.E4
FBB_D37: UV1.E21 UV10.E2
FBB_D38: UV1.G21 UV10.F4
FBB_D39: UV1.F21 UV10.F2
FBB_D40: UV1.G27 UV10.A11
FBB_D41: UV1.D27 UV10.A13
FBB_D42: UV1.G26 UV10.B11
FBB_D43: UV1.E27 UV10.B13
FBB_D44: UV1.E29 UV10.E11
FBB_D45: UV1.F29 UV10.E13
FBB_D46: UV1.E30 UV10.F11
FBB_D47: UV1.D30 UV10.F13
FBB_D48: UV1.A32 UV10.U11
FBB_D49: UV1.C31 UV10.U13
FBB_D50: UV1.C32 UV10.T11
FBB_D51: UV1.B32 UV10.T13
FBB_D52: UV1.D29 UV10.N11
FBB_D53: UV1.A29 UV10.N13
FBB_D54: UV1.C29 UV10.M11
FBB_D55: UV1.B29 UV10.M13
FBB_D56: UV1.B21 UV10.U4
FBB_D57: UV1.C23 UV10.U2
FBB_D58: UV1.A21 UV10.T4
FBB_D59: UV1.C21 UV10.T2
FBB_D60: UV1.B24 UV10.N4
FBB_D61: UV1.C24 UV10.N2
FBB_D62: UV1.B26 UV10.M4
FBB_D63: UV1.C26 UV10.M2
FBB_DBI0: UV1.E11 UV9.D2
FBB_DBI1: UV1.E3 UV9.D13
FBB_DBI2: UV1.A3 UV9.P13
FBB_DBI3: UV1.C9 UV9.P2
FBB_DBI4: UV1.F23 UV10.D2
FBB_DBI5: UV1.F27 UV10.D13
FBB_DBI6: UV1.C30 UV10.P13
FBB_DBI7: UV1.A24 UV10.P2
FBB_EDC0: UV1.D10 UV9.C2
FBB_EDC1: UV1.D5 UV9.C13
FBB_EDC2: UV1.C3 UV9.R13
FBB_EDC3: UV1.B9 UV9.R2
FBB_EDC4: UV1.E23 UV10.C2
FBB_EDC5: UV1.E28 UV10.C13
FBB_EDC6: UV1.B30 UV10.R13
FBB_EDC7: UV1.A23 UV10.R2
FBB_SEN0: RV379.2 UV9.J10
FBB_SEN2: RV392.2 UV10.J10
FBB_WCK01: UV1.F8 UV9.D4
FBB_WCK01#: UV1.E8 UV9.D5
FBB_WCK23: UV1.A5 UV9.P4
FBB_WCK23#: UV1.A6 UV9.P5
FBB_WCK45: UV1.D24 UV10.D4
FBB_WCK45#: UV1.D25 UV10.D5
FBB_WCK67: UV1.B27 UV10.P4
FBB_WCK67#: UV1.C27 UV10.P5
FBVREF_ALTV: QV22.2 QV23.2 QV24.2 QV25.2 RPH33.4 UV1.L1
FDI_CSYNC: U6.F11 U7.AL39
FDI_INT: U6.F12 U7.AL40
FFS_INT1: RN33.2 U7.G17 UN2.11
FFS_INT2: QN2.2 U7.AN4 UN2.9
FFS_INT2_Q: JHDD.18 QN2.3 RN23.2
GATEA20: RH159.1 U7.AN10 UE1.M2
GPU_COMP: PC824.2 PC825.2 PU800.12
GPU_EN: PC812.1 PR841.1 PU800.3
GPU_FB: PC821.2 PR823.2 PR824.1 PR825.2 PU800.11
GPU_FBRTN: PR818.2 PR819.2 PU800.10
GPU_GPIO2: RPH12.1 UV1.L6
GPU_GPIO3: RPH12.2 UV1.P5
GPU_GPIO4: RPH12.3 UV1.P7
GPU_GPIO7: RPH12.4 UV1.N8
GPU_GPIO13: RV10.1 UV1.M4
GPU_HOT#: QV42.6 UE36.2
GPU_HOT#_R: QV42.1 RPH33.1 UV1.N3
GPU_JTAG_TCK: T174.1(TP-1) UV1.AM10
GPU_JTAG_TDI: T11.1(TP-1) UV1.AM11
GPU_JTAG_TDO: T12.1(TP-1) UV1.AP12
GPU_JTAG_TMS: T13.1(TP-1) UV1.AP11
GPU_JTAG_TRST#: RV324.1 UV1.AN11
GPU_PGOOD: PR842.1 PU800.16
GPU_PSI: PR803.2 PU800.4 RV10.2
GPU_PVCC: PC823.1 PR821.1 PU800.21
GPU_REFADJ: PR809.2 PU800.6
GPU_REFIN: PC810.1 PR807.1 PR812.1 PU800.7
GPU_TESTMODE: RV320.2 RV323.1 UV1.AK11
GPU_TON: PR817.2 PU800.9
GPU_VDD_SENSE: PR823.1 UV1.L4
GPU_VID: PR836.2 PU800.5
GPU_VID_0: PR836.1 UV1.M5
GPU_VREF: PC807.1 PR804.1 PU800.8
GPU_VSS_SENSE: PR818.1 UV1.L5
H_CPU_SVIDALRT#: RU93.2 U6.J53
H_CPUPWRGD: RU7.1 RU33.2 U6.F50 U7.AV3
H_CPUPWRGD_XDP: JXDP.39 RU7.2
H_DRAMRST#: QU3.3 RU74.1 U6.BE51
H_PECI: RE38.2 U6.G51
H_PM_SYNC: U6.D52 U7.AY3
H_PROCHOT#: CE21.1 PC710.1 PQ230.1 PQ231.3 PR722.1 PR726.2 RU30.2 RU32.1 UE2.4
H_PROCHOT#_EC: PR290.1 RE42.1 UE1.E2 UE2.2
H_PROCHOT#_R: RU32.2 U6.E50
H_THERMTRIP#: RH162.2 U6.D53
H_THERMTRIP#_C: RH162.1 RU45.2 U7.AV1
HDA_BIT_CLK: CH1.2 RH5.2 U7.B25
HDA_BITCLK_5505: RA26.1 RA67.2 RA76.1 U12.23
HDA_BITCLK_5505_R: RA50.2 RA67.1
HDA_BITCLK_AUDIO: RA50.1 RA89.1 RH5.1 U12.6
HDA_BITCLK_R: CA39.2 RA26.2 U15.5
HDA_RST#: RH6.2 U7.C24
HDA_RST_5505: RA66.2 U12.18 U15.6
HDA_RST_5505_R: RA58.2 RA66.1
HDA_RST_AUDIO#: RA58.1 RA101.1 RH6.1 U12.11
HDA_SDIN0: RA81.1 U7.L22
HDA_SDIN0_C: RA56.1 RA81.2 U12.8
HDA_SDIN_5505: RA24.1 RA64.2 U12.21
HDA_SDIN_5505_R: RA56.2 RA64.1
HDA_SDIN_R: RA24.2 U15.8
HDA_SDO: RH11.1 UE1.C1
HDA_SDOUT: CH2.2 RH11.2 RH15.2 RH23.2 U7.A24
HDA_SDOUT_5505: RA68.2 U12.24 U15.4
HDA_SDOUT_5505_R: RA63.2 RA68.1
HDA_SDOUT_AUDIO: CA95.1 RA63.1 RH15.1 U12.5
HDA_SPKR: RA10.2 RH17.2 U7.AL10
HDA_SYNC: RH7.2 RH8.2 RH32.2 U7.A22
HDA_SYNC_5505: RA65.2 U12.19 U15.9
HDA_SYNC_5505_R: RA57.2 RA65.1
HDA_SYNC_AUDIO: CA93.1 RA57.1 RH7.1 U12.10
HDD_DETECT#: JHDD.12 RPH7.7 U7.U12
HDMI_A0N_VGA: CV760.2 U6.C24
HDMI_A0P_VGA: CV761.2 U6.D24
HDMI_A1N_VGA: CV762.2 U6.A25
HDMI_A1P_VGA: CV763.2 U6.B25
HDMI_A2N_VGA: CV764.2 U6.C25
HDMI_A2P_VGA: CV765.2 U6.D25
HDMI_A3N_VGA: CV758.2 U6.A24
HDMI_A3P_VGA: CV759.2 U6.B24
HDMI_BUF: RV430.1 RV431.2 U22.14
HDMI_CEC: CV796.2 JHDMI.13
HDMI_DDB_CTRLCLK: RPH16.1 U7.R40 U22.38
HDMI_DDB_CTRLDATA: RPH16.2 U7.R39 U22.39
HDMI_EQ: RV448.2 RV449.1 U22.17
HDMI_HPLUG: CV768.2 JHDMI.19 U22.28
HDMI_ISET: RV459.1 RV460.2 U22.34
HDMI_PCH_HPD: U7.K40 U22.3
HDMI_PD#: T118.1(TP-1) U22.36
HDMI_PRE: RV450.2 RV451.1 U22.16
HDMI_RESERVED: CV795.2 JHDMI.14
HP2_OUTL: RA18.1 U15.26
HP2_OUTL_R: CA38.1 DA2.2 JHP2.1 LA5.2 RA2.1 RA92.2 RA93.2 UA2.A1
HP2_OUTR: RA17.1 U15.27
HP2_OUTR_R: CA33.1 DA3.3 JHP2.2 LA6.2 RA3.1 RA94.2 RA95.1 UA2.A3
HWPG: RE27.2 RE29.2 UE1.F1
I2C_EN8723: RI6.1 UI5.6
I2CA_SCL: RPH13.1 RPH15.1 UV1.R4
I2CA_SDA: RPH13.2 RPH15.2 UV1.R5
I2CB_SCL: RPH13.3 RPH15.3 UV1.R7
I2CB_SDA: RPH13.4 RPH15.4 UV1.R6
I2CC_SCL: RV299.1 RV319.1 UV1.R2
I2CC_SDA: RV300.1 RV331.1 UV1.R3
IBAT1: Q19.3 R23.1
IBAT2: Q17.3 R16.1
IBAT3: Q16.3 R19.1
IBAT4: Q18.3 R22.1
IBAT5: Q15.3 R10.1
ILIM_HI1: R48.1 US1.16
ILIM_HI3: R51.1 US2.16
ILIM_LO1: R47.1 US1.15
ILIM_LO3: R52.1 US2.15
IMON: PC709.2 PR718.2 PU700.4
IMVP_VR_PG: JXDP.47 PR711.2 PR719.1 RU36.2 UE1.A1 UH3.2
IN+: PC251.1 PR283.1 PU202.4
IN-: PC251.2 PR284.1 PU202.5
INV_PWM: DV10.1 DV21.1 JEDP1.29 RV408.1
ISEN1: PC732.1 PR742.2 PR744.2 PU700.12
ISEN2: PC733.1 PR715.2 PR721.2 PU700.11
ISUMN: PC729.1 PC732.2 PC733.2 PC738.1 PH701.1 PR717.2 PR734.2 PR739.2 PR745.2 PR747.1 PR748.1
ISUMP: PC729.2 PC730.2 PC731.2 PR714.1 PR741.1 PR748.2 PR749.2 PU700.15
JACK_PLUG#: JHP2.6 QA4.5 RA70.1 RA98.1
JACK_PLUG#_DL: CA31.2 QA4.6 QA5.2 RA54.2 RA98.2
JACK_PLUG#_DL_R: QA5.1 RA22.2
KB_BL_DET: R30.1 R31.1 U7.D13
KB_BL_PWM: JKBL.1 Q11.1
KB_CAPS_LED: JKB.27 RE84.2
KB_DET#: CE29.1 JKB.1 RH98.1 U7.F38
KB_LED_PWM: Q11.2 UE1.M9
KB_RST#: RH175.1 U7.AT6 UE1.L2
KC3810_RST#: CE20.2 RE20.2 UE36.3
KSI0: CE38.1 JKB.9 UE1.D9
KSI1: CE44.1 JKB.7 UE1.E12
KSI2: CE46.1 JKB.5 UE1.E13
KSI3: CE50.1 JKB.8 UE1.D12
KSI4: CE41.1 JKB.4 UE1.D13
KSI5: CE49.1 JKB.6 UE1.C12
KSI6: CE51.1 JKB.3 UE1.C13
KSI7: CE53.1 JKB.2 UE1.D10
KSO0: CE47.1 JKB.18 UE1.J13
KSO1: CE45.1 JKB.16 UE1.J12
KSO2: CE43.1 JKB.17 UE1.H12
KSO3: CE39.1 JKB.15 RE43.2 UE1.H13
KSO4: CE37.1 JKB.11 UE1.H10
KSO5: CE35.1 JKB.10 UE1.H9
KSO6: CE33.1 JKB.13 UE1.G9
KSO7: CE31.1 JKB.12 UE1.G10
KSO8: CE52.1 JKB.14 UE1.G13
KSO9: CE48.1 JKB.24 UE1.G12
KSO10: CE42.1 JKB.26 UE1.F13
KSO11: CE40.1 JKB.25 UE1.F12
KSO12: CE36.1 JKB.19 UE1.F10
KSO13: CE34.1 JKB.22 UE1.F9
KSO14: CE32.1 JKB.23 UE1.E10
KSO15: CE30.1 JKB.21 UE1.E9
KSO16: CE28.1 JKB.20 UE1.E8
LANCLK_REQ#: RPH25.8 U7.AF1
LCD_DBC: RH178.2 RPH9.7 RV482.1 U7.AP1
LCD_DCR: RPH9.8 RV481.1 U7.AM3
LCD_DELAY: RV419.2 UE36.9
LCD_TEST: RE64.2 RV480.1 UE36.11
LDO_OUT: CA18.1 CA19.1 U15.40
LG_3V: PC315.1 PQ302.4 PU300.11
LG_5V: PC314.1 PQ303.4 PU300.15
LG_+V1.05V: PQ501.4 PU500.6
LGATE1: PQ703.4 PU700.21
LGATE2: PQ700.4 PU700.24
LID_SW_IN#: C18.1 DV20.1 R28.2 U5.3 UE1.H5
LPC_AD0: JSSD.16 U1.26 U7.A20 UE1.N4
LPC_AD1: JSSD.14 U1.23 U7.C20 UE1.K5
LPC_AD2: JSSD.12 U1.20 U7.A18 UE1.M4
LPC_AD3: JSSD.10 U1.17 U7.C18 UE1.N3
LPC_FRAME#: JSSD.8 U1.22 U7.B21 UE1.K4
LX_3V: PC310.1 PL301.2 PQ300.1 PQ300.2 PQ300.3 PQ302.5 PR309.1 PU300.8
LX_5V: PC311.2 PL300.1 PQ301.1 PQ301.2 PQ301.3 PQ303.5 PR310.1 PU300.18
M_CLK_DDR0: JDIMM1.101 U6.BF25
M_CLK_DDR1: JDIMM1.102 U6.BC25
M_CLK_DDR2: JDIMM2.101 U6.AV27
M_CLK_DDR3: JDIMM2.102 U6.AV26
M_CLK_DDR#0: JDIMM1.103 U6.BE25
M_CLK_DDR#1: JDIMM1.104 U6.BD25
M_CLK_DDR#2: JDIMM2.103 U6.AW27
M_CLK_DDR#3: JDIMM2.104 U6.AW26
M_ODT0: JDIMM1.116 U6.BC16
M_ODT1: JDIMM1.120 U6.BF16
M_ODT2: JDIMM2.116 U6.AY20
M_ODT3: JDIMM2.120 U6.BA19
MDP_A0N_CPU: CV780.2 U6.C21
MDP_A0N_R: C47.2 U11.22
MDP_A0P_CPU: CV779.2 U6.D21
MDP_A0P_R: C93.2 U11.23
MDP_A1N_CPU: CV782.2 U6.A21
MDP_A1N_R: C53.2 U11.19
MDP_A1P_CPU: CV781.2 U6.B21
MDP_A1P_R: C42.2 U11.20
MDP_A2N_CPU: CV784.2 U6.C20
MDP_A2N_R: C57.2 U11.16
MDP_A2P_CPU: CV783.2 U6.D20
MDP_A2P_R: C59.2 U11.17
MDP_A3N_CPU: CV786.2 U6.A20
MDP_A3N_R: C56.2 U11.13
MDP_A3P_CPU: CV785.2 U6.B20
MDP_A3P_R: C54.2 U11.14
MDP_AUXN_PCH: CV812.2 U7.K43
MDP_AUXN_PCH_C: CV812.1 U11.29
MDP_AUXP_PCH: CV813.2 U7.K45
MDP_AUXP_PCH_C: CV813.1 U11.30
MDP_CFG0: R2530.1 R2531.1 U11.5
MDP_CFG1_INPUT: R2533.1 R2536.1 U11.40
MDP_DDC_CTRLCLK: RPH16.3 U7.R35 U11.33
MDP_DDC_CTRLDATA: RPH16.4 U7.R36 U11.34
MDP_HPD: RV411.2 U11.9
MDP_HPD_SINK: JMDP.2 U11.11
MDP_PEQ: R2532.1 R2535.1 U11.4
MDP_RST#: C2021.1 R2534.1 U11.35
MEM_TEMP0: HT1.1 RT5.1 UE1.B13
MEM_TEMP1: HT3.1 RT3.1 UE1.B6
MIC1_VREF: RA95.2 U15.30
MIC2_VREF: RA93.1 U15.1
MIC2L: CA68.1 U15.47
MIC2L_C: CA68.2 RA92.1
MIC2R: CA69.1 U15.48
MIC2R_C: CA69.2 RA94.1
MINI3CLK_REQ#: JTB1.18 RPH25.6 U7.T3
MONO_IN: CA17.1 U15.2
MULTI_STRAP_REF0_GND: RV318.1 UV1.J1
MUTE#: QA2.1 RA100.1 RA102.1 RZ38.2 UA5.1 UA5.2
NFC_DET#: JNFC1.12 RN7.1 RPH24.8 U7.Y3
NFC_IRQ: JNFC1.11 RH65.1 RN1.2 U7.H6
NFC_RST#: JNFC1.6 RPH24.5 U7.AE4
NFC_VDD_SIM: JNFC1.10 RN8.2 RN9.1
NTC: PR724.2 PU700.6
ODD_DA#: RPH2.2 U7.F17
ODD_DETECT#: RH171.2 U7.BB4
ODD_EN#: RPH9.6 U7.C16
P1: PC271.1 PL205.1 PL206.1 PR201.4
P1_SW: PL702.2 PR741.2 PR742.1
P2_SW: PL701.2 PR714.2 PR715.1
PBTN_OUT#: JXDP.41 T81.1(TP-1) U7.K1 UE1.H4
PBTN_SW#: DE2.2 DE9.1 RE48.2 SW1.1
PCH_CLK_BIASREF: RH28.1 U7.AN44
PCH_GPIO0: RPH8.5 U7.AT8
PCH_GPIO1: RH168.2 RH172.1 U7.F13
PCH_GPIO5: RH167.2 U7.M15
PCH_GPIO6: RPH8.7 U7.A14
PCH_GPIO12: RPH7.6 U7.K13
PCH_GPIO15: RH158.2 U7.AB11
PCH_GPIO16: RH176.2 RH191.2 U7.AN2
PCH_GPIO20: RPH25.7 U7.AF3
PCH_GPIO21: RH12.1 U7.AT1
PCH_GPIO24: RPH7.8 U7.Y10
PCH_GPIO28: RH165.2 U7.AD11
PCH_GPIO36: RH194.2 U7.AT3
PCH_GPIO37: RH169.2 U7.AK1
PCH_GPIO44: RPH24.7 U7.AA2
PCH_GPIO49: RH180.2 RH188.2 U7.AK3
PCH_GPIO52: RPH2.1 U7.B13
PCH_GPIO70: RH163.2 U7.G13
PCH_GPIO72: RPH4.5 U7.K7
PCH_INTVRMEN: RH13.2 RH16.2 U7.G10
PCH_JTAG_TCK: RH35.1 U7.AB3
PCH_JTAG_TDI: RH20.2 RH26.1 U7.AE2
PCH_JTAG_TDO: RH18.2 RH24.1 U7.AD3
PCH_JTAG_TMS: RH19.2 RH25.1 U7.AD1
PCH_PLTRST#: U7.Y11 UH4.1 UH5.1 UH5.2
PCH_PWROK_EC: RH193.2 T175.1(TP-1) U7.AB7 U7.F10 UE1.E6 UH3.1
PCH_RSMRST#: RH127.2 T177.1(TP-1) U7.J2 UE1.D4
PCH_RTCRST#: CH5.1 CLRP1.1 RH3.2 U7.D9
PCH_RTCX1: CH3.1 RH1.1 U7.B5 YH1.1
PCH_RTCX2: CH4.1 RH1.2 U7.B4 YH1.2
PCH_SATALED#: RH14.1 U7.AP3
PCH_SMBCLK: DE6.2 JDIMM1.202 JDIMM2.202 JTP.4 JXDP.53 QH2.1 RPH14.3 UN2.4
PCH_SMBDATA: DE6.3 JDIMM1.200 JDIMM2.200 JTP.3 JXDP.51 QH2.4 RPH14.4 UN2.6
PCH_SMLCLK: JTB1.38 QH3.1 QV7.1 QV21.6 RPH19.8 UE1.B8
PCH_SMLDATA: JTB1.40 QH3.4 QV7.4 QV21.3 RPH19.7 UE1.A6
PCH_SPI_CLK: RPH5.1 UH2.6
PCH_SPI_CLK_R: RPH5.8 U7.AJ11
PCH_SPI_CS1#: T7.1(TP-1) U7.AL7
PCH_SPI_CS#: RH33.2 U7.AJ7 UH2.1
PCH_SPI_HOLD#: RH40.2 RH41.1 UH2.7
PCH_SPI_HOLD#_R: RH41.2 U7.AJ2
PCH_SPI_SI: RPH5.2 UH2.5
PCH_SPI_SI_R: RPH5.7 U7.AH1
PCH_SPI_SO: RPH5.3 UH2.2
PCH_SPI_SO_R: RPH5.6 U7.AH3
PCH_SPI_WP#: RH38.2 RPH5.4 UH2.3
PCH_SPI_WP#_R: RPH5.5 U7.AJ4
PCH_SRTCRST#: CH6.2 CLRP2.2 RH4.2 U7.B9
PCH_SUSWARN#: RPH4.8 T178.1(TP-1) U7.J4 UE1.D8
PCH_TD_IREF: RH322.1 U7.AY43
PCI_PIRQA#: RPH1.1 U7.H20
PCI_PIRQB#: RPH1.2 U7.L20
PCI_PIRQC#: RPH1.4 U7.K17
PCI_PIRQD#: RPH1.3 U7.M20
PCIE_MCARD1_DET#: RPH8.8 U7.AT7
PCIE_PRX_CARDTX_N4: JTB1.39 U7.AT33
PCIE_PRX_CARDTX_P4: JTB1.37 U7.AR33
PCIE_PRX_WLANTX_N3: JTB1.43 U7.AW33
PCIE_PRX_WLANTX_P3: JTB1.45 U7.AY33
PCIE_PTX_CARDRX_N4: CH21.1 JTB1.81
PCIE_PTX_CARDRX_N4_C: CH21.2 U7.BE36
PCIE_PTX_CARDRX_P4: CH22.1 JTB1.79
PCIE_PTX_CARDRX_P4_C: CH22.2 U7.BC36
PCIE_PTX_WLANRX_N3: CH19.1 JTB1.73
PCIE_PTX_WLANRX_N3_C: CH19.2 U7.BE34
PCIE_PTX_WLANRX_P3: CH20.1 JTB1.75
PCIE_PTX_WLANRX_P3_C: CH20.2 U7.BC34
PCIE_RCOMP: RH113.2 U7.BD29
PCIECLKREQ0#: RPH24.6 U7.AB1
PEG_A_CLKRQ#: QV39.1 RH64.1 U7.AF6
PEG_B_CLKREQ#: RPH30.1 U7.U4
PEG_COMP: RU1.1 U6.AH6
PEG_GTX_C_HRX_N0: CV532.2 U6.Y2
PEG_GTX_C_HRX_N1: CV534.2 U6.Y3
PEG_GTX_C_HRX_N2: CV536.2 U6.V1
PEG_GTX_C_HRX_N3: CV538.2 U6.V4
PEG_GTX_C_HRX_N4: CV540.2 U6.V5
PEG_GTX_C_HRX_N5: CV542.2 U6.M2
PEG_GTX_C_HRX_N6: CV544.2 U6.L4
PEG_GTX_C_HRX_N7: CV546.2 U6.M4
PEG_GTX_C_HRX_N8: CV548.2 U6.L2
PEG_GTX_C_HRX_N9: CV551.2 U6.L5
PEG_GTX_C_HRX_N10: CV557.2 U6.B9
PEG_GTX_C_HRX_N11: CV559.2 U6.D9
PEG_GTX_C_HRX_N12: CV561.2 U6.E9
PEG_GTX_C_HRX_N13: CV563.2 U6.B10
PEG_GTX_C_HRX_N14: CV565.2 U6.C10
PEG_GTX_C_HRX_N15: CV567.2 U6.E10
PEG_GTX_C_HRX_P0: CV531.2 U6.Y1
PEG_GTX_C_HRX_P1: CV533.2 U6.Y4
PEG_GTX_C_HRX_P2: CV535.2 U6.V2
PEG_GTX_C_HRX_P3: CV537.2 U6.V3
PEG_GTX_C_HRX_P4: CV539.2 U6.Y5
PEG_GTX_C_HRX_P5: CV541.2 U6.M1
PEG_GTX_C_HRX_P6: CV543.2 U6.L3
PEG_GTX_C_HRX_P7: CV545.2 U6.M3
PEG_GTX_C_HRX_P8: CV547.2 U6.L1
PEG_GTX_C_HRX_P9: CV550.2 U6.M5
PEG_GTX_C_HRX_P10: CV552.2 U6.A9
PEG_GTX_C_HRX_P11: CV558.2 U6.C9
PEG_GTX_C_HRX_P12: CV560.2 U6.F9
PEG_GTX_C_HRX_P13: CV562.2 U6.A10
PEG_GTX_C_HRX_P14: CV564.2 U6.D10
PEG_GTX_C_HRX_P15: CV566.2 U6.F10
PEG_GTX_HRX_N0: CV532.1 UV1.AJ14
PEG_GTX_HRX_N1: CV534.1 UV1.AG14
PEG_GTX_HRX_N2: CV536.1 UV1.AJ15
PEG_GTX_HRX_N3: CV538.1 UV1.AK16
PEG_GTX_HRX_N4: CV540.1 UV1.AJ17
PEG_GTX_HRX_N5: CV542.1 UV1.AG17
PEG_GTX_HRX_N6: CV544.1 UV1.AJ18
PEG_GTX_HRX_N7: CV546.1 UV1.AK19
PEG_GTX_HRX_N8: CV548.1 UV1.AJ20
PEG_GTX_HRX_N9: CV551.1 UV1.AG20
PEG_GTX_HRX_N10: CV557.1 UV1.AJ21
PEG_GTX_HRX_N11: CV559.1 UV1.AK22
PEG_GTX_HRX_N12: CV561.1 UV1.AJ23
PEG_GTX_HRX_N13: CV563.1 UV1.AG23
PEG_GTX_HRX_N14: CV565.1 UV1.AJ24
PEG_GTX_HRX_N15: CV567.1 UV1.AK25
PEG_GTX_HRX_P0: CV531.1 UV1.AK14
PEG_GTX_HRX_P1: CV533.1 UV1.AH14
PEG_GTX_HRX_P2: CV535.1 UV1.AK15
PEG_GTX_HRX_P3: CV537.1 UV1.AL16
PEG_GTX_HRX_P4: CV539.1 UV1.AK17
PEG_GTX_HRX_P5: CV541.1 UV1.AH17
PEG_GTX_HRX_P6: CV543.1 UV1.AK18
PEG_GTX_HRX_P7: CV545.1 UV1.AL19
PEG_GTX_HRX_P8: CV547.1 UV1.AK20
PEG_GTX_HRX_P9: CV550.1 UV1.AH20
PEG_GTX_HRX_P10: CV552.1 UV1.AK21
PEG_GTX_HRX_P11: CV558.1 UV1.AL22
PEG_GTX_HRX_P12: CV560.1 UV1.AK23
PEG_GTX_HRX_P13: CV562.1 UV1.AH23
PEG_GTX_HRX_P14: CV564.1 UV1.AK24
PEG_GTX_HRX_P15: CV566.1 UV1.AL25
PEG_HTX_C_GRX_N0: CU16.2 UV1.AM12
PEG_HTX_C_GRX_N1: CU15.2 UV1.AM14
PEG_HTX_C_GRX_N2: CU14.2 UV1.AP15
PEG_HTX_C_GRX_N3: CU13.2 UV1.AM15
PEG_HTX_C_GRX_N4: CU12.2 UV1.AM17
PEG_HTX_C_GRX_N5: CU11.2 UV1.AP18
PEG_HTX_C_GRX_N6: CU10.2 UV1.AM18
PEG_HTX_C_GRX_N7: CU9.2 UV1.AM20
PEG_HTX_C_GRX_N8: CU8.2 UV1.AP21
PEG_HTX_C_GRX_N9: CU7.2 UV1.AM21
PEG_HTX_C_GRX_N10: CU6.2 UV1.AM23
PEG_HTX_C_GRX_N11: CU5.2 UV1.AP24
PEG_HTX_C_GRX_N12: CU4.2 UV1.AM24
PEG_HTX_C_GRX_N13: CU3.2 UV1.AM26
PEG_HTX_C_GRX_N14: CU2.2 UV1.AP27
PEG_HTX_C_GRX_N15: CU1.2 UV1.AM27
PEG_HTX_C_GRX_P0: CU32.2 UV1.AN12
PEG_HTX_C_GRX_P1: CU31.2 UV1.AN14
PEG_HTX_C_GRX_P2: CU30.2 UV1.AP14
PEG_HTX_C_GRX_P3: CU29.2 UV1.AN15
PEG_HTX_C_GRX_P4: CU28.2 UV1.AN17
PEG_HTX_C_GRX_P5: CU27.2 UV1.AP17
PEG_HTX_C_GRX_P6: CU26.2 UV1.AN18
PEG_HTX_C_GRX_P7: CU25.2 UV1.AN20
PEG_HTX_C_GRX_P8: CU24.2 UV1.AP20
PEG_HTX_C_GRX_P9: CU23.2 UV1.AN21
PEG_HTX_C_GRX_P10: CU22.2 UV1.AN23
PEG_HTX_C_GRX_P11: CU21.2 UV1.AP23
PEG_HTX_C_GRX_P12: CU20.2 UV1.AN24
PEG_HTX_C_GRX_P13: CU19.2 UV1.AN26
PEG_HTX_C_GRX_P14: CU18.2 UV1.AP26
PEG_HTX_C_GRX_P15: CU17.2 UV1.AN27
PEG_HTX_GRX_N0: CU16.1 U6.T1
PEG_HTX_GRX_N1: CU15.1 U6.T4
PEG_HTX_GRX_N2: CU14.1 U6.R4
PEG_HTX_GRX_N3: CU13.1 U6.R2
PEG_HTX_GRX_N4: CU12.1 U6.R6
PEG_HTX_GRX_N5: CU11.1 U6.T6
PEG_HTX_GRX_N6: CU10.1 U6.J2
PEG_HTX_GRX_N7: CU9.1 U6.J3
PEG_HTX_GRX_N8: CU8.1 U6.G3
PEG_HTX_GRX_N9: CU7.1 U6.J5
PEG_HTX_GRX_N10: CU6.1 U6.E3
PEG_HTX_GRX_N11: CU5.1 U6.G4
PEG_HTX_GRX_N12: CU4.1 U6.D4
PEG_HTX_GRX_N13: CU3.1 U6.E6
PEG_HTX_GRX_N14: CU2.1 U6.C5
PEG_HTX_GRX_N15: CU1.1 U6.B6
PEG_HTX_GRX_P0: CU32.1 U6.T2
PEG_HTX_GRX_P1: CU31.1 U6.T3
PEG_HTX_GRX_P2: CU30.1 U6.R3
PEG_HTX_GRX_P3: CU29.1 U6.R1
PEG_HTX_GRX_P4: CU28.1 U6.R5
PEG_HTX_GRX_P5: CU27.1 U6.T5
PEG_HTX_GRX_P6: CU26.1 U6.J1
PEG_HTX_GRX_P7: CU25.1 U6.J4
PEG_HTX_GRX_P8: CU24.1 U6.G2
PEG_HTX_GRX_P9: CU23.1 U6.J6
PEG_HTX_GRX_P10: CU22.1 U6.E2
PEG_HTX_GRX_P11: CU21.1 U6.G5
PEG_HTX_GRX_P12: CU20.1 U6.E4
PEG_HTX_GRX_P13: CU19.1 U6.D6
PEG_HTX_GRX_P14: CU18.1 U6.B5
PEG_HTX_GRX_P15: CU17.1 U6.C6
PEX_TSTCLK_OUT: RV286.2 UV1.AJ26
PEX_TSTCLK_OUT#: RV286.1 UV1.AK26
PHASE1: PC727.2 PQ703.3 PU700.20
PHASE2: PC706.2 PQ700.3 PU700.25
PLT_RST#: CM22.1 JSSD.17 JTB1.30 RE57.2 RH155.1 RU12.2 U1.16 UE1.M5 UH5.4 UU2.2
PLTRST_VGA#: RH154.1 UH4.4 UV1.AJ12
PM_CLKRUN#: RH120.2 RH136.2 U1.15 U7.AN7
PM_DRAM_PWRGD: RU51.1 U7.H3
PM_SLP_A#: T37.1(TP-1) U7.F3
PM_SLP_S3#: JTB1.48 PR409.1 PR503.1 RN30.1 RN42.1 T44.1(TP-1) U7.H1 UE1.J5 UN3.3 UZ4.3 UZ4.5
PM_SLP_S4#: PR407.1 T42.1(TP-1) U7.C6 UE1.N1
PM_SLP_S5#: T41.1(TP-1) U7.Y7 UE1.N9
PM_SLP_SUS#: RZ30.1 T40.1(TP-1) U7.F1 UE1.F2 UZ14.3
PM_SYS_PWRGD_BUF: QU7.1 R59.1 RU43.1 RU60.2 UU3.4
PM_SYS_PWRGD_BUF_R: RU43.2 RU56.2 U6.AP48
POK: PR110.2 PR112.1 PR337.1 U7.L13
PP: R1.1 U1.7
PS_ID: PD100.1 PR102.2 PR103.2 UE1.K6
PSID: ADP100.4 PL101.1
PSID-1: PQ101.2 PR104.2 PR106.1
PSID-2: PQ100.2 PQ101.1 PR105.1
PSID-3: PQ100.3 PR101.2 PR103.1
PWR_SRC_ON: CV751.2 QV29.3 RV412.2 RV413.1
PWRBTN_LED#: QZ20.2 UE1.A3
PWRSHARE_OE#1: RI19.2 US1.9
PWRSHARE_OE#3: RI30.2 US2.9
REF_+1.5V_RUNP: PC605.2 PR600.1 PU600.26
REGN: PC212.1 PD201.2 PR217.1 PR224.2 PU200.16
REXT_SATA: RN16.1 RN40.1 UN1.20
RF_+V1.05V: PR505.1 PU500.5
RI#: RPH4.6 U7.N4
RING2: CA34.1 DA2.3 JHP2.3 RA20.2 U15.31
ROM_CS_GPU: RV507.1 UV1.H6
ROM_CS_GPU_R: RV506.2 RV507.2 U23.1
ROM_SCLK_GPU: RV305.1 RV313.2 RV509.1 UV1.H4
ROM_SCLK_GPU_R: RV509.2 U23.6
ROM_SI_GPU: RV304.1 RV312.2 RV508.1 UV1.H5
ROM_SI_GPU_R: RV508.2 U23.5
ROM_SO_GPU: RV303.1 RV311.2 U23.2 UV1.H7
S5_1.35V: PR407.2 PU400.8
SATA_APRE0: RN3.1 RN6.1 UN1.9
SATA_APRE1: RN11.2 RN15.2 UN1.19
SATA_BPRE0: RN4.1 RN20.1 UN1.8
SATA_BPRE1: RN10.2 RN14.2 UN1.17
SATA_PRX_DTX_N0: CN10.1 U7.BC8
SATA_PRX_DTX_N0_C: CN10.2 UN1.4
SATA_PRX_DTX_N0_RC: CN9.1 UN1.12
SATA_PRX_DTX_N0_RC1: CN9.2 JHDD.5
SATA_PRX_DTX_N1: JSSD.25 U7.BC10
SATA_PRX_DTX_P0: CN11.1 U7.BE8
SATA_PRX_DTX_P0_C: CN11.2 UN1.5
SATA_PRX_DTX_P0_RC: CN8.1 UN1.11
SATA_PRX_DTX_P0_RC1: CN8.2 JHDD.6
SATA_PRX_DTX_P1: JSSD.23 U7.BE10
SATA_PTX_DRX_N0: CN18.1 U7.AW8
SATA_PTX_DRX_N0_C: CN18.2 UN1.2
SATA_PTX_DRX_N0_RC: CN13.1 UN1.14
SATA_PTX_DRX_N0_RC1: CN13.2 JHDD.3
SATA_PTX_DRX_N1: CH18.1 U7.AV10
SATA_PTX_DRX_N1_C: CH18.2 JSSD.31
SATA_PTX_DRX_P0: CN19.1 U7.AY8
SATA_PTX_DRX_P0_C: CN19.2 UN1.1
SATA_PTX_DRX_P0_RC: CN12.1 UN1.15
SATA_PTX_DRX_P0_RC1: CN12.2 JHDD.2
SATA_PTX_DRX_P1: CH17.1 U7.AW10
SATA_PTX_DRX_P1_C: CH17.2 JSSD.33
SATA_RCOMP: RH21.1 U7.AY5
SATA_TEST: RN12.2 RN13.2 UN1.18
SCLK: PR702.2 PR706.2 PU700.1
SDA: PR700.2 PR703.2 PU700.31
SENSE_B#: RA22.1 U15.33
SERIRQ: RH75.2 U1.27 U7.AL11 UE1.M3
SKIN_TEMP0: HT2.1 RT6.1 UE1.E7
SKIN_TEMP1: HT4.1 RT1.1 UE1.D7
SLEEVE: CA37.1 DA3.2 JHP2.4 QA3.6 RA19.2 U15.32
SLP_LAN#: T38.1(TP-1) U7.G5
SLP_WLAN#: T170.1(TP-1) U7.D2
SM_INTRUDER#: RH2.2 U7.A8
SM_RCOMP0: RU58.1 U6.BB51
SM_RCOMP1: RU59.1 U6.BB53
SM_RCOMP2: RU61.1 U6.BB52
SMBCLK: QH2.6 RH448.1 U7.R10
SMBDATA: QH2.3 RH456.1 U7.U11
SML0CLK: DN2.2 JNFC1.8 RH724.1 U7.U8
SML0DATA: DN2.3 JNFC1.9 RH725.1 U7.R7
SML1CLK: QH3.6 RPH14.1 U7.K6
SML1DATA: QH3.3 RPH14.2 U7.N11
SNUB_1.35V: PC409.1 PR403.2
SNUB_3V: PC316.1 PR309.2
SNUB_5V: PC317.1 PR310.2
SPK_L+: CA54.1 DA4.2 JSPK1.1 LA11.2
SPK_L-: CA55.1 DA4.3 JSPK1.2 LA8.2
SPK_LC+: CA30.1 CA53.2 UA5.3
SPK_LC-: CA58.2 UA5.4
SPK_OUT_L+: CA61.2 LA11.1 UA5.25
SPK_OUT_L-: CA62.2 LA8.1 UA5.23
SPK_OUT_R+: CA72.2 LA7.1 UA5.18
SPK_OUT_R-: CA73.2 LA9.1 UA5.20
SPK_R+: CA56.1 DA5.3 JSPK1.3 LA7.2
SPK_R-: CA57.1 DA5.2 JSPK1.4 LA9.2
SPK_RC+: CA59.2 UA5.12
SPK_RC-: CA60.2 UA5.11
SPKL+: CA61.1 UA5.26
SPKL-: CA62.1 UA5.22
SPKR+: CA72.1 UA5.17
SPKR-: CA73.1 UA5.21
SRN: PR221.1 PU200.12
SRP: PR218.1 PU200.13
STRAP0: RV308.1 RV316.2 UV1.J2
STRAP1: RV307.1 RV315.2 UV1.J7
STRAP2: RV306.1 RV314.2 UV1.J6
STRAP3: RV302.1 RV310.2 UV1.J5
STRAP4: RV301.1 RV309.2 UV1.J3
SUSACK#: T176.1(TP-1) U7.R6 UE1.M13
SUSCLK_R: JTB1.22 RE39.1 T39.1(TP-1) U7.Y6
SW_1.35V: PC404.1 PL400.2 PQ400.1 PQ400.2 PQ400.3 PQ401.5 PR403.1 PU400.16
SW_+1.5VRUN: PL600.1 PR607.2 PR608.1 PU600.6 PU600.7 PU600.8 PU600.9
SW_+V1.05V: PC504.2 PL500.1 PQ500.1 PQ500.2 PQ500.3 PQ501.5 PR504.1 PU500.8
SYS_PWROK: RH130.2 U7.AD7 UH3.4
SYSTEM_FAN2_FB: JTB1.44 UE1.N11
SYSTEM_FAN2_PWM: JTB1.42 UE1.M10
SYSTEM_FAN_FB: CE27.1 DE4.2 RE51.2 UE1.M11
SYSTEM_FAN_PWM: JFAN1.1 UE1.N10
THM_ALERT#: RPH33.3 UV1.M2
THM_OVERT#: QV40.1 RE322.1
THM_OVERT#_R: QV40.3 RPH33.2 UV1.M1
TMDS_L_TX0N: DV4.4 DV4.7 JHDMI.9 LV8.2
TMDS_L_TX0P: DV4.5 DV4.6 JHDMI.7 LV8.3
TMDS_L_TX1N: DV5.5 DV5.6 JHDMI.6 LV9.2
TMDS_L_TX1P: DV5.4 DV5.7 JHDMI.4 LV9.3
TMDS_L_TX2N: DV5.2 DV5.8 JHDMI.3 LV10.2
TMDS_L_TX2P: DV5.1 DV5.9 JHDMI.1 LV10.3
TMDS_L_TXCN: DV4.1 DV4.9 JHDMI.12 LV7.2
TMDS_L_TXCP: DV4.2 DV4.8 JHDMI.10 LV7.3
TMDS_RD_TX0N: LV8.1 U22.24
TMDS_RD_TX0P: LV8.4 U22.25
TMDS_RD_TX1N: LV9.1 U22.26
TMDS_RD_TX1P: LV9.4 U22.27
TMDS_RD_TX2N: LV10.1 U22.29
TMDS_RD_TX2P: LV10.4 U22.30
TMDS_RD_TXCN: LV7.1 U22.21
TMDS_RD_TXCP: LV7.4 U22.22
TMDS_TX0N: CV760.1 U22.7
TMDS_TX0P: CV761.1 U22.6
TMDS_TX1N: CV762.1 U22.5
TMDS_TX1P: CV763.1 U22.4
TMDS_TX2N: CV764.1 U22.2
TMDS_TX2P: CV765.1 U22.1
TMDS_TXCN: CV758.1 U22.10
TMDS_TXCP: CV759.1 U22.9
TP_CLK: C13.1 L1.1 RPE2.8 UE1.A5
TP_CLK_R: C15.1 DE5.2 JTP.2 L1.2
TP_DATA: C14.1 L2.1 RPE2.7 UE1.B5
TP_DATA_R: C16.1 DE5.3 JTP.1 L2.2
TRIP_+V1.05V: PR502.2 PU500.2
TS_SLEEP#: DV17.1 UE36.6
U2_BOOT1: PR801.1 PU800.1
U2_BOOT2: PR813.1 PU800.18
U2_BOOT3: PR832.1 PU801.4
U2_LGATE1: PQ800.4 PR837.2 PU800.23
U2_LGATE2: PQ801.4 PU800.20
U2_LGATE3: PQ802.4 PU801.7
U2_PHASE1: PC800.2 PQ800.3 PR850.1 PU800.24
U2_PHASE2: PC813.2 PQ801.3 PR851.1 PU800.19
U2_PHASE3: PC839.2 PQ802.3 PR852.1 PU801.2
U2_PWM3: PU800.22 PU801.5
U2_UGATE1: PQ800.2 PU800.2
U2_UGATE2: PQ801.2 PU800.17
U2_UGATE3: PQ802.2 PU801.3
UG_3V: PQ300.4 PU300.10
UG_5V: PQ301.4 PU300.16
UG_+V1.05V: PQ500.4 PU500.9
UGATE1: PQ703.2 PU700.19
UGATE2: PQ700.2 PU700.26
USB0_CTL1: RE63.2 UE1.B4 US1.6
USB0_DET_EC#: DE7.1 DE10.1 JUSB1.10
USB0_DET_EC#_D: DE7.2 RE55.2 UE1.K2
USB0_PWR_EN_EC: RI17.2 UE1.B1 US1.5
USB1_CTL1: RE65.2 UE1.H1 US2.6
USB1_DET_EC#: DE13.1 DE15.1 JUSB3.10
USB1_DET_EC#_D: DE13.2 RE69.2 UE1.J2
USB1_PWR_EN_EC: RI32.2 UE1.D5 US2.5
USB2_CTL1: JTB1.6 UE36.14
USB2_DET_EC#: DE14.1 DE16.1 JTB1.2
USB2_DET_EC#_D: DE14.2 RE71.2 UE36.8
USB2_PWR_EN_EC: JTB1.4 UE36.16
USB3_CTL1: JTB1.16 UE36.15
USB3_DET_EC#: DE17.1 DE18.1 JTB1.12
USB3_DET_EC#_D: DE17.2 RE72.2 UE36.18
USB3_PWR_EN_EC: JTB1.14 UE36.19
USB3RN1: CI5.1 U7.AR26
USB3RN1_8723: LI3.4 UI5.27
USB3RN1_C: CI5.2 UI5.1
USB3RN1_D-: DI1.1 DI1.9 JUSB1.5 LI3.3
USB3RN2: CI11.1 U7.AW26
USB3RN2_8723: LI9.4 UI5.21
USB3RN2_C: CI11.2 UI5.7
USB3RN2_D-: DI6.1 DI6.9 JUSB3.5 LI9.3
USB3RN3: JTB1.57 U7.AW29
USB3RN4: JTB1.51 U7.AR29
USB3RP1: CI6.1 U7.AP26
USB3RP1_8723: LI3.1 UI5.26
USB3RP1_C: CI6.2 UI5.2
USB3RP1_D+: DI1.2 DI1.8 JUSB1.6 LI3.2
USB3RP2: CI12.1 U7.AV26
USB3RP2_8723: LI9.1 UI5.20
USB3RP2_C: CI12.2 UI5.8
USB3RP2_D+: DI6.2 DI6.8 JUSB3.6 LI9.2
USB3RP3: JTB1.55 U7.AV29
USB3RP4: JTB1.49 U7.AP29
USB3T_N1: CI3.2 LI2.4
USB3T_N2: CI16.2 LI8.4
USB3T_P1: CI4.2 LI2.1
USB3T_P2: CI17.2 LI8.1
USB3TN1: CI7.1 U7.BE24
USB3TN1_8723: CI3.1 UI5.24
USB3TN1_C: CI7.2 UI5.4
USB3TN1_D-: DI1.4 DI1.7 JUSB1.8 LI2.3
USB3TN2: CI13.1 U7.BD25
USB3TN2_8723: CI16.1 UI5.18
USB3TN2_C: CI13.2 UI5.10
USB3TN2_D-: DI6.4 DI6.7 JUSB3.8 LI8.3
USB3TN3: JTB1.61 U7.BE26
USB3TN4: JTB1.69 U7.BD27
USB3TP1: CI8.1 U7.BD23
USB3TP1_8723: CI4.1 UI5.23
USB3TP1_C: CI8.2 UI5.5
USB3TP1_D+: DI1.5 DI1.6 JUSB1.9 LI2.2
USB3TP2: CI20.1 U7.BC24
USB3TP2_8723: CI17.1 UI5.17
USB3TP2_C: CI20.2 UI5.11
USB3TP2_D+: DI6.5 DI6.6 JUSB3.9 LI8.2
USB3TP3: JTB1.63 U7.BC26
USB3TP4: JTB1.67 U7.BE28
USB20_N0: U7.B37 US1.2
USB20_N1: U7.A38 US2.2
USB20_N2: JTB1.15 U7.A36
USB20_N3: JTB1.3 U7.A34
USB20_N4: JTB1.9 U7.B33
USB20_N9: LI4.1 RI8.1 U7.A30
USB20_N9_R: DI3.2 JTS.4 LI4.2 RI8.2
USB20_N12: JTB1.21 U7.G26
USB20_P0: U7.D37 US1.3
USB20_P1: U7.C38 US2.3
USB20_P2: JTB1.13 U7.C36
USB20_P3: JTB1.1 U7.C34
USB20_P4: JTB1.7 U7.D33
USB20_P9: LI4.4 RI9.1 U7.C30
USB20_P9_R: DI3.3 JTS.3 LI4.3 RI9.2
USB20_P12: JTB1.19 U7.F26
USB8723_TEST: RI468.1 UI5.22
USB_D_PD#: JTB1.46 UE36.7 UI5.12
USB_ILIM_SEL: JTB1.10 RE61.1 UE36.22 US1.4 US2.4
USB_MCARD1_DET#: RH177.2 U7.H15
USB_OC0#: RPH29.1 U7.P3 US1.13 US2.13
USB_OC1#: JTB1.8 RH84.1 U7.V1
USB_OC2#: RPH30.3 U7.U2
USB_OC3#: RPH30.4 U7.P1
USB_OC4#: RPH29.4 U7.M3
USB_OC5#: RPH30.2 U7.T1
USB_OC6#: RPH29.2 U7.N2
USB_OC7#: RPH29.3 U7.M1
USBCHG_DET#_D: DE10.2 DE15.2 DE16.2 DE18.2 QE1.2 RE44.1 RE50.2
USBCHG_DET_D: QE1.1 RE59.2 RE341.1
USBP0_D+: LI1.1 US1.10
USBP0_D-: LI1.4 US1.11
USBP0_R_D+: DI2.2 JUSB1.3 LI1.2
USBP0_R_D-: DI2.3 JUSB1.2 LI1.3
USBP1_D+: LI7.1 US2.10
USBP1_D-: LI7.4 US2.11
USBP1_R_D+: DI5.2 JUSB3.3 LI7.2
USBP1_R_D-: DI5.3 JUSB3.2 LI7.3
USBRBIAS: RH143.1 U7.K24 U7.K26
VCIN0_PH: HU101.1 RU118.1 UE1.C2
VCIN1_PH: PC111.1 PR116.2 PR118.1 UE1.D2
VCORE_VDDP: PC708.2 PR712.2 PU700.22 PU700.23
VCOUT0_PH#: RE32.1 RE321.1 UE1.E4
VR_HOT_CPU: PR722.2 PU700.5
VR_ON: PR710.1 RE36.1 UE1.J1
VR_ON_VCORE: PR710.2 PU700.2
VR_SVID_ALRT#: PR705.1 RU91.2 RU93.1
VR_SVID_CLK: PR706.1 U6.J52
VR_SVID_DAT: PR703.1 RU90.2 U6.J50
VSB_N_001: PC108.2 PQ102.3 PR107.2 PR108.2
VSB_N_002: PC110.1 PQ103.2 PR112.2
VSB_N_003: PQ103.1 PR108.1
VSET: RZ600.2 RZ601.1 UZ600.4
WAKE#: RPH4.7 U7.K3
WAKE_PCH#: RE76.2 RH170.2 RH173.2 U7.R11 UE1.L12
WL_OFF#: JTB1.26 RH243.2 RPH2.4 U7.AL6
WLAN_WAKE#: DE12.2 RE66.2 UE36.21
XDP_BPM#0: JXDP.21 U6.R51
XDP_BPM#1: JXDP.23 U6.R50
XDP_DBRESET#: JXDP.48 RU35.1 U6.F53 U7.AM1
XDP_PRDY#: JXDP.5 U6.N53
XDP_PREQ#: JXDP.3 U6.N52
XDP_RST#_R: JXDP.46 RU12.1
XDP_TCK: JXDP.57 RU67.1 U6.N54
XDP_TDI: JXDP.56 U6.N49
XDP_TDO: JXDP.52 RU66.1 U6.M49
XDP_TMS: JXDP.58 U6.M51
XDP_TRST#: JXDP.54 RU68.1 U6.M53
XTAL25_IN: CH28.1 RH89.2 U7.AL44 YH2.3
XTAL25_OUT: CH27.1 RH89.1 U7.AM43 YH2.1
XTAL_5505_IN: CA97.1 U12.2 YA2.3
XTAL_5505_OUT: CA96.1 U12.3 YA2.1
XTALOUTBUFF: RPH32.1 UV1.J4
XTALSSIN: RPH32.2 UV1.H1
N05583: PQ201.5 PQ201.6 PQ201.7 PQ201.8 PR201.1
N3514407: PR305.2 PU300.5
N3514423: PC307.1 PR335.2 PU300.3
N3514453: PC319.1 PU300.13
N6647607: PD200.1 PR213.1
N6650847: PC202.1 PC203.1 PC204.1 PC205.1 PC206.1 PC207.1 PL205.2 PL206.2 PQ204.1
N6654636: PC200.2 PC208.2 PR207.2 PR208.1
N6663158: PQ208.4 PR227.2
N6682547: PQ200.4 PQ201.4 PR207.1
N6682601: PC216.2 PD201.1 PR215.2
N12536479: PC228.2 PQ207.2 PR225.1
N17034077: PR306.1 PU300.1
N17034092: PC320.1 PR338.1 PU300.12
N17198654: RV479.1 UV1.AG10
N17766075: CV643.1 RV348.1 RV349.1
N17832487: RV352.2 UV5.J1
N17860472: RV354.2 UV5.J13
N17888940: RV327.1 UV1.J27
N17889477: RV328.1 UV1.H27
N17890015: RV329.1 UV1.H25
N17929472: RV330.1 UV1.F2
N17930576: RV332.1 UV1.F1
N18066258: QV22.1 RV357.2 RV359.2
N18135138: RV346.2 UV1.G14
N18135149: RV347.2 UV1.G20
N18386177: CV668.1 RV361.1 RV362.1
N18928736: RU51.2 RU76.2 UU3.2
N19849916: PC614.2 PR608.2
N19912586: PL802.1 PQ801.5 PQ801.6 PQ801.7 PR822.1
N20180024: PC820.1 PR815.2 PR817.1
N20194225: PC811.1 PR804.2 PR807.2 PR809.1
N21723775: PT601.1(TP-1) PU600.1
N23212224: JKBL.3 R30.2
N23484074: RN18.1 UN1.16
N23484361: RN42.2 UN1.7
N25669355: RV365.2 UV6.J13
N25669840: RV363.2 UV6.J1
N30765189: C8.1 R2.2
N35393149: RV290.1 UV1.AP29
N37456018: CE58.1 QZ24.5 QZ24.6 RE54.2
N48708347: PC404.2 PR400.1
N48708367: PR409.2 PU400.7
N48708425: PR406.2 PU400.9
N48711271: PH700.2 PR724.1 PR727.2
N48711504: PL702.1 PQ703.5 PQ703.6 PQ703.7 PR743.1
N49558169: PC728.1 PR743.2
N50583534: PC711.1 PR725.1 PU700.17
N50650291: PR704.2 PU700.28
N50662090: PR709.2 PU700.30
N50663336: PR707.2 PU700.29
N51036953: PC722.1 PR734.1 PU700.14
N51069821: PC730.1 PC731.1 PR747.2
N51091911: PC714.1 PR730.1 PU700.16
N51163915: QZ5.6 RZ10.2
N51163924: QZ5.3 RZ11.2
N51197016: PC507.1 PC510.2 PJP501.1 PJP502.1 PL500.2 PR507.2
N52118688: PC506.1 PR510.1 PU500.7
N52999986: PD102.2 PD102.3 PL101.2 PQ100.1 PR101.1 PR104.1
N55060104: QN2.5 QN2.6 RN26.2
N55155843: QV30.1 RV413.2
N55341619: RV391.2 UV10.J13
N55342064: RV389.2 UV10.J1
N55342363: CV718.1 RV387.1 RV388.1
N55351604: CV693.1 RV374.1 RV375.1
N55351739: RV378.2 UV9.J1
N55351833: RV380.2 UV9.J13
N55360027: RV344.2 UV1.R28
N55376079: CZ6.1 CZ8.1 RZ5.2 UZ1.4
N66076440: CE11.1 RE13.2
N76227960: CA75.1 RA60.1 RA61.1 UA5.10
N76228019: CA76.1 RA61.2 UA5.9
N76426526: QZ17.6 RZ15.2
N76474852: QZ17.3 RZ6.2
N85751893: PC509.1 PR504.2
N87586804: T6.1(TP-1) U7.AD10
N89512774: PQ202.1 PQ203.3 PR202.2 PR203.2
N89512778: PQ203.5 PQ203.6 PR204.2 PR211.1
N89512794: PC213.1 PQ203.2 PR212.2
N89515927: PC200.1 PQ200.1 PQ200.2 PQ200.3 PQ201.1 PQ201.2 PQ201.3 PR200.1
N89520789: PL701.1 PQ700.5 PQ700.6 PQ700.7 PR716.1
N91124401: DV8.1 HDMIF1.2
N94674399: RTCD1.2 RTCR1.1
N96795421: JP6.1 U7.R24 U7.R26 U7.R28 U7.U26
N97573639: JP7.1 U7.U30 U7.V28 U7.V30 U7.Y30
N98184072: CH72.1 CH75.1 CH76.1 CH78.1 CH95.1 JP5.2 U7.AK22 U7.AM18 U7.AM20 U7.AM22 U7.AP22 U7.AR22 U7.AT22
N100081938: RV429.2 U22.13
N100123145: RV458.2 U22.18
N100135407: RV444.2 U22.23
N104640372: JDIMM1.197 RD8.2
N104640401: JDIMM1.201 RD9.2
N104706821: JDIMM2.197 RD16.2
N104706826: JDIMM2.201 RD15.2
N107416912: RV8.2 RV501.2 UV1.E1
N108767585: PL203.1 PQ204.5 PQ204.6 PQ204.7 PR222.1
N108866597: PC252.1 PR282.2 PU202.3
N108866653: PC250.1 PR281.2 PT200.1(TP-1)
N108873638: PR341.1 PU300.20
N109409461: RN17.1 UN1.10
N109777135: QV39.2 RV289.1
N109801948: QZ5.2 QZ19.1 RZ12.2
N109970739: PR350.1 PU300.19
N110156589: RE74.1 UE36.13
N110678802: PC706.1 PR713.2
N110678827: PC727.1 PR740.2
N110682945: PC722.2 PR739.1
N110700740: PC821.1 PR824.2
N110703687: PC809.1 PR806.2
N110725812: PC726.1 PR736.2
N110740517: PC224.1 PR222.2
N110805086: PC260.1 PQ230.2 PR290.2
N110807082: PC261.2 PQ231.5 PR294.1
N110807094: PC261.1 PQ231.6 PR292.2
N110807104: PQ231.2 PR291.2 PR293.1
N110833422: PL801.1 PQ800.5 PQ800.6 PQ800.7 PR806.1
N110836828: PC838.1 PR830.2
N110836908: PL803.1 PQ802.5 PQ802.6 PQ802.7 PR830.1
N110922537: PC504.1 PR501.2
N110935137: PC718.1 PR732.2
N110935195: PC725.1 PR738.2
N110935541: PC800.1 PR801.2
N110936515: PC813.1 PR813.2
N110936719: PC824.1 PR827.2
N110936976: PC839.1 PR832.2
N111031508: PR280.2 PU202.1
N111036757: PR852.2 PU800.13
N111036762: PR851.2 PU800.14
N111036767: PR850.2 PU800.15
N111046328: PH701.2 PR749.1
N111069434: PR600.2 PR602.2 PU600.25
N111120800: PC602.2 PU600.21
N111178724: ADP100.5 ADP100.6 ADP100.7 PC121.1 PL103.1 PL108.1
N111701081: QZ24.4 RE84.1
N111798152: CZ15.1 UZ4.12
N111798158: CZ38.1 UZ4.10
N112063266: C2020.1 U11.2
N112063456: R2515.2 U11.7
N112071134: RI320.1 UI5.30
N112104092: RA75.1 U12.41
N112104127: CA91.1 RA76.2
N112104904: CA94.1 RA89.2
N112208327: DPF1.1 DV9.1
N112581938: JHP2.5 RA4.1
N112582115: LA5.1 RA18.2
N112582117: LA6.1 RA17.2
N112583802: CA26.1 U15.38
N112583814: CA14.1 U15.36
N112583837: CA20.2 U15.20
N112583855: RA7.2 U15.35
N112583857: CA5.1 CA6.1 LA1.2 U15.25
N112583906: CA21.2 U15.10
N112583945: CA16.2 U15.41
N112583953: CA15.2 U15.21
N112583955: CA15.1 U15.24
N113011856: QU7.3 RU56.1
N113014039: DE305.2 RE341.2
N113014056: DE303.2 RE340.2
N113014135: DE304.1 RE321.2
N113172796: DE4.1 JFAN1.3 RE53.2
N113206218: CA17.2 CA32.1 RA5.2 RA9.1 RA10.1 RA11.1
N113470198: QA3.2 QA3.3 RA43.2
N113470202: QA3.5 RA42.1 RA101.2 RA102.2
N113473311: QA4.3 RA44.2 RA55.1
N113473853: CA22.1 QA4.2 RA55.2
N113477170: CA28.2 UA2.B3
N113477928: RA99.2 RA100.2 UA2.B1
N113626745: QV23.1 RV370.2 RV372.2
N113629630: CT21.1 U4.4
N113637608: QV24.1 RV383.2 RV385.2
N113676531: QV25.1 RV396.2 RV398.2
N113699173: RV345.2 UV1.AC28
N113760009: QZ18.1 QZ25.2 RZ484.1
N113846970: DE306.1 RE322.2
N114071099: QV7.2 QV7.5 RV416.1 RV419.1
N114300903: R72.2 U1.28
N114414277: CZ602.1 RZ602.2 UZ600.1
N115378415: R66.1 SW1.5
N115378546: QZ20.1 SW1.4 SW1.6
N116140097: JEDP1.36 RV480.2
N116140123: JEDP1.23 RV481.2
N116140149: JEDP1.18 RV482.2
N116494866: PC607.2 PR607.1
N116495432: PC707.1 PR716.2
N116496514: PC822.1 PR822.2
N116508096: PR853.2 PU801.1
N116579401: T46.1(TP-1) U7.U7
N116608481: CA30.2 RA11.2
N117057142: R67.1 SW1.3
N117059899: DV17.2 DV20.2 JTS.5 RV5.2
N117846833: Q15.5 Q15.6 R12.2
N117847159: Q16.5 Q16.6 R21.2
N117847657: Q17.5 Q17.6 R18.2
N117847900: Q18.5 Q18.6 R25.2
N117848353: Q19.5 Q19.6 R27.2
N117848549: Q20.5 Q20.6 R33.2
N117915684: PR340.2 PU300.6
N117915720: PR337.2 PU300.7
N118699787: DV13.3 RV11.2
N118700499: DV10.3 RV12.2
N118700526: T126.1(TP-1) UE1.D1
N118750823: RE469.1 UE36.23

Pads without a net: D8 3; DE2 3; DV8 3; DV9 3; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JHDD 20; JKBL 2; JNFC1 4 5 13; JSSD 1 3 5 6 7 11 13 20 22 28 30 32 36 38 42 44 45 46 47 48; JTB1 62; JTP 5 8; JTS 2; JXDP 55; PU600 2 3 4 20 27; PU700 10; U1 6 12 13 14; U6 A4 A5 A6 A16 A17 A51 AD45 AE9 AF9 AG45 AH9 AH49 AL6 AM48 AM49 AN18 AN22 AN31 AN33 AN35 AN37 AR49 AU19 AU26 AU27 AU39 AU40 AV19 AV35 AV36 AV39 AV40 AW19 AW20 AW39 AW40 AY26 AY27 AY36 AY39 AY40 B16 B17 B50 BA26 BA27 BA39 BA40 BC1 BC4 BC23 BC34 BC37 BC39 BC53 BC54 BD3 BD4 BD16 BD17 BD23 BD31 BD34 BD37 BD38 BD39 BE4 BE17 BE23 BE37 BE38 BE39 BF4 BF17 BF23 BF37 BF39 BF51 C16 C17 C51 D1 D16 D17 D54 E1 E5 E12 F1 F6 F8 F16 F17 F24 F25 G6 G10 G12 G14 G17 G21 G24 G50 G53 H50 J12 J17 J21 J26 J31 L49 L50 L51 L52 L53 N50 N51 P49 P51 P53 R49 U49 U51 V49 W9 W49; U7 A28 A32 A40 AA42 AA44 AB6 AB10 AB39 AB40 AB43 AB45 AD38 AD39 AE42 AE44 AF7 AF10 AF11 AJ10 AJ35 AJ36 AJ42 AJ44 AL35 AL36 AN38 AN39 AP15 AR13 AR15 AR31 AR44 AT13 AT31 AT39 AT40 AT45 AU42 AU44 AV15 AV17 AV36 AV43 AV45 AW13 AW15 AW17 AW31 AW36 AW38 AW44 AY1 AY13 AY31 AY38 AY45 B17 B29 BA2 BA45 BB2 BB9 BB13 BB29 BB33 BB37 BC12 BC14 BC30 BC32 BC38 BC40 BC45 BD9 BD13 BD33 BD37 BD41 BD42 BE12 BE14 BE32 BE38 BE40 BE43 BE44 C26 C28 C32 D21 D29 F8 F22 F24 F31 F36 F39 F41 G20 G22 G24 G29 G31 H29 H39 H43 H45 J42 J44 K22 K31 L31 L33 M33 M43 M45 N38 N40 N42 N44 T45 U44 V45 Y38 Y39 Y43 Y45; U11 8 15 21 26 37 43 46; U12 4 7 20 22 26 27 28 29 30 31 32 33 34 35 36 38 39 45 46 47 48; U15 3 15 16 17 18 19 34 37 45 46; UA5 13; UE2 1; UN2 2 3; UU2 1; UV1 A9 A26 A27 A30 AA1 AA2 AA3 AA4 AA5 AA6 AA7 AA8 AB3 AB4 AB8 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC32 AD1 AD2 AD3 AD4 AD5 AD6 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF6 AF7 AF8 AF30 AF32 AG1 AG2 AG3 AG4 AG5 AG6 AG7 AG8 AG9 AH3 AH4 AH6 AH8 AH9 AH31 AJ1 AJ2 AJ3 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ28 AJ31 AJ32 AJ33 AK1 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AP3 AP5 AP6 AP8 AP9 B2 B6 B23 C6 C12 C15 C20 D6 D7 D9 D19 D20 D22 D23 D26 D28 E4 E26 E34 F26 H30 H31 J30 J31 J32 J33 K3 K4 L2 L3 L7 M3 M6 M30 M34 N4 P1 P2 P3 P4 P8 R1 R8 R32 T8 U1 U2 U3 U4 U5 U6 U7 U8 V1 V2 V3 V4 V5 V6 V7 V8 V32 W2 W3 W4 W5 W7 W8 Y1 Y2 Y3 Y4 Y5 Y6 Y7 Y8; UV5 A5 U5; UV6 A5 U5; UV9 A5 U5; UV10 A5 U5

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 4754 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 780 vias
v3: diameter 0.305, hole 0.102, TOP to GND1, 487 vias
v4: diameter 0.457, hole 0.203, GND1 to GND3, 376 vias
v5: diameter 0.305, hole 0.102, GND1 to IN1, 126 vias
v6: diameter 0.305, hole 0.102, IN4 to GND3, 101 vias
v7: diameter 0.305, hole 0.102, GND3 to BOTTOM, 681 vias
v8: diameter 0.406, hole 0.203, TOP to BOTTOM, 163 vias
v9: diameter 0.508, hole 0.254, TOP to BOTTOM, 1192 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.35V_B+: length 12.7
  TOP w0.254: v1(121.52,15.29) 121.27,15.54 PR406.1
  BOTTOM w0.254: 130.36,17.58 128.89,19.06 127.62,19.06 127.05,19.63 125.22,19.63 121.52,15.93 v1(121.52,15.29)
  vias: v2(130.15,16.91) v9(129.35,16.14) v9(129.99,16.14) v9(130.62,16.14) v9(132.3,16.22) v9(132.93,16.24) v9(133.57,16.24)
1.35V_FB: length 4.6
  TOP w0.102: v2(120.24,19.83) 120.28,19.87 PC412.1
  TOP w0.203: PR408.1 122.88,18.24 PU400.6 ; PR408.1 122.19,18.93 PR408.1
  TOP w0.254: PR408.1 122.17,18.94 PR405.1 PC412.1
3.3VS_GFX_EN: length 10.9
  TOP w0.102: v1(214.37,67) 214.75,66.62 QZ1.3 214.75,64.6 CZ7.1 215.12,63.32 215.75,63.32 v2(215.83,63.23) 216.09,62.97 RZ8.2 215.9,62.13 QZ2.3
  BOTTOM w0.102: v1(214.37,67) 212.91,68.46 RZ5.1
3.3VS_GFX_ON#: length 17.1
  TOP w0.254: RZ3.2 212.18,60.83 QZ2.6 213.59,60.83 214.63,59.79 214.63,59.13 214.95,58.81 QZ5.5 ; RZ3.2 212.14,61.49 212.15,61.48 QZ2.5 ; RZ3.2 210.3,61.49 209.74,62.05 v2(209.74,64.92) 209.74,66.24 209.23,66.75 QZ17.5 QZ17.2
3VA_EN: length 178
  TOP w0.102: DE306.2 185.44,18.74 DE303.1 DE305.1 183.51,15.88 v1(182.18,14.55) ; v1(173.5,14.49) 173.9,14.09 173.9,11.44 173.77,11.31 CE322.1 172.85,11.69 DE304.2
  TOP w0.254: v1(41.61,28.57) 42.35,29.32 v2(42.35,33.88) 42.35,33.89 42.64,34.18 PR340.1
  IN3 w0.102: v1(41.61,28.57) 53.43,28.57 56.28,31.42 57.72,31.42 57.87,31.27 57.87,28.85 59.21,27.52 63.67,27.52 65.16,29 74.12,29 75.29,30.17 81.71,30.17 82.27,29.61 82.91,29.61 84.97,27.55 90.15,27.55 94.12,23.58 99.62,23.58 104.01,19.18 108.17,19.18 108.91,18.44 119.98,18.44 120.18,18.24 120.18,17.86 120.5,17.54 120.82,17.54 121.42,18.14 123.9,18.14 124.61,18.85 126.32,18.85 126.9,18.28 128.45,18.28 128.86,18.68 140.21,18.68 143.08,15.81 144.67,15.81 145,16.15 146.06,16.15 146.37,15.84 146.37,15.55 146.87,15.06 148.58,15.06 149.18,15.65 152.93,15.65 155.16,13.43 158.29,13.43 158.98,14.11 161.23,14.11 162.98,12.36 165.28,12.36 165.88,12.96 166.6,12.96 167.2,12.36 171.04,12.36 172.53,13.85 172.85,13.85 v1(173.5,14.49) 173.94,14.49 174.31,14.13 181.76,14.13 v1(182.18,14.55)
5VA_EN: length 125.6
  TOP w0.089: 161.8,14.23 162.03,14.47 162.03,14.91 UE1.B2
  TOP w0.102: v1(160.85,13.03) 160.97,13.15 161.31,13.15 161.59,13.43 161.59,14.03 161.8,14.23
  TOP w0.254: v1(57.28,29.85) 57.28,29.85 57.53,30.11 57.53,32.2 56.45,33.29 v2(54.75,33.29) PR341.2
  IN2 w0.102: v4(81.88,29.17) 82.24,28.8 92.55,28.8 93.75,30.01 98.42,30.01 107.88,20.54 116.37,20.54 116.98,19.93 122.18,19.93 122.96,19.16 123.66,19.16 123.77,19.27 127.84,19.27 128.5,19.93 146.12,19.93 147.34,18.7 148.02,18.7 148.3,18.42 148.3,17.85 148.58,17.57 153.35,17.57 154.06,16.86 154.06,15.72 155.97,13.81 157.19,13.81 157.74,13.26 158.58,13.26 159.19,12.65 160.47,12.65 v1(160.85,13.03)
  IN3 w0.102: v4(81.88,29.17) 81.07,29.97 75.37,29.97 72.88,27.47 63.91,27.47 63.76,27.31 59.12,27.31 57.28,29.16 v1(57.28,29.85)
+0.675VS: length 120.5
  TOP w0.102: v1(132.3,30.11) v8(131.56,30.11)
  IN2 w1.016: 172.97,27.06 173.86,27.95 182.62,27.95 184.61,25.96 244.83,25.96 246.19,27.31
  IN3 w1.016: 171.94,26.04 171.39,26.6 133.15,26.6 132.3,27.44 132.3,28.71
  BOTTOM w0.356: 246.71,27.88 246.7,27.87 JDIMM2.204 ; JDIMM2.203 246.4,33.19 v9(246.71,32.87)
  vias: v1(132.3,29.53) v1(172.53,34.62) v1(172.53,33.98) v1(172.79,26.21) v1(172.78,25.6) v9(245.82,28.77) v9(246.31,28.33) v9(246.71,32.24)
+0.675VSP: length 1.5
  TOP w0.203: PU400.2 125.53,19.67
  TOP w0.508: 126.1,20.18 126.04,20.18 125.53,19.67
  vias: v1(128.08,21.81) v2(127.89,21.19)
+1.2V_5505SWR: length 48.9
  TOP w0.254: v1(15.37,21.47) 16.17,22.28 U12.37 ; CA84.2 21.36,31.27 20.67,30.57 U12.15 ; v1(14.73,29.54) 14.73,29.03 15.03,28.73 U12.25 ; U12.1 23.01,23.23 23.3,22.93
  TOP w0.508: CA63.1 15.37,20.47 v1(15.37,21.47) ; CA84.2 22.2,31.44 v1(22.2,31.1) ; v1(22.16,19.18) 22.54,19.18 CA78.2 22.86,20.63 CA80.1 22.87,21.94 23.3,22.37 23.3,22.93
  IN3 w0.508: v1(14.73,29.54) 15.15,29.12 20.92,29.12 21.96,30.16 21.96,30.86 v1(22.2,31.1) 24.54,31.1 26.88,33.44 v1(28.26,33.44) ; v1(15.37,21.47) 16.19,20.65 18.29,20.65 19.75,19.18 v1(22.16,19.18)
  IN4 w0.508: v1(14.73,29.54) 15.37,28.9 v1(15.37,21.47)
  BOTTOM w0.508: CA64.2 15.37,21.79 v1(15.37,21.47) ; CA83.1 15.11,29.15 v1(14.73,29.54)
  vias: v2(33.4,33.19)
+1.2V_5505SWR_S: length 7.7
  TOP w0.254: U12.13 21.67,30.01 22.02,30.36 22.54,30.36 23.28,31.1
  TOP w0.762: LA3.1 26.9,32.48 26.6,32.77 25.72,32.77 25.26,32.32 v2(25,32.32) 23.91,32.32 23.66,32.06 23.66,31.48 23.28,31.1
+1.5V_RUN_B+: length 1
  TOP w0.102: v2(186.05,125.62) 186.19,125.48 v9(186.19,124.72)
  vias: v9(183.88,124.44) v9(184.52,124.42) v9(185.53,124.75)
+1.5V_VSNS: length 18.9
  IN1 w0.254: v1(191.17,127.33) 191.84,127.33 192.28,126.89 192.28,123.64 191.76,123.12 191.76,114.69 189.12,112.05 v1(189.12,111.57)
  BOTTOM w0.203: PU600.22 190.87,127.03 v1(191.17,127.33)
  vias: v2(186.89,116.78) v9(187.41,117.89) v9(187.41,117.25) v9(188.09,117.86) v9(188.09,117.23) v9(188.72,117.86) v9(188.72,117.23) v9(189.42,117.86) v9(189.36,117.23) v9(189.99,117.23) v9(190.05,117.86)
+1.05VM_VCCASW: length 6.7
  BOTTOM w0.203: U7.AA18 U7.Y18 266.95,28.75 267.23,28.47 v1(267.23,28.39) ; U7.V20 267.61,29.66 v1(267.26,30.02) 266.95,29.71 U7.Y20 ; U7.V18 267.61,28.68 v1(267.89,28.4) 268.27,28.78 U7.U18 ; U7.U22 268.27,30.35 v1(267.94,30.02) 268.27,29.68 U7.U20 ; v1(267.33,30.83) 267.61,31.12 U7.V24 U7.U24
  BOTTOM w0.254: v1(267.94,30.02) 267.61,30.35 U7.V22 ; U7.Y22 266.95,30.42 267.26,30.11 v1(267.26,30.02)
  vias: v1(271.27,44.58) v1(271.78,44.14) v2(272.01,45.04)
+1.05VM_VCCSUS1: length 2
  TOP w0.457: CH94.1 267.9,26.61 v1(267.58,26.29)
  GND1 w0.508: v3(268.09,21.61) 268.48,21.61 v4(268.71,21.38)
  BOTTOM w0.254: U7.Y12 267.29,26.57 v1(267.58,26.29)
+1.05VM_VCCSUS2: length 2.2
  BOTTOM w0.203: U7.Y35 267.48,36.35 v1(267.48,38.05)
  vias: v2(267.03,38.67)
+1.5VS: length 328.5
  TOP w0.102: v8(252.21,29.78) 252.45,29.78 v1(252.83,30.16)
  TOP w0.203: 33.15,101.61 32.84,101.3 U22.19 ; U22.20 32.54,101.7 32.83,101.99 ; U22.12 32.89,98.5 v1(33.02,98.37) ; CV756.1 26.72,101.7 U22.31 ; CV772.1 25.03,96.85 25.53,96.85 26.78,98.1 U22.40
  TOP w0.457: v1(33.02,98.37) 33.15,98.37 33.59,98.81 CV774.1
  TOP w0.508: v1(259.3,45.94) 257.16,45.94 256.35,46.74 ; CV756.1 25.27,103.2 25.53,103.45 v1(26.03,103.45) ; CV772.1 v1(24.97,96.15) ; RH99.1 252.91,30.24 v1(252.83,30.16)
  GND1 w0.508: v3(254.36,23.43) 254.7,23.09 v4(254.7,23.01)
  IN2 w0.457: v1(251.14,37.22) 251.65,36.71 251.65,33.99 251.22,33.56 251.22,31.77 v1(252.83,30.16) 253.8,30.16 254.16,29.79 254.16,23.54 v4(254.7,23.01)
  IN2 w0.508: v4(258.05,23.44) 255.13,23.44 v4(254.7,23.01)
  IN2 w1.016: 255.36,52.74 254.79,52.74 253.94,51.9 239.71,51.9 232.33,44.52 112.2,44.52 109.6,41.92 92.39,41.92 90.55,40.08 ; 69.91,40.32 62.43,40.32 62.03,40.72 56.32,40.72 54.31,42.73 49.22,42.73 46.23,45.73 46.23,47.85 42.58,51.49 38.2,51.49 34.43,55.27 34.43,62.67 33.91,63.19 33.91,84.58 34.32,84.99 34.32,100.39 33.56,101.14
  IN3 w0.508: v1(251.14,37.22) 253.23,39.31 v1(258.25,39.31)
  IN4 w0.457: v6(253.5,28.07) 253.43,28.07 252.21,29.29 252.21,29.88 252.49,30.16 v1(252.83,30.16)
  GND3 w0.254: v4(258.05,23.44) 258.01,23.44 257.96,23.39 v7(257.3,23.39)
  GND3 w0.508: v6(253.5,28.07) v7(253.5,27.5)
  BOTTOM w0.254: U7.AW40 258.37,39.31 v1(258.25,39.31) ; U7.BE30 256.49,33.96 256,34.46 ; v7(257.3,23.39) 257.3,23.21 U7.BD4 ; U7.BE16 255.75,28.12 ; RH28.2 260.51,43.72 260.51,42.56 262.15,40.92 U7.AM45
  BOTTOM w0.508: 252.48,35.88 v1(251.14,37.22) ; 252.48,35.88 254.58,35.88 256,34.46 ; 252.48,35.88 RH113.1 ; v7(253.5,27.5) 255.13,27.5 255.75,28.12 ; v1(259.3,45.94) 259.3,44.94 RH28.2
  vias: v1(32.76,102.56) v1(33.08,101.93) v1(256.22,52.2) v1(256.27,48.85)
+1.5VS_G9141: length 1
  TOP w0.102: 249.82,44.23 249.64,44.05 v2(248.85,44.05)
  vias: v1(255.31,48.83)
+1.05VS_VCCCORE: length 14.7
  TOP w0.102: CH37.1 265.5,32.83 265.82,33.15 265.82,33.2 266.3,33.68 267.03,33.68 v2(267.1,33.75)
  BOTTOM w0.203: U7.AD28 U7.AD26 265.63,31.95 v1(265.33,31.64) 264.97,32 U7.AE26 264.64,31.72 v1(264.64,31.64) 264.31,31.31 U7.AG24 ; U7.AG18 264.31,28.72 v1(264.64,28.39) ; U7.AD20 265.63,29.74 v1(265.35,30.02) ; U7.AE20 264.97,29.74 v1(264.69,30.02)
  BOTTOM w0.254: v1(264.69,30.02) 264.97,30.29 U7.AE22 264.97,30.57 U7.AD24 265.63,31.34 v1(265.33,31.64) ; v1(264.69,30.02) 264.31,30.4 U7.AG22 264.31,30.57 U7.AE24 264.97,31.31 v1(264.64,31.64) ; v1(264.69,30.02) 264.31,29.63 U7.AG20 ; U7.Y26 266.95,31.97 v1(266.62,31.64) ; v1(266.62,31.64) 266.29,31.31 U7.AA24 ; v1(266.62,31.64) 266.29,31.97 U7.AA26 ; U7.AE18 264.97,28.78 264.64,28.45 v1(264.64,28.39) ; v1(265.35,30.02) 265.63,30.29 U7.AD22
+1.5VSDGPU: length 242.5
  TOP w0.508: RV399.1 253.78,98.48 v1(253.39,98.88) 253.39,98.01 252.73,97.35 CV734.1 ; v1(246.37,101.78) 246.26,101.67 CV732.1 ; v1(253.51,82.46) 253.65,82.6 CV710.1 ; v1(227.46,125.04) 227.77,125.36 227.77,126.44 CV659.1 ; v1(224.7,126.47) 224.33,126.84 CV658.1 ; CV677.1 193.88,123.37 194.6,124.09 v1(194.6,124.22) ; CV735.1 254.34,110.69 253.67,110.02 v1(253.46,110.02) ; CV657.1 217.98,114.87 218.31,115.2 v1(218.31,115.26) ; RV371.1 210.68,126.08 RV373.1 210.42,127.2 208.61,127.2 208.27,126.85 v1(208.27,126.47) ; v1(194.56,125.8) 194.56,126.79 CV682.1 ; RZ10.1 218.36,59.51 v1(220.2,61.35) ; v1(242.2,91.23) 242.16,91.27 CV706.1 ; CV653.1 215.38,126.76 v1(215.1,126.48) ; v1(225.51,118.48) 225.23,118.76 CV652.1 ; v1(223.84,95.25) 224.01,95.07 RV347.1 ; CV737.1 241.34,107.34 v1(242.06,107.34) ; v1(225.5,115.27) 225.41,115.18 CV661.1 ; CV660.1 223.91,119.72 v1(223.65,119.45) ; v1(201.05,115.2) 200.84,114.99 CV687.1 200.85,114.41 RV338.2 ; CV730.1 244.48,103.79 v1(244.59,103.69) ; CV713.1 254.1,89.62 v1(253.5,89.62) ; CV707.1 242.72,81.22 242.03,81.22 v1(242.02,81.23) ; CV686.1 205.98,115.16 v1(205.87,115.27) ; CV607.1 223.1,93.6 CV608.1 223.83,93.61 v1(223.84,93.6) ; v1(252.28,113.77) 252.28,114.12 252.63,114.46 RV397.1 ; CV703.1 252.19,85.65 v1(251.78,85.65) ; CV738.1 241.99,102.6 v1(242.11,102.72) ; v1(217.36,101.93) 217.36,102.31 217.75,102.7 RV344.1 218.12,103.5 CV606.1 ; v1(204.27,115.27) 204.27,114.8 CV684.1 ; RV409.2 v1(239.71,101.68) ; CV712.1 253.65,84.09 v1(253.55,84.19) ; v1(197.87,115.27) 197.87,114.92 198.53,114.26 CV688.1 ; v1(227.2,117.04) 227.32,116.92 RV358.1 227.33,116.39 RV360.1 ; CV702.1 253.78,92.05 v1(253.4,92.05) ; RV386.1 255.69,80.23 255.15,80.78 v1(253.45,80.78) ; v1(223.9,115.27) 223.63,115 CV663.1 ; RV342.1 225.3,98.75 v1(225.55,98.5) ; v1(243.79,107.68) 243.76,107.7 CV728.1 ; CV704.1 241.93,82.91 v1(242.02,82.82) ; v1(223.1,126.47) 222.55,127.02 CV655.1 ; CV711.1 252.62,88.88 v1(252.59,88.85) ; RV384.1 v1(250.32,95.18) ; v1(250.75,113.32) 251.12,112.95 CV733.1 ; CV729.1 249.22,105.67 250.23,106.68 v1(250.23,106.89) ; v1(219.1,116.07) 219.1,116.07 RV339.2 ; CV731.1 250.95,99.72 v1(250.99,99.68) ; v1(218.3,126.47) 218.3,126.9 CV654.1 ; CV736.1 250.43,97.37 251.01,97.95 v1(251.01,98.05) ; v1(205.9,123.26) 205.79,123.14 CV680.1 ; CV727.1 241.81,99.47 v1(242.03,99.25) ; CV679.1 206.61,126.52 v1(206.67,126.47) ; v1(216.71,115.26) 216.85,115.12 216.85,114.83 CV662.1 ; CV708.1 242.87,88.73 v1(242.99,88.85) ; CV656.1 224.73,122.68 v1(224.73,123.26) ; CV591.1 223.77,97.68 v1(223.77,96.71) ; v1(244.59,81.64) 244.56,81.62 CV705.1 ; v1(207.47,115.2) 207.78,115.2 CV683.1
  IN4 w0.508: v1(220.2,61.35) 220.2,60.9 220.51,60.59 222.44,60.59 223.61,61.76 223.61,66.8 223.62,66.81 223.62,67.29 224.85,68.52 227.2,68.52 228.92,70.24 228.92,75.64 v1(228.34,76.21)
  GND3 w0.254: v4(227.87,87.97) 227.68,87.79 v7(227.22,87.79) ; v7(229.68,88.09) 229.68,88.5 v4(229.5,88.68) ; v7(228.73,90.97) v4(229.27,90.97)
  GND3 w0.508: v7(217.78,104.42) v4(217.13,104.42) ; v7(214.74,104.4) v4(214.74,103.84)
  BOTTOM w0.203: v1(225.68,91) 226.03,90.65 UV1.E16 ; UV1.E13 226.85,88.15 v7(227.22,87.79)
  BOTTOM w0.254: UV5.H12 221.12,124.47 v1(221.49,124.83) 221.9,125.25 UV5.G13 ; v1(217.36,101.93) 217.55,102.12 UV1.T30 ; UV6.G14 203.87,126.08 v1(204.28,126.5) ; UV10.G13 252.21,103.28 v1(252.59,102.9) 252.97,103.28 UV10.G14 ; v1(219.06,124.91) 219.47,124.51 219.47,124.5 UV5.K12 ; UV10.N10 v1(249.39,108.48) ; v1(250.99,92.05) UV9.T12 ; UV9.L11 250.2,88.83 v1(250.2,88.83) ; UV5.T1 215.07,115.3 v1(215.07,115.25) ; v1(250.99,89.65) UV9.M12 251.4,89.25 251.77,88.88 251.77,88.87 ; UV10.B1 242.56,99.25 v1(242.03,99.25) ; v1(215.1,126.48) 214.7,126.08 UV5.T14 ; v1(250.99,110.08) UV10.T12 ; UV6.L4 200.67,118.07 v1(201.08,117.66) 201.47,117.28 UV6.K3 ; v1(250.99,99.68) UV10.B12 ; UV5.L11 218.7,123.7 v1(219.09,124.09) ; UV5.M3 217.91,117.27 v1(218.31,117.67) ; UV1.AA30 213.32,102.4 v1(212.98,102.05) ; UV5.P11 v1(216.7,124.07) UV5.P12 ; UV6.E10 205.52,122.87 v1(205.9,123.26) 206.27,123.62 UV6.D11 ; v7(229.68,88.09) 229.63,88.14 229.21,88.14 UV1.B13 ; v1(243.79,102.08) UV10.F3 ; v1(223.65,119.45) 223.5,119.31 UV5.E5 ; v1(214.31,124.09) 214.7,124.47 UV5.T12 ; v1(215.07,116.85) 215.07,116.9 UV5.T3 ; UV6.H12 203.07,124.48 v1(203.48,124.9) ; v1(253.45,80.78) 252.99,81.24 UV9.B14 ; v1(229.8,93.25) 229.7,93.15 UV1.B19 ; v1(242.99,88.05) UV9.L1 ; v1(252.59,88.05) 252.59,88.06 252.97,88.45 UV9.L14 v1(252.59,88.85) UV9.M14 ; v1(253.44,106.88) 253.04,107.28 UV10.M14 ; v1(243.79,110.07) 244.19,110.47 UV10.T3 ; UV10.T14 253,110.48 v1(253.46,110.02) ; UV5.N5 v1(217.1,119.41) ; v1(252.59,102.09) 252.98,102.48 UV10.F14 ; UV5.D12 224.3,124.52 v1(223.94,124.88) ; UV9.G13 252.18,85.24 v1(251.78,85.65) 251.39,86.04 UV9.H12 ; v1(246.37,101.78) 245.89,101.78 UV10.E5 ; v1(222.3,125.67) UV5.G14 ; v7(217.78,104.42) 217.55,104.65 UV1.T33 ; UV5.B12 225.9,124.46 v1(225.53,124.08) ; UV6.F14 204.67,126.08 v1(205.08,126.5) ; v1(242.11,102.72) 242.35,102.48 UV10.F1 ; v1(250.99,81.64) UV9.B12 ; v1(242.05,108.88) 242.06,108.87 242.57,108.87 UV10.P1 ; UV6.B3 v1(207.47,117.67) ; v1(226.47,92.76) 226.8,93.09 UV1.E19 ; v1(242.2,92.83) 242.2,92.83 UV9.T1 ; v1(251.79,100.48) UV10.D12 ; UV6.G2 203.88,116.47 204.28,116.87 ; UV10.H3 244.2,104.08 v1(244.59,103.69) 244.99,103.29 UV10.G4 ; UV10.L2 243.31,106.4 242.66,106.4 UV10.L1 242.05,106.48 v1(242.03,106.49) ; UV6.L11 200.67,123.66 200.65,123.66 200.27,123.28 v1(200.27,123.27) ; v1(253.55,84.19) 253.29,84.19 253.09,84.4 253.03,84.4 UV9.F14 UV9.G14 ; v1(207.47,115.2) 207.87,115.6 UV6.B1 ; UV5.R5 215.5,118.87 215.96,119.33 v1(215.96,119.32) ; UV6.L1 200.67,115.58 v1(201.05,115.2) ; v1(205.87,115.27) UV6.D1 ; UV9.F12 251.34,84.44 250.99,84.1 v1(250.99,84.03) ; v1(243.79,88.05) UV9.L2 ; UV10.L4 v1(244.59,106.08) UV10.K3 ; v7(214.74,104.4) 215.04,104.69 215.04,104.79 UV1.W33 ; v1(250.99,102.09) 250.99,102.17 251.3,102.48 UV10.F12 ; UV9.T14 253,92.45 v1(253.4,92.05) ; v1(242.2,91.23) 242.2,91.23 UV9.P1 ; UV5.R10 v1(215.9,122.47) ; 251.77,88.87 UV9.L13 UV9.K12 ; 251.77,88.87 v1(251.77,88.86) ; v1(242.03,110.45) 242.56,110.45 UV10.T1 ; v1(253.39,98.88) UV10.B14 ; v1(250.19,108.48) UV10.P11 ; UV9.R5 245.4,92.03 v1(245.4,92.03) ; UV5.D3 v1(223.9,116.87) ; UV5.K3 219.5,117.32 v1(219.86,117.68) ; UV5.M1 v1(218.31,115.26) ; UV10.D1 242.05,100.88 v1(242.02,100.85) ; UV5.F3 222.7,117.26 v1(223.07,116.88) ; v1(242.06,107.34) 242.12,107.28 UV10.M1 ; v1(244.59,88.05) UV9.L4 ; v1(242.99,84.84) UV9.G1 ; v1(200.27,124.88) 200.65,125.27 UV6.L13 ; v1(244.59,81.64) UV9.B3 ; UV10.D11 250.59,100.89 v1(250.19,101.29) 249.79,101.68 UV10.E10 ; v1(250.19,109.28) UV10.R10 ; UV5.L4 v1(218.29,118.48) ; v1(250.96,90.45) 250.59,90.82 UV9.P11 ; UV9.P14 253.36,91.22 v1(253.36,91.26) ; v1(246.33,109.68) UV10.R5 ; UV1.B16 229.05,90.65 v7(228.73,90.97) ; UV10.L14 v1(252.59,106.88) UV10.L13 ; v1(214.63,101.99) 215.04,102.4 UV1.W30 ; v1(244.59,85.64) UV9.G4 ; v1(245.41,81.64) 245.79,82.02 UV9.C5 ; v1(201.07,116.87) UV6.L2 ; UV6.G4 203.83,118.07 v1(203.47,117.71) ; UV6.H3 203.07,117.26 203.48,116.84 203.48,116.82 v1(203.47,116.82) ; UV6.F3 204.67,117.26 204.28,116.87 ; UV5.F12 222.7,124.45 223.07,124.07 v1(223.14,124.07) ; UV5.M14 v1(218.3,125.67) UV5.L13 ; v1(250.23,84.84) 250.59,85.2 UV9.G11 ; v1(222.3,118.46) 221.92,118.07 UV5.G4 ; UV5.M12 218.29,124.86 v1(218.29,124.86) ; UV6.N10 v1(198.67,122.47) ; v1(250.23,106.89) 250.56,106.56 250.56,106.51 UV10.L11 ; UV5.G2 v1(222.3,116.07) UV5.G1 ; v1(218.3,126.47) UV5.L14 ; UV9.B1 242.57,81.23 v1(242.02,81.23) ; v1(224.73,123.26) 225.1,122.88 UV5.C10 ; v1(224.7,126.47) UV5.D14 ; UV5.P14 v1(216.7,125.67) ; UV5.C5 225.13,118.87 v1(225.51,118.48) ; UV10.H12 251.38,104.08 v1(250.99,103.69) 250.59,103.28 UV10.G11 ; UV9.N10 v1(249.39,90.45) ; UV5.L1 v1(219.1,116.07) UV5.L2 ; UV6.M1 199.87,115.55 v1(200.24,115.18) ; v1(244.55,86.45) 244.19,86.08 UV9.H3 v1(243.79,85.64) UV9.G2 ; UV6.G13 203.87,125.28 v1(204.28,125.7) ; v1(245.39,99.68) UV10.C5 ; 204.28,116.87 v1(204.28,116.87) ; UV6.C10 v1(206.67,123.27) ; UV6.B12 v1(207.47,124.07) ; v1(253.54,100.8) 253.51,100.8 253.44,100.88 UV10.D14 ; v1(246.32,83.64) UV9.E5 ; UV5.P1 v1(216.71,115.26) ; v1(249.36,100.39) 249.67,100.08 UV10.C10 ; UV10.G1 v1(242.99,102.88) UV10.G2 ; UV6.E5 205.5,118.87 v1(205.87,119.24) ; v1(225.5,115.27) UV5.B1 ; UV6.P14 v1(198.67,125.67) ; v1(196.27,115.27) UV6.T1 ; v1(222.26,123.31) 221.9,123.67 UV5.G11 ; UV6.D3 v1(205.87,117.67) ; UV6.P3 v1(197.87,117.67) ; v1(205.11,124.07) 205.04,124.07 204.67,124.45 UV6.F12 ; UV5.H3 221.1,117.29 v1(220.72,116.91) ; UV9.C10 249.72,82.04 v1(249.35,82.42) ; v1(242.02,82.82) 242.05,82.84 UV9.D1 ; UV6.R10 v1(197.87,123.27) ; v1(244.59,99.68) UV10.B3 ; v1(243.79,83.24) UV9.D3 ; v1(201.05,124.87) 201.12,124.87 201.43,124.56 201.43,124.5 UV6.K12 ; UV6.B14 v1(208.27,126.47) ; v1(243.79,92.05) 244.18,92.45 UV9.T3 ; v1(204.23,123.31) 203.87,123.67 UV6.G11 ; v1(197.87,115.27) UV6.P1 ; UV9.P3 244.18,90.85 v1(243.79,90.45) ; UV9.N5 245.79,90.05 v1(245.39,90.45) ; UV5.F1 222.7,115.64 v1(222.27,115.21) ; UV6.D12 206.28,124.47 v1(206.69,124.88) ; v1(212.1,105.2) 212.5,104.8 UV1.AB33 ; v1(204.27,115.27) UV6.F1 ; v1(223.1,126.47) UV5.F14 ; UV9.D12 251,82.46 v1(251,82.45) ; UV5.D11 224.3,123.63 v1(223.93,123.26) 223.54,122.87 UV5.E10 ; v1(246.33,108.08) UV10.N5 ; v1(250.99,108.48) UV10.P12 ; UV6.D14 v1(206.67,126.47) ; UV5.P3 v1(215.9,117.67) ; v1(253.51,82.46) 253.13,82.84 UV9.D14 ; UV6.M14 200.25,125.68 v1(200.27,125.68) 200.65,126.07 UV6.L14 ; v1(243.79,107.68) UV10.M3 ; v1(249.43,84.01) 249.79,83.65 UV9.E10 249.79,83.63 v1(250.19,83.23) 250.57,82.84 UV9.D11 ; UV10.K12 251.43,105.68 v1(251.8,106.05) ; v1(250.99,106.88) UV10.M12 ; UV6.G1 203.87,115.69 v1(204.24,116.06) ; v1(196.27,117.67) UV6.T3 ; v1(242.99,88.85) UV9.M1 ; UV6.R5 197.47,118.92 v1(197.01,119.37) ; UV9.F1 242.27,84.76 v1(242.11,84.76) ; v1(250.19,91.25) UV9.R10 ; UV6.P12 v1(198.67,124.07) ; UV6.T14 v1(197.07,126.47) ; UV6.T12 v1(197.07,124.07) ; v1(252.59,108.48) UV10.P14 ; v1(244.59,109.28) UV10.P3 ; UV6.P11 v1(198.67,123.27) ; UV6.N5 v1(198.67,118.47) ; v1(226.3,125.67) UV5.B14 ; UV6.M12 v1(200.27,124.07) ; v1(243.79,88.85) UV9.M3 ; UV9.P12 250.99,91.24 v1(250.99,91.24) ; v1(244.59,87.25) UV9.K3 ; v1(223.9,115.27) UV5.D1 ; UV6.C5 v1(207.47,119.27) ; v1(243.79,84.04) UV9.F3 ; v1(216.7,122.47) UV5.N10 ; v1(243.79,101.28) UV10.D3 ; UV6.M3 v1(199.47,116.87) ; v1(225.5,116.87) UV5.B3
  BOTTOM w0.305: UV1.H24 224.3,97.29 223.77,96.76 v1(223.77,96.71) 223.98,96.5 UV1.H23 ; UV1.H16 224.24,90.65 v1(223.84,90.25) 224.29,89.8 UV1.H15 ; UV1.H19 224.29,93.15 v1(223.84,93.6) 224.24,94 UV1.H20 ; UV1.H14 224.05,89 v1(223.65,88.6) 224.1,88.15 UV1.H13 ; UV1.H11 224.29,86.5 v1(223.84,86.95) 224.19,87.3 UV1.H12 ; v1(224.72,92.72) 224.31,92.3 UV1.H18 ; UV1.H21 224.29,94.8 v1(223.84,95.25) 224.24,95.65 UV1.H22 ; v1(222.97,85.23) 222.97,85.17 224.24,83.9 UV1.H8 ; UV1.H9 224.29,84.8 v1(223.84,85.25) 224.24,85.65 UV1.H10
  BOTTOM w0.508: RV410.2 239.27,85.16 239.67,84.76 v1(242.11,84.76) ; RV332.2 228.66,75.89 v1(228.34,76.21) ; CV685.1 197.87,114.34 v1(197.87,115.27) ; CV709.1 v1(241.49,77.8)
  vias: v1(197.47,127.27) v1(209.62,99.5) v1(210.48,99.47) v1(212.16,99.47) v1(213.78,99.47) v1(219.63,99.47) v1(220.48,99.42) v1(221.27,99.42) v1(226.47,110.36) v1(226.89,109.94) v8(221.8,85.86) v9(191.43,112.85) v9(191.75,112.22) v9(191.75,111.58) v9(192.06,112.85) v9(192.38,112.22) v9(192.38,111.58) v9(192.7,112.85) v9(193.02,112.22) v9(193.02,111.58) v9(193.65,111.9) v9(193.65,111.26) v9(194.3,111.26) v9(194.3,110.62) v9(194.83,110.22) v9(195.31,109.76) v9(195.74,109.28)
