# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSO10: length 18.5
  TOP w0.089: v3(164.22,21.12) 164.28,21.06 UE1.F13
  TOP w0.102: v3(174.28,23.81) v2(174.71,23.81)
  GND1 w0.089: v5(164.23,20.75) 164.23,21.1 v3(164.22,21.12)
  GND1 w0.102: v5(174.31,23.35) 174.31,23.78 v3(174.28,23.81)
  IN1 w0.089: v5(164.23,20.75) 164.4,20.91 164.4,21.72
  IN1 w0.102: 164.4,21.72 164.86,22.18 164.98,22.18 165.21,22.41 165.21,22.63 165.53,22.94 166.76,22.94 166.96,23.15 174.1,23.15 v5(174.31,23.35) 175.47,23.35 176.3,22.53 v4(176.3,22.29)
  GND3 w0.102: v7(175.83,21.65) 175.83,21.82 v4(176.3,22.29)
  BOTTOM w0.102: v7(175.83,21.65) 175.77,21.59 JKB.26
KSO11: length 22.1
  TOP w0.089: UE1.F12 164.03,20.41 164.03,20.84 163.92,20.95 163.92,21.22
  TOP w0.102: 163.92,21.22 163.92,21.24 164.03,21.36 164.03,21.9 163.76,22.17 v3(163.7,22.17) ; v3(177.28,23.5) v2(176.74,23.5)
  GND1 w0.102: v5(163.96,22.49) 163.7,22.23 v3(163.7,22.17) ; v3(177.28,23.5) 177.25,23.48 v5(177.25,23.07)
  IN1 w0.102: v4(177.56,22.47) 177.56,22.76 v5(177.25,23.07) 177.17,23.15 176.88,23.15 175.74,24.29 171.42,24.29 171.09,23.96 166.62,23.96 166.42,23.76 164.64,23.76 163.96,23.07 v5(163.96,22.49)
  GND3 w0.102: v7(177.29,22.11) 177.56,22.37 v4(177.56,22.47)
  BOTTOM w0.102: v7(177.29,22.11) 177.24,22.11 CE40.1 176.77,21.64 JKB.25
KSO12: length 26.4
  TOP w0.089: UE1.F10 164.22,19.22 164.22,19.64 164.53,19.95 164.53,20.86
  TOP w0.102: v3(175.63,22.18) v2(175.14,22.18) ; 164.53,20.86 164.53,21.38 164.39,21.52 164.4,21.52 v3(164.4,21.52)
  GND1 w0.089: v5(164.7,21.55) 164.67,21.52 v3(164.4,21.52)
  GND1 w0.102: v3(175.63,22.18) 175.64,22.19 v5(175.64,22.6)
  IN1 w0.089: v5(164.7,21.55) 164.7,21.65 164.78,21.72
  IN1 w0.102: 164.78,21.72 165.03,21.98 165.07,21.98 165.42,22.33 165.42,22.55 165.61,22.74 166.84,22.74 167.04,22.94 175.3,22.94 v5(175.64,22.6) 175.82,22.42 175.82,22.2 176.14,21.88 176.68,21.88 177.16,21.39 179.45,21.39 180.23,22.17 183.15,22.17 v4(183.18,22.15)
  GND3 w0.102: v4(183.18,22.15) 182.73,21.7 v7(182.73,21.64)
  BOTTOM w0.102: v7(182.73,21.64) 182.73,21.01 182.77,20.96 JKB.19
KSO13: length 32.3
  TOP w0.089: 163.03,20.95 163.03,20.49 163.11,20.41 163.42,20.41 163.53,20.3 163.53,20 163.62,19.91 163.79,19.91 164.03,19.67 164.03,18.91 UE1.F9
  TOP w0.102: v2(161.94,26.09) 162.14,25.89 162.14,24.54 162.52,24.16 162.52,22.18 162.84,21.86 v3(162.84,21.84) 162.85,21.83 162.85,21.13 163.03,20.95
  GND1 w0.102: v5(162.37,22.3) 162.83,21.84 v3(162.84,21.84)
  IN1 w0.102: v4(179.07,23.5) 178.37,24.2 177,24.2 176.1,25.1 171.37,25.1 171.03,25.45 165.18,25.45 163.02,23.28 163.02,22.61 162.7,22.3 v5(162.37,22.3)
  GND3 w0.102: v4(179.07,23.5) 179.07,23.31 v7(179.32,23.06)
  BOTTOM w0.102: JKB.22 179.77,20.96 179.83,21.02 CE34.1 179.32,22.16 v7(179.32,23.06)
KSO14: length 22.6
  TOP w0.089: v1(163.5,19.55) 163.5,19.44 UE1.E10
  TOP w0.102: v2(172.53,21.09) 172.53,21.29 v3(172.73,21.5)
  GND1 w0.102: v5(172.25,21.5) v3(172.73,21.5)
  IN1 w0.089: v1(163.5,19.55) 163.71,19.55 165.39,21.23 166.32,21.23 166.32,21.24
  IN1 w0.102: 166.32,21.24 167.06,21.24 167.55,21.72 171.54,21.72 171.77,21.5 v5(172.25,21.5) 172.76,21.5 172.99,21.72 174.56,21.72 175.89,20.4 176.44,20.4 177.06,19.77 178.85,19.77 v4(179.26,20.18)
  GND3 w0.102: v7(179.26,20.84) v4(179.26,20.18)
  BOTTOM w0.102: v7(179.26,20.84) 179.26,21.2 CE32.1 178.77,21.61 JKB.23
KSO15: length 25.3
  TOP w0.089: UE1.E9 163.53,18.91 162.96,18.91 v3(162.81,19.06)
  TOP w0.102: v3(179.74,19.49) v2(179.74,19.97)
  GND1 w0.089: v5(162.45,19.3) 162.69,19.06 v3(162.81,19.06)
  GND1 w0.102: v3(179.74,19.49) 179.73,19.5 v5(179.73,19.95)
  IN1 w0.089: v5(162.45,19.3) 162.69,19.06 163.56,19.06 164.04,19.54 164.04,19.65 165.46,21.06 167.89,21.06 168.18,20.77
  IN1 w0.102: v4(180.21,20.43) v5(179.73,19.95) 179.35,19.57 176.98,19.57 176.35,20.19 174.71,20.19 174.32,20.58 168.38,20.58 168.18,20.77
  GND3 w0.102: v4(180.21,20.43) v7(180.21,20.9)
  BOTTOM w0.102: JKB.21 180.77,20.89 180.82,20.94 CE30.1 180.21,21.03 v7(180.21,20.9)
KSO16: length 25.9
  TOP w0.089: v3(164.21,18.3) 163.92,18.3 UE1.E8
  TOP w0.102: v3(182.26,20.56) 181.9,20.56 v2(181.8,20.45)
  GND1 w0.089: v5(164.06,18.68) 164.06,18.45 v3(164.21,18.3)
  GND1 w0.102: v5(182.26,20) v3(182.26,20.56)
  IN1 w0.089: v5(164.06,18.68) 164.29,18.91 164.64,18.91 164.72,18.99 165.82,18.99 166.31,19.49 166.31,19.93 166.62,20.24 167.2,20.24 167.88,19.56 168.78,19.56
  IN1 w0.102: 168.78,19.56 173.8,19.56 174.18,19.18 175.89,19.18 176.53,18.54 180.05,18.54 v4(181.65,20.14) 182.11,20.14 v5(182.26,20)
  GND3 w0.102: v7(181.35,20.9) 181.35,20.44 v4(181.65,20.14)
  BOTTOM w0.102: JKB.20 181.77,21.58 CE28.1 181.35,21.29 v7(181.35,20.9)
LANCLK_REQ#: length 8.3
  TOP w0.102: v3(260.5,17.73) 260.08,17.31 RPH25.8
  GND1 w0.102: v4(260.74,18.54) 260.74,17.97 v3(260.5,17.73)
  GND3 w0.102: v7(260.84,18.95) 260.74,18.85 v4(260.74,18.54)
  BOTTOM w0.089: 263.73,19.66 264.7,20.63 264.7,21.55 U7.AF1
  BOTTOM w0.102: v7(260.84,18.95) 261.7,18.95 261.9,19.15 262.39,19.15 262.86,19.62 v2(263.06,19.62) 263.68,19.62 263.73,19.66
LCD_DBC: length 202.4
  TOP w0.089: v3(261.47,19.82) 261.74,19.82 261.9,19.66
  TOP w0.102: 261.9,19.66 262.06,19.5 v2(262.06,19.26) 262.06,18.61 261.51,18.06 259.47,18.06 259.12,17.71 259.12,16.75 RH178.2 258.27,15.9 258.27,15.06 259.12,14.21 259.12,13.96 260.06,13.02 265.31,13.02 265.65,12.67 RPH9.7
  GND1 w0.089: v3(261.47,19.82) 261.01,19.82 v4(261.01,19.82)
  IN2 w0.089: v4(261.01,19.82) 254.47,19.82
  IN2 w0.102: v1(91.5,34.72) 91.86,35.07 99.77,35.07 107.97,26.87 133.71,26.87 134.36,26.22 152.36,26.22 153.1,25.48 158.93,25.48 160.63,23.77 167.84,23.77 169.29,22.33 175.04,22.33 175.72,21.65 181.57,21.65 183.5,19.72 192.24,19.72 194.14,21.62 196.45,21.62 197.21,22.39 202.83,22.39 203.65,23.21 227.64,23.21 228.13,23.71 229.37,23.71 229.86,23.22 233.4,23.22 234.02,23.85 234.8,23.85 237.73,20.91 250.23,20.91 250.72,20.42 253.44,20.42 254.04,19.82 254.47,19.82
  GND3 w0.089: v4(261.01,19.82) 260.97,19.85 v7(260.97,20.55)
  BOTTOM w0.089: v7(260.97,20.55) 260.97,21.29 U7.AP1
  BOTTOM w0.102: v1(91.5,34.72) 90.91,35.31 90.42,35.31 90.04,34.93 RV482.1
LCD_DCR: length 204
  TOP w0.102: RPH9.8 265.78,12.17 265.14,12.81 259.97,12.81 258.91,13.87 258.91,14.09 258.06,14.94 258.06,17.22 v2(258.93,18.09) 259.11,18.27 261.41,18.27 261.63,18.49 v3(261.63,19.41)
  GND1 w0.089: v4(261.96,19.82) 261.96,19.74 261.88,19.66
  GND1 w0.102: v3(261.63,19.41) 261.88,19.66
  IN2 w0.089: v4(261.96,19.82) 261.59,20.19 254.47,20.19
  IN2 w0.102: v1(90.81,34.72) 91.36,35.28 99.85,35.28 108.05,27.08 133.8,27.08 134.45,26.42 152.44,26.42 153.18,25.68 159.01,25.68 160.71,23.98 167.93,23.98 169.37,22.53 175.13,22.53 175.8,21.85 181.65,21.85 183.24,20.27 187.24,20.27 189.61,22.64 197.34,22.64 198.51,23.81 227.95,23.81 228.05,23.91 229.47,23.91 229.95,23.43 233.31,23.43 233.94,24.05 234.88,24.05 237.82,21.12 250.32,21.12 250.81,20.63 253.71,20.63 254.14,20.19 254.47,20.19
  GND3 w0.089: v7(262.29,20.05) 262.06,19.82 v4(261.96,19.82)
  BOTTOM w0.089: v7(262.29,20.05) 262.47,20.23 262.47,21.75 262.15,22.08 U7.AM3
  BOTTOM w0.102: v1(90.81,34.72) 90.13,34.04 RV481.1
LCD_DELAY: length 83.1
  TOP w0.102: v3(177.3,25.84) 176.46,25.84 175.18,24.56 172.14,24.56 170.2,26.49 159.92,26.49 159.05,25.62 155.99,25.62 153.69,23.33 148.19,23.33 v2(147.79,22.92) 147.42,22.55 147.42,21.86 146.93,21.38 UE36.9
  GND1 w0.102: v3(177.3,25.84) 177.54,25.84 v5(177.66,25.95) ; v3(222.78,20.26) v5(222.36,20.26)
  IN1 w0.102: v5(222.36,20.26) 221.79,20.26 221.26,19.73 217.46,19.73 212.15,25.04 206.05,25.04 205.23,25.87 177.75,25.87 v5(177.66,25.95)
LCD_TEST: length 91.1
  TOP w0.102: v1(73.51,37.62) v2(73.51,36.85) ; RE64.2 146.3,21.91 v3(146.1,21.7) 145.93,21.54 UE36.11
  GND1 w0.102: v3(146.1,21.7) 146.61,21.7 146.72,21.82 v5(146.72,21.73)
  IN1 w0.102: v5(146.72,21.73) 146.72,23.75 143.94,26.53 143.94,31.82 v4(142.86,32.9)
  IN2 w0.102: v1(73.51,37.62) 73.55,37.66 93.64,37.66 95.89,39.91 98.59,39.91 104,34.5 141.29,34.5 142.86,32.93 v4(142.86,32.9)
  BOTTOM w0.102: RV480.1 72.88,36.99 v1(73.51,37.62)
LDO_OUT: length 5.2
  TOP w0.203: U15.40 23.95,37.77 v1(23.84,37.65)
  BOTTOM w0.102: CA18.1 25.37,40.46 v2(25.49,40.57)
  BOTTOM w0.254: CA18.1 24.78,39 CA19.1 24.32,38.11 23.86,37.65 v1(23.84,37.65)
LG_3V: length 13.9
  IN4 w1.016: 41.44,20.18 42.68,21.42 46.11,21.42 47.53,22.84 47.53,28.58
  BOTTOM w0.102: v9(47.49,30.97) v2(47.49,31.91)
  vias: v9(40.88,19.82) v9(41.52,19.82) v9(47.15,30.16)
LG_5V: length 14.1
  IN4 w1.016: 47.69,17.06 48.76,17.06 50.05,18.35 50.05,28.77
  BOTTOM w0.102: v2(49.77,30.69) 49.75,30.67 v9(49.75,29.96)
  vias: v9(45.61,16.57) v9(46.29,16.57) v9(50.58,29.65)
LG_+V1.05V: length 14.4
  IN2 w1.016: 233.08,70.8 234.73,70.8 237.53,73.6 241.34,73.6 243.93,71.01
  BOTTOM w0.102: v9(233.41,69.41) 233.41,69.67 232.69,70.39 v2(232.62,70.39)
  vias: v9(232.78,69.41) v9(243.98,69.79) v9(243.95,69.1)
LGATE1: length 41.1
  TOP w0.102: v2(112.25,79.38) 112.25,79.39 v9(111.67,79.39)
  IN1 w1.016: v9(111.67,79.39) 111.24,79.82 111.24,98.87 112.59,100.22 120.02,100.22 121.5,101.7 121.5,109.13 122.93,110.56
  vias: v1(110.91,79.41) v9(124.12,112.26) v9(124.24,112.92)
LGATE2: length 9.4
  TOP w0.102: v2(120.74,102.6) v9(120,102.6)
  IN1 w1.016: 121.73,111.98 120.1,110.35 120.1,103.95
  vias: v9(119.98,101.97) v9(122.62,112.79) v9(123.05,113.32)
LID_SW_IN#: length 241
  TOP w0.089: v1(166.58,15.58) 166.25,15.91 166.15,15.91 166.03,16.03 166.03,16.29 165.91,16.41 165.65,16.41 165.39,16.66 UE1.H5
  TOP w0.102: C18.1 9.17,86.42 v1(9.94,87.2) ; C18.1 8.65,86.14 8.14,85.63 U5.3 ; C18.1 9.17,85.3 R28.2 ; v1(17.31,113.72) v8(16.57,113.72)
  IN2 w0.102: v1(17.31,113.72) 16.93,113.34 16.93,102.03 11.47,96.57 11.47,88.72 v1(9.94,87.2) 16.74,80.4 16.74,80.12 17.32,79.54 20.41,79.54 21.41,78.53 21.41,75.71 23,74.13 23,71.47 25.56,68.9 25.56,64.33 26.48,63.42 26.48,59.4 28.94,56.93 28.94,52.59 29.64,51.89 29.64,48.02 33.97,43.7 36.7,43.7 37.92,42.48 39.58,42.48 45.21,36.85 49.71,36.85 50.08,36.48 53.23,36.48 54.17,35.54 59.88,35.54 60.28,35.14 62.93,35.14 63.86,34.2 66.91,31.15 66.91,30.74 67.32,30.34 71.35,30.34 72.09,31.07 83.81,31.07 84.54,30.34 92.93,30.34 93.42,30.82 98.76,30.82 108.22,21.36 116.7,21.36 117.32,20.74 122.75,20.74 123.15,21.14 127.31,21.14 127.71,20.74 146.84,20.74 147.31,20.26 147.97,20.26 149.85,18.38 153.69,18.38 154.87,17.2 154.87,16.05 155.47,15.46 157.04,15.46 v4(157.39,15.11)
  IN3 w0.076: v1(166.58,15.58) 166.11,15.11 163.4,15.11 162.9,14.61 162.47,14.61 162.29,14.79 161.99,14.79 161.99,14.8 160.65,14.8
  IN3 w0.102: v4(157.39,15.11) 157.7,14.8 160.65,14.8
  BOTTOM w0.102: v1(17.31,113.72) 17.03,114 DV20.1
LPC_AD0: length 136.6
  TOP w0.089: v3(168.33,16.07) 168.28,16.12 167.82,16.12 UE1.N4
  TOP w0.102: v3(279.59,21.03) 280.02,20.6 v2(280.3,20.6) JSSD.16 ; v1(207.66,18.28) 207.11,18.83 U1.26 204.64,18.83 v1(203.87,18.05)
  GND1 w0.089: 168.78,16.07 v3(168.33,16.07)
  GND1 w0.102: 168.78,16.07 169.23,16.07 v5(169.32,16.16) ; v4(278.89,20.91) 278.99,21.02 279.58,21.02 v3(279.59,21.03)
  IN1 w0.076: v5(169.32,16.16) 169.61,16.16 169.76,16.31 170.47,16.31 170.72,16.57 171.7,16.57 171.72,16.59 174.94,16.59 175.49,16.04 181.19,16.04 181.47,16.32 193.47,16.32 193.91,15.88 201.73,15.88 201.84,15.77 202.32,15.77 203.87,17.31 v1(203.87,18.05)
  IN4 w0.076: v1(207.66,18.28) 207.66,18.09 207.85,17.9 212.05,17.9 212.56,17.39 221.25,17.39 224.29,14.35 236.46,14.35 237.08,14.97 240.58,14.97 241.08,14.47 243.01,14.47 243.37,14.83 252.2,14.83 253.04,15.66 256.19,15.66 257.02,16.5 262.25,16.5 262.73,16.01 263.57,16.01 264.91,17.35 277.93,17.35 278.88,18.29 278.88,20.9 v4(278.89,20.91) 278.67,21.13 278.67,25.73 278.55,25.85 278.55,27.36 278.06,27.85 277.25,27.85 277.17,27.92 276.69,27.92 275.88,28.74 v6(275.88,28.96)
  GND3 w0.089: v7(275.72,29.71) 275.88,29.55 v6(275.88,28.96)
  BOTTOM w0.089: U7.A20 275.68,29.75 v7(275.72,29.71)
LPC_AD1: length 141.1
  TOP w0.089: v3(166.74,16.96) 166.58,16.96 UE1.K5
  TOP w0.102: v1(202.77,16.88) 202.77,16.88 U1.23 v1(206.88,16.88) ; v2(279.18,21.72) 279.21,21.7 v3(279.21,20.07) 279.48,19.8 JSSD.14
  GND1 w0.089: v3(166.74,16.96) 166.98,16.96 167.09,16.85 v5(167.26,16.85)
  GND1 w0.102: v4(279.38,20.51) 279.21,20.33 v3(279.21,20.07)
  IN1 w0.076: v5(167.26,16.85) 167.74,17.33 168.03,17.33 168.11,17.25 168.64,17.25 168.98,17.6 170.37,17.6 170.64,17.33 171.38,17.33 171.41,17.36 175.25,17.36 175.81,16.8 180.87,16.8 181.68,17.61 193.26,17.61 194.22,16.64 202.53,16.64 v1(202.77,16.88)
  IN4 w0.076: v1(206.88,16.88) 207.03,17.03 211.51,17.03 211.99,16.55 221.12,16.55 224.69,12.99 226.57,12.99 227.19,13.61 228.64,13.61 229.27,12.99 233.85,12.99 234.42,13.56 236.78,13.56 237.01,13.79 243.29,13.79 243.65,14.14 252.49,14.14 253.14,14.79 258.73,14.79 258.94,14.99 263.52,14.99 264.5,15.97 266.68,15.97 267.07,16.37 270.76,16.37 271.23,16.84 277.96,16.84 279.26,18.14 279.26,20.38 v4(279.38,20.51) 279.38,20.98 279.06,21.31 279.06,25.88 278.88,26.06 278.88,27.68 278.23,28.33 277.28,28.33 277.07,28.13 276.79,28.13 276.21,28.71 276.21,29.06 276.01,29.26 275.64,29.26 275.54,29.15 275.18,29.15 v6(274.92,29.42)
  GND3 w0.089: v7(274.67,29.75) 274.92,29.5 v6(274.92,29.42)
  BOTTOM w0.089: v7(274.67,29.75) 274.66,29.75 U7.C20
LPC_AD2: length 140.9
  TOP w0.089: v3(168.34,15.12) 168.34,15.13 168.05,15.41 167.07,15.41 166.97,15.51 166.97,15.84 UE1.M4
  TOP w0.102: v3(279.65,19.38) 280.03,19 v2(280.3,19) JSSD.12 ; v1(204.27,15.73) 205.06,14.93 U1.20 v1(207.01,14.93)
  GND1 w0.076: v3(168.34,15.12) 168.34,15.11 168.34,15.14 168.68,15.49 168.71,15.49 168.78,15.55
  GND1 w0.102: v5(168.92,15.69) 168.78,15.55 ; v4(279.7,19.93) 279.65,19.88 v3(279.65,19.38)
  IN1 w0.076: v5(168.92,15.69) 169.01,15.78 169.77,15.78 169.92,15.93 171.79,15.93 171.94,15.78 174.9,15.78 175.03,15.66 181.35,15.66 181.63,15.94 193.31,15.94 193.75,15.5 198.54,15.5 199.1,14.94 203.47,14.94 v1(204.27,15.73)
  IN4 w0.076: v1(207.01,14.93) 208.7,16.62 211.38,16.62 211.83,16.17 217.41,16.17 221.59,12 233.4,12 234.43,13.03 236.32,13.03 236.66,12.68 239.61,12.68 240.38,13.46 243.43,13.46 243.79,13.81 252.63,13.81 253.27,14.46 258.56,14.46 258.82,14.2 259.29,14.2 259.75,14.66 263.66,14.66 264.64,15.64 266.82,15.64 267.21,16.04 270.89,16.04 271.36,16.5 278.17,16.5 279.7,18.04 v4(279.7,19.93) 279.83,20.06 279.83,21.07 279.44,21.46 279.44,26.04 279.21,26.27 279.21,27.82 277.2,29.83 276.75,29.83 276.38,29.46 v6(275.4,29.46)
  GND3 w0.089: v7(275.48,29.11) 275.48,29.38 v6(275.4,29.46)
  BOTTOM w0.089: v7(275.48,29.11) 275.48,29.11 275.31,28.94 U7.A18
LPC_AD3: length 143.6
  TOP w0.089: 168.78,15.39 168.75,15.42 168.28,15.42 168.06,15.64 167.8,15.64 UE1.N3
  TOP w0.102: v1(207.07,12.98) U1.17 204.45,12.98 204.27,13.16 v1(204.27,15.15) ; 168.78,15.39 v3(169.07,15.1) ; JSSD.10 v2(281.57,18.2) 280.67,18.2 v3(280.51,18.04)
  GND1 w0.102: v3(169.07,15.1) 169.49,15.51 v5(170.05,15.51) ; v3(280.51,18.04) 280.71,18.24 v4(280.71,18.38)
  IN1 w0.076: v5(170.05,15.51) 171.67,15.51 171.79,15.4 174.74,15.4 174.87,15.27 181.51,15.27 181.79,15.56 193.15,15.56 193.7,15.01 198.49,15.01 198.94,14.56 203.67,14.56 v1(204.27,15.15)
  IN4 w0.076: v1(207.07,12.98) 208.37,12.98 209.76,14.36 213.33,14.36 214.37,15.41 217.1,15.41 221.29,11.21 233.69,11.21 234.3,11.82 236.44,11.82 237.05,11.21 243.76,11.21 244.33,11.79 252.63,11.79 253.36,12.52 254.33,12.52 254.56,12.75 262.75,12.75 264.93,14.93 267.18,14.93 267.4,15.15 271.84,15.15 272.49,15.79 278.63,15.79 280.71,17.87 v4(280.71,18.38) 280.71,21.27 280.2,21.78 280.2,26.36 279.97,26.59 279.97,28.15 277.51,30.61 277.07,30.61 277,30.54 276.74,30.54 v6(276.27,30.07)
  GND3 w0.089: v7(276.15,29.71) 276.15,29.95 v6(276.27,30.07)
  BOTTOM w0.089: v7(276.15,29.71) 275.85,29.41 275.16,29.41 274.81,29.06 274.34,29.06 U7.C18
LPC_FRAME#: length 143.1
  TOP w0.089: UE1.K4 166.64,16.16 v3(166.72,16.07)
  TOP w0.102: v1(209.71,16.07) 209.31,16.48 209.31,16.78 209.12,16.97 207.55,16.97 206.81,16.23 U1.22 v1(202.12,16.23) ; v3(279.91,17.24) 280.06,17.4 v2(280.43,17.4) JSSD.8
  GND1 w0.089: v5(167.04,16) 166.8,16 v3(166.72,16.07)
  GND1 w0.102: v4(280,17.71) 279.91,17.62 v3(279.91,17.24)
  IN1 w0.076: v1(202.12,16.23) 202.09,16.26 194.06,16.26 193.1,17.23 181.84,17.23 181.03,16.42 175.65,16.42 175.1,16.97 171.57,16.97 171.54,16.95 170.57,16.95 170.31,16.7 169.61,16.7 169.45,16.54 169.16,16.54 168.25,15.63 167.4,15.63 v5(167.04,16)
  IN4 w0.076: v1(209.71,16.07) 211.19,16.07 211.48,15.79 217.26,15.79 221.45,11.6 233.54,11.6 234.59,12.65 236.16,12.65 237.21,11.6 243.6,11.6 244.18,12.17 252.48,12.17 253.2,12.9 254.17,12.9 254.4,13.13 262.59,13.13 264.78,15.31 267.03,15.31 267.42,15.7 271.03,15.7 271.5,16.17 278.38,16.17 279.91,17.71 v4(280,17.71) 280.21,17.93 280.21,21.23 279.82,21.62 279.82,26.2 279.59,26.43 279.59,27.98 277.34,30.23 276.9,30.23 276.42,29.76 275.57,29.76 275.12,30.2 v6(274.8,30.2)
  GND3 w0.089: v7(275.21,30.16) 274.84,30.16 v6(274.8,30.2)
  BOTTOM w0.089: U7.B21 275.2,30.18 v7(275.21,30.16)
LX_3V: length 14.3
  IN4 w1.016: 45.73,32.32 45.02,31.61 45.02,31.53 43.43,29.94 43.43,29.15 42.12,27.85 42.12,25.79 40.98,24.65 39.86,24.65 38.42,23.2 36.89,23.2
  vias: v2(36.51,21.45) v9(36.41,23.08) v9(36.41,22.44) v9(36.56,20.23) v9(36.56,19.59) v9(36.6,18.95) v9(36.6,18.31) v9(36.6,17.68) v9(36.6,17.04) v9(37.25,18.96) v9(37.25,18.33) v9(37.25,17.69) v9(37.25,17.06) v9(45.4,32.68) v9(46.26,32.57)
LX_5V: length 3.9
  BOTTOM w1.016: 51.22,27.47 51.22,28.56 51.6,28.94 51.6,31.25 51.6,31.25
  vias: v2(53.02,21.6) v9(47.62,20.29) v9(47.62,19.66) v9(47.62,19.02) v9(47.62,18.39) v9(48.25,20.29) v9(48.25,19.66) v9(48.25,19.02) v9(48.25,18.39) v9(51.52,32.52) v9(52.21,31.88) v9(52.24,20.78) v9(52.24,20.14) v9(52.24,19.51) v9(52.24,18.87) v9(52.24,18.24) v9(52.24,17.6) v9(52.87,20.78) v9(52.87,20.14) v9(52.87,19.51) v9(52.87,18.87) v9(52.87,18.24) v9(52.87,17.6)
M_CLK_DDR0: length 61.7
  IN4 w0.076: v1(165.42,71.21) 165.42,71.07 165.32,70.97 165.11,70.97 165.01,71.07 165.01,75.01 164.82,75.2 164.34,75.2 164.15,75.01 164.15,70.49 164.65,69.99 164.65,65.47 142.65,43.46 142.65,38.76 142.25,38.36 142.16,38.36 v1(141.97,38.55)
  BOTTOM w0.089: v1(165.42,71.21) 165.42,71.17 165.08,70.83 164.62,70.83 164.06,71.4 164.06,73.97 164.14,74.06 U6.BF25
  BOTTOM w0.102: v1(141.97,38.55) 141.97,38.34 141.77,38.14 141.55,38.14 141.3,37.89 141.3,36.65 141.67,36.28 141.67,35.62 141.57,35.52 141.39,35.52 141.3,35.43 JDIMM1.101
M_CLK_DDR1: length 66.4
  IN4 w0.076: v1(165.42,73.01) 165.6,72.83 165.8,72.83 165.97,72.65 165.97,69.53 165.44,68.99 165.44,65.14 143.43,43.14 143.43,34.54 143.18,34.29 142.3,34.29 142.19,34.19 142.19,33.56 142.28,33.46 143.88,33.46 144.07,33.27 144.07,32.49 143.88,32.3 142.31,32.3 142.19,32.18 142.19,30.13 142.4,29.92 142.56,29.92 v1(142.8,30.15)
  BOTTOM w0.089: U6.BC25 164.7,75.66 164.7,73.19 164.93,72.96 165.37,72.96 v1(165.42,73.01)
  BOTTOM w0.102: v1(142.8,30.15) 142.5,29.86 142.37,29.86 142.03,29.52 142.03,28.4 141.6,27.97 JDIMM1.102
M_CLK_DDR2: length 101.8
  IN1 w0.076: v1(216.11,38.42) 215.9,38.21 215.62,38.21 214.48,39.35 205.22,39.35 190.16,54.4 173.84,54.4 166.51,61.73 166.51,63.18 166.33,63.36 164.79,63.36 164.72,63.43 164.72,63.71 164.79,63.79 166.34,63.79 166.51,63.95 166.51,64.31 166.34,64.47 164.76,64.47 164.68,64.55 164.68,64.78 164.76,64.85 166.34,64.85 166.51,65.02 166.51,65.38 166.34,65.54 164.74,65.54 164.67,65.62 164.67,65.85 164.74,65.92 166.34,65.92 166.51,66.09 166.51,66.44 166.34,66.61 164.88,66.61 164.81,66.68 164.81,66.91 164.88,66.99 166.34,66.99 166.51,67.15 166.51,67.51 166.34,67.67 164.88,67.67 164.81,67.75 164.81,67.98 164.88,68.05 166.34,68.05 166.51,68.22 166.51,68.58 166.34,68.74 164.88,68.74 164.81,68.82 164.81,74.77 163.14,76.44 163.14,79.6 v1(162.76,79.98)
  BOTTOM w0.089: U6.AV27 162.44,79.66 v1(162.76,79.98)
  BOTTOM w0.102: v1(216.11,38.42) 215.94,38.25 215.65,38.25 215.28,37.87 215.28,36.71 215.8,36.19 JDIMM2.101
M_CLK_DDR3: length 101.6
  IN1 w0.076: v1(217.18,29.44) 217.52,29.44 217.77,29.69 217.77,33.22 217.69,33.29 217.03,33.29 216.86,33.46 216.86,33.81 217.03,33.98 217.69,33.98 217.77,34.06 217.77,34.28 217.69,34.36 216.85,34.36 216.69,34.53 216.69,34.88 216.85,35.05 217.69,35.05 217.77,35.12 217.77,35.35 217.69,35.43 216.85,35.43 216.69,35.59 216.69,35.95 216.85,36.11 217.69,36.11 217.77,36.19 217.77,36.42 217.69,36.49 216.85,36.49 216.69,36.66 216.69,37.02 216.85,37.18 217.69,37.18 217.77,37.26 217.77,38.23 216.17,39.83 205.42,39.83 190.36,54.88 174.04,54.88 166.99,61.93 166.99,75.64 165.38,77.25 164.44,77.25 163.33,78.35 163.33,79.61 v1(163.7,79.98)
  BOTTOM w0.089: U6.AV26 163.38,79.66 v1(163.7,79.98)
  BOTTOM w0.102: JDIMM2.102 216.1,28.04 216.52,28.46 216.52,28.79 217.18,29.44 v1(217.18,29.44)
M_CLK_DDR#0: length 61.8
  IN4 w0.076: v1(165.42,70.61) 165.21,70.82 165.05,70.82 164.86,71.01 164.86,74.95 164.76,75.05 164.4,75.05 164.3,74.95 164.3,70.56 164.81,70.05 164.81,65.41 142.8,43.4 142.8,38.7 142.23,38.12 142.23,38.04 v1(141.97,37.78)
  BOTTOM w0.089: v1(165.42,70.61) 164.53,70.61 163.84,71.31 163.84,74.4 U6.BE25
  BOTTOM w0.102: JDIMM1.103 141.9,36.37 141.53,36.74 141.53,37.79 141.64,37.9 141.85,37.9 v1(141.97,37.78)
M_CLK_DDR#1: length 66.5
  IN4 w0.076: v1(165.42,72.42) 165.42,72.51 165.59,72.68 165.73,72.68 165.82,72.59 165.82,69.59 165.29,69.06 165.29,65.21 143.28,43.2 143.28,34.6 143.12,34.44 142.23,34.44 142.04,34.25 142.04,33.5 142.22,33.31 143.81,33.31 143.92,33.21 143.92,32.56 143.81,32.46 142.25,32.46 142.04,32.24 142.04,30.07 142.34,29.76 142.71,29.76 142.8,29.67 v1(142.8,29.39)
  BOTTOM w0.089: v1(165.42,72.42) 165.11,72.74 164.84,72.74 164.51,73.07 164.51,75.38 164.43,75.46 U6.BD25
  BOTTOM w0.102: v1(142.8,29.39) 142.8,29.56 142.73,29.62 142.46,29.62 142.26,29.42 142.26,28.31 141.83,27.88 141.83,27.45 141.93,27.36 142.09,27.36 142.2,27.25 JDIMM1.104
M_CLK_DDR#2: length 101.8
  IN1 w0.076: v1(162.76,79.28) 162.86,79.28 162.99,79.15 162.99,76.37 164.65,74.71 164.65,68.75 164.82,68.59 166.28,68.59 166.36,68.51 166.36,68.28 166.28,68.21 164.82,68.21 164.65,68.04 164.65,67.69 164.82,67.52 166.28,67.52 166.36,67.45 166.36,67.22 166.28,67.14 164.82,67.14 164.65,66.98 164.65,66.62 164.82,66.45 166.28,66.45 166.36,66.38 166.36,66.15 166.28,66.07 164.68,66.07 164.51,65.91 164.51,65.55 164.68,65.39 166.28,65.39 166.36,65.31 166.36,65.08 166.28,65.01 164.69,65.01 164.53,64.84 164.53,64.49 164.69,64.32 166.28,64.32 166.36,64.24 166.36,64.02 166.28,63.94 164.73,63.94 164.57,63.77 164.57,63.37 164.73,63.2 166.27,63.2 166.36,63.11 166.36,61.67 173.78,54.25 190.1,54.25 205.15,39.19 214.42,39.19 215.56,38.05 215.97,38.05 216.11,37.91 v1(216.11,37.66)
  BOTTOM w0.089: v1(162.76,79.28) 162.41,79.28 162.3,79.18 U6.AW27
  BOTTOM w0.102: v1(216.11,37.66) 216.11,37.92 216.01,38.02 215.75,38.02 215.51,37.78 215.51,36.81 216.03,36.28 216.03,35.72 216.13,35.62 216.22,35.62 216.4,35.43 JDIMM2.103
M_CLK_DDR#3: length 101.6
  IN1 w0.076: v1(163.7,79.28) 163.49,79.06 163.49,78.41 164.5,77.4 165.44,77.4 167.14,75.7 167.14,62 174.1,55.04 190.43,55.04 205.48,39.98 216.23,39.98 217.92,38.3 217.92,37.19 217.75,37.03 216.91,37.03 216.84,36.95 216.84,36.72 216.91,36.65 217.75,36.65 217.92,36.48 217.92,36.13 217.75,35.96 216.91,35.96 216.84,35.89 216.84,35.66 216.91,35.58 217.75,35.58 217.92,35.41 217.92,35.06 217.75,34.89 216.91,34.89 216.84,34.82 216.84,34.59 216.91,34.51 217.75,34.51 217.92,34.35 217.92,33.99 217.75,33.83 217.09,33.83 217.02,33.75 217.02,33.52 217.09,33.45 217.75,33.45 217.92,33.28 217.92,29.63 217.34,29.05 217.2,29.05 217.12,28.97 217.12,28.74 v1(217.18,28.68)
  BOTTOM w0.089: U6.AW26 163.24,79.2 163.4,79.36 163.63,79.36 v1(163.7,79.28)
  BOTTOM w0.102: JDIMM2.104 216.7,27.2 216.6,27.3 216.46,27.3 216.33,27.43 216.33,27.95 216.75,28.37 216.75,28.69 216.91,28.85 217.01,28.85 v1(217.18,28.68)
M_ODT0: length 64
  IN4 w0.117: v1(146.99,28.2) 146.99,28.5 147.11,28.63 147.68,28.63 147.92,28.86 147.92,34.27 149.11,35.47 149.11,41.93 170.23,63.05 170.23,72.23 169.84,72.62 169.84,73.77 170.88,74.81 170.88,74.99 170.23,75.65 170.05,75.65 v1(169.49,75.09)
  BOTTOM w0.089: U6.BC16 170.2,75.84 170.2,75.26 170.04,75.09 v1(169.49,75.09)
  BOTTOM w0.16: JDIMM1.116 145.8,27.61 146.39,28.2 v1(146.99,28.2)
M_ODT1: length 61.6
  IN4 w0.117: v1(148.88,28.2) 148.03,27.35 147.85,27.35 147.52,27.69 147.52,27.87 148.35,28.7 148.35,34.11 149.54,35.29 149.54,41.76 170.65,62.88 170.65,72.88 170.52,73.01 v1(170.29,73.01)
  BOTTOM w0.089: v1(170.29,73.01) 169.88,73.41 U6.BF16
  BOTTOM w0.16: v1(148.88,28.2) 148.08,28.2 147,27.12 JDIMM1.120
M_ODT2: length 102.1
  IN3 w0.089: 174.03,71.38 174.03,75.85 173.52,76.36 173.52,76.64 172.92,77.24 169.2,77.24 168.74,77.7 168.27,77.7 167.46,78.5 v1(167.46,78.58)
  IN3 w0.196: v1(222.01,29.82) 224.22,32.04 224.22,32.84 225.16,33.77 225.16,39.37 201.07,63.45 184.33,63.45 184.14,63.64 184.14,64.38 183.94,64.58 179.79,64.58 179.5,64.87 179.5,65.14 179.76,65.4 179.76,65.68 179.48,65.95 179.2,65.95 178.95,65.7 178.67,65.7 178.39,65.97 178.39,66.25 178.95,66.81 178.95,67.09 178.68,67.36 178.4,67.36 177.84,66.8 177.56,66.8 177.29,67.08 177.29,67.36 177.85,67.92 177.85,68.19 177.57,68.47 177.29,68.47 176.73,67.91 176.46,67.91 176.18,68.19 176.18,68.46 176.74,69.02 176.74,69.3 176.46,69.58 176.19,69.58 175.63,69.02 175.35,69.02 175.07,69.29 175.07,69.57 175.52,70.02 175.52,70.29 175.25,70.57 174.97,70.57 174.52,70.12 174.24,70.12 174.03,70.33 174.03,71.38
  BOTTOM w0.089: U6.AY20 167.14,78.26 v1(167.46,78.58)
  BOTTOM w0.16: JDIMM2.116 220.3,28.12 v1(222.01,29.82)
M_ODT3: length 104.6
  IN3 w0.089: 175.36,71.38 174.69,72.06 174.69,75.57 173.95,76.31 173.95,76.61 173.14,77.43 169.28,77.43 168.63,78.07 v1(168.42,78.07)
  IN3 w0.196: v1(222.01,28.3) 225.81,32.1 225.81,39.64 201.34,64.1 196.14,64.1 195.94,64.3 195.94,65.04 195.74,65.23 195.35,65.23 195.16,65.04 195.16,64.3 194.96,64.1 194.57,64.1 194.38,64.3 194.38,65.04 194.18,65.23 193.79,65.23 193.59,65.04 193.59,64.3 193.4,64.1 193.01,64.1 192.81,64.3 192.81,65.04 192.61,65.23 192.22,65.23 192.03,65.04 192.03,64.3 191.83,64.1 191.44,64.1 191.25,64.3 191.25,65.04 191.05,65.23 190.66,65.23 190.46,65.04 190.46,64.3 190.27,64.1 189.88,64.1 189.68,64.3 189.68,65.04 189.49,65.23 189.09,65.23 188.9,65.04 188.9,64.3 188.7,64.1 188.31,64.1 188.12,64.3 188.12,65.04 187.92,65.23 187.53,65.23 187.33,65.04 187.33,64.3 187.14,64.1 186.75,64.1 186.55,64.3 186.55,65.04 186.36,65.23 185.97,65.23 185.77,65.04 185.77,64.3 185.57,64.1 185.18,64.1 184.99,64.3 184.99,65.04 184.79,65.23 181.73,65.23 175.93,71.03 175.71,71.03 175.36,71.38
  BOTTOM w0.089: U6.BA19 167.94,77.6 v1(168.42,78.07)
  BOTTOM w0.16: JDIMM2.120 221.5,27.79 v1(222.01,28.3)
MDP_A0N_CPU: length 210.4
  IN4 w0.089: v1(29.92,69.97) 29.95,69.97 30.17,70.2 30.17,70.26 30.03,70.4 29.65,70.4 29.4,70.15 29.4,69.27 31.51,67.17 31.51,66.07 32.35,65.24 32.35,57.11 33.23,56.22 33.23,54.8 36.85,51.18 42.38,51.18 48.49,45.07 49.27,45.07 57.73,36.61 69.1,36.61 69.43,36.28 93.99,36.28 95.06,35.22 99.46,35.22 116.7,52.46 118.53,52.46 131.46,65.39 131.46,74.54 133.58,76.65 133.58,82.88 135.63,84.94 135.63,92.71 137.27,94.34 137.27,95.05 140.02,97.8 140.02,99.37 140.52,99.88 140.52,100.48 141.45,101.4 142.05,101.4 142.43,101.79 142.43,102.35 143.21,103.13 143.95,103.13 145.83,105.01 146.96,105.01 147.62,105.67 164.67,105.67 165.25,105.1 165.25,104.68 166.66,103.27 166.85,103.27 166.94,103.37 166.94,103.58 v1(166.91,103.6)
  BOTTOM w0.089: v1(166.91,103.6) 166.56,103.24 U6.C21
  BOTTOM w0.102: CV780.2 30.36,72.65 30.55,72.65 30.59,72.6 30.59,71.3 30.25,70.96 30.25,70.3 v1(29.92,69.97)
MDP_A0N_R: length 1.7
  BOTTOM w0.102: C47.2 30.9,82.96 30.9,82.86 30.68,82.64 30.68,82.32 30.55,82.2 U11.22
MDP_A0P_CPU: length 210.5
  IN4 w0.089: v1(166.91,102.9) 166.79,103.03 166.56,103.03 165.01,104.58 165.01,105 164.57,105.43 147.72,105.43 147.06,104.77 145.93,104.77 144.05,102.89 143.31,102.89 142.67,102.25 142.67,101.69 142.15,101.16 141.55,101.16 140.77,100.38 140.77,99.78 140.26,99.27 140.26,97.7 137.51,94.95 137.51,94.24 135.88,92.61 135.88,84.84 133.82,82.78 133.82,76.55 131.7,74.44 131.7,65.29 118.63,52.22 116.8,52.22 99.56,34.98 94.96,34.98 93.89,36.04 69.33,36.04 69,36.37 57.63,36.37 49.17,44.83 48.39,44.83 42.28,50.93 36.75,50.93 32.99,54.7 32.99,56.12 32.1,57.01 32.1,65.13 31.27,65.97 31.27,67.07 29.16,69.17 29.16,70.25 29.55,70.65 30.13,70.65 30.41,70.36 30.41,70.06 v1(30.5,69.97)
  BOTTOM w0.089: U6.D21 166.55,102.54 v1(166.91,102.9)
  BOTTOM w0.102: v1(30.5,69.97) 30.5,70.86 30.84,71.2 30.84,72.24 CV779.2
MDP_A0P_R: length 1.8
  BOTTOM w0.102: C93.2 31.15,82.91 31.15,82.75 30.93,82.53 30.93,82.32 31.05,82.2 U11.23
MDP_A1N_CPU: length 210.5
  IN4 w0.089: v1(29.69,71.27) 29.87,71.44 30.18,71.44 32.13,69.49 32.13,68.88 32.04,68.8 31.75,68.8 31.48,68.53 31.48,68.14 31.75,67.87 32.04,67.87 32.13,67.78 32.13,66.46 33.83,64.75 33.83,55.05 37.1,51.79 42.69,51.79 48.81,45.66 49.54,45.66 58,37.21 69.36,37.21 69.68,36.88 94.24,36.88 95.3,35.82 98.73,35.82 116.9,53.98 118.93,53.98 130.66,65.72 130.66,91.86 131.1,92.3 134.35,92.3 136.63,94.57 136.63,95.28 139.37,98.03 139.37,99.58 139.85,100.06 139.85,101.2 141.87,103.22 142.22,103.22 144.43,105.43 147,105.43 147.79,106.22 165.56,106.22 166.43,105.34 166.43,104.54 v1(166.18,104.29)
  BOTTOM w0.089: v1(166.18,104.29) 166.53,104.64 U6.A21
  BOTTOM w0.102: CV782.2 28.7,72.13 28.7,71.7 28.97,71.43 29.53,71.43 v1(29.69,71.27)
MDP_A1N_R: length 1.6
  BOTTOM w0.102: U11.19 29.05,82.45 29.15,82.54 29.15,82.93 C53.2
MDP_A1P_CPU: length 210.5
  IN4 w0.089: v1(29.69,71.85) 29.87,71.68 30.28,71.68 32.37,69.59 32.37,68.78 32.14,68.55 31.85,68.55 31.72,68.43 31.72,68.24 31.85,68.11 32.14,68.11 32.37,67.88 32.37,66.56 34.07,64.85 34.07,55.15 37.2,52.03 42.79,52.03 48.91,45.91 49.64,45.91 58.1,37.45 69.46,37.45 69.78,37.12 94.34,37.12 95.4,36.06 98.63,36.06 116.8,54.22 118.83,54.22 130.42,65.82 130.42,91.96 131,92.54 134.25,92.54 136.38,94.67 136.38,95.38 139.13,98.13 139.13,99.68 139.61,100.16 139.61,101.3 141.77,103.46 142.12,103.46 144.33,105.67 146.9,105.67 147.69,106.46 165.66,106.46 166.67,105.44 166.67,104.57 v1(166.94,104.3)
  BOTTOM w0.089: v1(166.94,104.3) 166.58,103.94 U6.B21
  BOTTOM w0.102: CV781.2 28.95,72.13 28.95,71.81 29.07,71.69 29.53,71.69 v1(29.69,71.85)
MDP_A1P_R: length 1.7
  BOTTOM w0.102: C42.2 29.4,82.93 29.4,82.54 29.55,82.39 U11.20
MDP_A2N_CPU: length 218.5
  IN4 w0.089: v1(167.73,103.59) 167.73,103.41 168.16,102.98 168.16,101.7 167.38,100.92 164.62,100.92 163.4,102.14 163.4,102.93 162.23,104.1 146.07,104.1 144.68,102.7 144.68,101.33 142.12,98.78 141.64,98.78 141.1,98.23 141.1,96.45 137.21,92.57 137.21,84.98 134.65,82.43 134.65,76.09 132.56,74 132.56,67.93 132.75,67.75 132.75,64.62 119.19,51.06 117.13,51.06 100.21,34.14 94.42,34.14 93.38,35.19 82.61,35.19 81.61,34.18 76.24,34.18 75.77,34.65 68.92,34.65 68.03,35.53 66.42,35.53 65.8,34.91 63.75,34.91 63.13,35.53 57.28,35.53 48.82,43.99 46.67,43.99 44.17,46.49 44.17,47.1 41.53,49.74 36.75,49.74 32.15,54.34 32.15,55.77 31.27,56.66 31.27,63.31 31.18,63.4 30.73,63.4 30.5,63.63 30.5,64.1 30.73,64.33 31.18,64.33 31.27,64.42 31.27,64.79 30.33,65.73 30.33,66.81 29.48,67.65 29.36,67.65 28.96,67.26 28.58,67.26 28.31,67.53 28.31,67.91 28.7,68.31 28.7,68.44 28.29,68.84 28.29,69.43 26.97,70.75 v1(26.97,71.73)
  BOTTOM w0.089: U6.C20 167.38,103.24 v1(167.73,103.59)
  BOTTOM w0.102: v1(26.97,71.73) 26.97,72.08 26.61,72.45 CV784.2
MDP_A2N_R: length 7.4
  BOTTOM w0.102: U11.16 27.55,82.2 27.68,82.32 27.68,82.57 27.67,82.57 v9(27.67,82.96) 27.67,83.17 27.22,83.62 26.25,83.62 26.18,83.69 23.89,83.69 23.48,84.1 23.48,84.26 23.26,84.48 22.95,84.48 22.79,84.32 22.79,84.14 C57.2
MDP_A2P_CPU: length 218.4
  IN4 w0.089: v1(167.73,102.88) 167.73,103.03 167.59,103.17 167.37,103.17 167.29,103.09 167.29,102.59 167.43,102.45 167.87,102.45 167.92,102.4 167.92,101.8 167.28,101.16 164.72,101.16 163.64,102.24 163.64,103.03 162.33,104.34 145.97,104.34 144.44,102.8 144.44,101.43 142.02,99.02 141.54,99.02 140.85,98.33 140.85,96.55 136.97,92.67 136.97,85.08 134.41,82.53 134.41,76.19 132.32,74.1 132.32,67.83 132.5,67.65 132.5,64.72 119.09,51.3 117.03,51.3 100.11,34.38 94.52,34.38 93.48,35.43 82.51,35.43 81.51,34.42 76.34,34.42 75.87,34.89 69.02,34.89 68.13,35.77 66.32,35.77 65.7,35.15 63.85,35.15 63.23,35.77 57.38,35.77 48.92,44.23 46.77,44.23 44.41,46.59 44.41,47.2 41.63,49.98 36.85,49.98 32.4,54.44 32.4,55.87 31.51,56.76 31.51,63.41 31.28,63.64 30.83,63.64 30.75,63.73 30.75,64 30.83,64.09 31.28,64.09 31.51,64.32 31.51,64.89 30.57,65.83 30.57,66.91 29.58,67.89 29.26,67.89 28.86,67.5 28.68,67.5 28.55,67.63 28.55,67.81 28.94,68.21 28.94,68.54 28.54,68.94 28.54,69.53 27.21,70.85 27.21,71.4 27.54,71.73 v1(27.55,71.73)
  BOTTOM w0.089: v1(167.73,102.88) 167.39,102.54 U6.D20
  BOTTOM w0.102: v1(27.55,71.73) 27.22,72.06 27.22,72.18 CV783.2
MDP_A2P_R: length 7.4
  BOTTOM w0.102: C59.2 23.16,84.73 23.37,84.73 23.73,84.37 23.73,84.2 24,83.94 26.29,83.94 26.35,83.88 v9(26.55,83.88) 27.32,83.88 27.93,83.27 27.93,82.68 27.93,82.67 27.93,82.32 28.05,82.2 U11.17
MDP_A3N_CPU: length 218.4
  IN4 w0.089: v1(24.91,71.75) 24.91,72.43 26.02,73.54 32.66,73.54 33.6,72.6 33.6,66.53 34.94,65.2 34.94,55.48 37.3,53.12 42.88,53.12 49.26,46.74 50.02,46.74 58.48,38.29 69.99,38.29 70.32,37.96 72.35,37.96 72.88,38.49 74.08,38.49 74.61,37.96 94.87,37.96 95.93,36.89 98.19,36.89 116.6,55.3 118.4,55.3 129.58,66.49 129.58,94.43 132.01,96.86 135.09,96.86 138.77,100.54 138.77,101.76 141.41,104.4 142.05,104.4 144.08,106.43 146.46,106.43 147.33,107.3 166.2,107.3 167.28,106.22 167.28,104.98 167.34,104.92 167.59,104.92 v1(167.75,105.09)
  BOTTOM w0.089: U6.A20 167.36,104.69 v1(167.75,105.09)
  BOTTOM w0.102: v1(24.91,71.75) 25.08,71.92 25.08,72.17 CV786.2
MDP_A3N_R: length 7.2
  BOTTOM w0.102: C56.2 22.91,82.45 23.08,82.61 23.39,82.61 23.49,82.51 23.49,81.41 23.77,81.14 v9(24.01,81.14) 24.23,81.14 24.51,81.41 24.51,82.51 24.63,82.63 26.25,82.63 26.3,82.58 26.3,82.43 26.25,82.38 26.11,82.38 26.05,82.32 U11.13
MDP_A3P_CPU: length 218.3
  IN4 w0.089: v1(167.75,104.27) 167.75,104.58 167.65,104.68 167.24,104.68 167.04,104.88 167.04,106.12 166.1,107.06 147.43,107.06 146.56,106.19 144.18,106.19 142.15,104.16 141.51,104.16 139.01,101.66 139.01,100.44 135.19,96.62 132.12,96.62 129.82,94.33 129.82,66.39 118.5,55.06 116.7,55.06 98.29,36.65 95.83,36.65 94.77,37.72 74.51,37.72 73.98,38.25 72.98,38.25 72.45,37.72 70.22,37.72 69.89,38.04 58.38,38.04 49.92,46.5 49.16,46.5 42.78,52.88 37.2,52.88 34.69,55.38 34.69,65.1 33.36,66.43 33.36,72.5 32.56,73.3 26.12,73.3 25.15,72.33 25.15,72.1 v1(25.5,71.75)
  BOTTOM w0.089: v1(167.75,104.27) 167.42,103.94 U6.B20
  BOTTOM w0.102: v1(25.5,71.75) 25.33,71.92 25.33,72.07 CV785.2
MDP_A3P_R: length 7.2
  BOTTOM w0.102: C54.2 23.11,82.87 23.49,82.87 23.74,82.62 23.74,81.52 23.87,81.39 24.13,81.39 24.25,81.52 24.25,82.62 24.52,82.89 v9(25.04,82.89) 26.35,82.89 26.55,82.69 U11.14
MDP_AUXN_PCH: length 305
  IN4 w0.089: v1(270.9,38.87) 270.82,38.87 270.58,39.11 270.58,39.44 270.25,39.78 265.65,39.78 264.41,41.02 264.41,41.58 264.05,41.94 260.14,41.94 259.4,42.68 253.78,42.68 253.38,42.27 213.16,42.27 207.06,36.18 207.06,26.4 202.27,21.6 200.55,21.6 199.07,20.12 198.25,20.12 197.63,19.51 172.42,19.51 172.11,19.82 168.59,19.82 167.14,21.27 156.88,21.27 156.63,21.52 154.73,21.52 154.52,21.3 150.13,21.3 149.06,22.37 146.82,22.37 146.24,21.79 130.21,21.79 129.55,22.45 116.62,22.45 116.22,22.05 111.32,22.05 100.63,32.73 93.54,32.73 92.76,33.5 87.02,33.5 86.27,32.75 75.58,32.75 75.09,33.24 63.43,33.24 63.17,33.5 60.84,33.5 60.22,34.12 56.65,34.12 52.78,37.99 51.64,37.99 51.01,38.62 51.01,39.26 47.69,42.58 45.99,42.58 42.73,45.83 42.73,46.32 40.78,48.28 33.83,48.28 31.84,50.27 31.84,52.61 30.72,53.73 30.72,55.21 29.82,56.11 29.82,61.54 29.01,62.35 29.01,63.47 27.71,64.77 27.71,67.54 27.15,68.11 27.15,69.73 26.35,70.53 26.35,72.02 26.8,72.46 30.38,72.46 31.25,71.59 31.47,71.59 v1(31.81,71.24)
  BOTTOM w0.089: v1(270.9,38.87) 271.02,38.87 271.38,39.23 271.48,39.23 271.54,39.29 271.54,39.41 271.39,39.56 271.21,39.56 271.09,39.44 U7.K43
  BOTTOM w0.102: v1(31.81,71.24) 31.95,71.38 32.24,71.38 32.61,71.75 32.61,72.23 CV812.2
MDP_AUXN_PCH_C: length 7.9
  BOTTOM w0.102: CV812.1 32.62,73.57 32.62,74.12 34.05,75.54 34.05,78.7 33.83,78.91 v9(33.59,78.91) 33.18,78.91 33.04,79.06 U11.29
MDP_AUXP_PCH: length 305.1
  IN4 w0.089: v1(31.81,71.83) 31.35,71.83 30.48,72.7 26.7,72.7 26.11,72.12 26.11,70.43 26.91,69.63 26.91,68.01 27.47,67.44 27.47,64.67 28.76,63.37 28.76,62.25 29.58,61.44 29.58,56.01 30.48,55.11 30.48,53.63 31.6,52.51 31.6,50.17 33.73,48.04 40.68,48.04 42.49,46.22 42.49,45.73 45.89,42.34 47.59,42.34 50.77,39.16 50.77,38.52 51.54,37.75 52.68,37.75 56.55,33.88 60.12,33.88 60.74,33.26 63.07,33.26 63.33,33 74.99,33 75.48,32.51 86.37,32.51 87.12,33.26 92.66,33.26 93.44,32.49 100.53,32.49 111.22,21.8 116.32,21.8 116.72,22.21 129.45,22.21 130.11,21.55 146.34,21.55 146.92,22.13 148.96,22.13 150.03,21.06 154.62,21.06 154.83,21.27 156.53,21.27 156.78,21.03 167.04,21.03 168.49,19.58 172.01,19.58 172.32,19.27 197.73,19.27 198.35,19.88 199.17,19.88 200.65,21.36 202.37,21.36 207.31,26.3 207.31,36.08 213.26,42.03 253.48,42.03 253.88,42.44 259.3,42.44 260.04,41.7 263.95,41.7 264.17,41.48 264.17,40.92 265.55,39.54 270.15,39.54 270.34,39.34 v1(270.34,38.82)
  BOTTOM w0.089: U7.K45 271.09,39.78 270.8,39.49 270.8,39.41 270.34,38.95 v1(270.34,38.82)
  BOTTOM w0.102: v1(31.81,71.83) 32,71.64 32.14,71.64 32.36,71.86 32.36,72.14 32.05,72.45 CV813.2
MDP_AUXP_PCH_C: length 7.9
  BOTTOM w0.102: U11.30 32.99,78.56 33.1,78.66 33.73,78.66 33.79,78.6 v9(33.79,76.26) 33.79,75.65 32.37,74.23 32.37,73.35 32.28,73.26 32.04,73.26 CV813.1
MDP_CFG0: length 3.8
  TOP w0.102: R2530.1 26.96,78.32 R2531.1 v2(26.89,77.29) 26.89,77.13 26.82,77.07 26.61,77.07 v1(26.26,77.42)
  BOTTOM w0.102: v1(26.26,77.42) 26.13,77.56 U11.5
MDP_CFG1_INPUT: length 3.6
  TOP w0.102: R2536.1 R2533.1 29.52,74.37 v1(29.93,73.95) 29.93,73.82 v2(30.39,73.36)
  BOTTOM w0.102: v1(29.93,73.95) 30.05,74.07 U11.40
MDP_DDC_CTRLCLK: length 313.1
  TOP w0.089: v1(271.51,40.77) 272.8,42.06 RPH16.3
  IN1 w0.076: v1(271.51,40.77) 271.51,38.95 269.23,36.66 269.23,36.03 v1(269.71,35.54)
  IN3 w0.102: v1(31.08,77.17) 30.85,76.94 30.56,76.94 30.16,76.55 30.16,75.33 28.23,73.4 28.23,66.14 28.53,65.84 28.84,65.84 v4(29.04,65.64)
  IN4 w0.089: v1(271.51,40.77) 271.71,40.57 271.71,40.44 271.44,40.17 265.79,40.17 264.79,41.18 264.79,41.75 264.34,42.2
  IN4 w0.102: 264.34,42.2 263.3,43.25 261.68,43.25 261.19,42.76 260.57,42.76 259.59,43.74 213.48,43.74 206.04,36.3 206.04,26.52 201.98,22.46 199.41,22.46 197.27,20.31 190.81,20.31 190.01,21.12 187.73,21.12 186.95,20.33 182.85,20.33 181.73,21.45 177.45,21.45 176.32,20.31 172.76,20.31 170.75,22.32 154.4,22.32 154.18,22.11 151.89,22.11 150.39,23.6 136.17,23.6 135.82,23.25 117.19,23.25 116.38,24.07 110.45,24.07 100.98,33.54 93.97,33.54 93.19,34.31 86.69,34.31 85.94,33.56 76.01,33.56 75.52,34.04 63.76,34.04 62.88,34.93 57.01,34.93 48.56,43.38 46.4,43.38 43.57,46.22 43.57,46.85 41.32,49.09 36.53,49.09 31.55,54.07 31.55,55.52 30.66,56.41 30.66,61.97 29.83,62.8 29.83,63.79 28.55,65.07 28.55,65.74 28.69,65.88 28.8,65.88 v4(29.04,65.64)
  BOTTOM w0.089: v1(269.71,35.54) 269.67,35.54 269.25,35.96 U7.R35
  BOTTOM w0.102: v1(31.08,77.17) 31.19,77.06 U11.33
MDP_DDC_CTRLDATA: length 311.6
  TOP w0.089: v1(272.11,40.79) 272.88,41.56 RPH16.4
  IN1 w0.076: v1(272.11,40.79) 271.69,40.37 271.69,38.87 269.61,36.79 v1(269.61,36.25)
  IN3 w0.102: v4(29.04,66.3) 28.79,66.05 28.61,66.05 28.43,66.23 28.43,73.31 30.36,75.24 30.36,76.46 30.64,76.74 30.93,76.74 v1(31.1,76.57)
  IN4 w0.089: v1(272.11,40.79) 271.91,40.58 271.91,40.37 271.51,39.97 265.73,39.97 264.6,41.1 264.6,41.66 264.05,42.2
  IN4 w0.102: 264.05,42.2 263.22,43.04 261.76,43.04 261.28,42.55 260.49,42.55 259.51,43.54 213.56,43.54 206.26,36.23 206.26,26.45 202.06,22.25 199.5,22.25 197.36,20.11 190.73,20.11 189.93,20.91 187.82,20.91 187.03,20.12 182.76,20.12 181.65,21.24 177.53,21.24 176.4,20.11 172.67,20.11 170.67,22.12 154.48,22.12 154.27,21.9 151.8,21.9 150.3,23.4 136.26,23.4 135.91,23.05 117.11,23.05 116.29,23.86 110.37,23.86 100.9,33.33 93.88,33.33 93.11,34.11 86.77,34.11 86.02,33.36 75.87,33.36 75.39,33.84 63.68,33.84 62.8,34.72 56.93,34.72 48.47,43.18 46.31,43.18 43.36,46.13 43.36,46.77 41.24,48.89 36.45,48.89 31.35,53.99 31.35,55.44 30.46,56.33 30.46,61.88 29.63,62.72 29.63,63.7 28.34,64.99 28.34,65.83 28.64,66.12 28.87,66.12 v4(29.04,66.3)
  BOTTOM w0.089: v1(269.61,36.25) 269.3,36.56 U7.R36
  BOTTOM w0.102: U11.34 32.27,76.57 v1(31.1,76.57)
MDP_HPD: length 37.1
  IN2 w0.102: v1(26.26,79.9) 26.83,79.33 26.83,76.78 26.06,76.01 26.06,69.84 26.58,69.32 26.58,66.31 28.95,63.93 28.95,60.68 30.88,58.76 30.88,55.28 33.34,52.83 33.34,50.68 v4(33.62,50.4)
  GND3 w0.102: v7(33.25,51.04) 33.25,50.77 v4(33.62,50.4)
  BOTTOM w0.102: U11.9 25.93,79.56 v1(26.26,79.9) ; v7(33.25,51.04) 33.25,51.04 RV411.2 34.15,51.29 v2(34.81,51.95)
MDP_HPD_SINK: length 23.2
  BOTTOM w0.102: JMDP.2 8.6,89.01 8.95,88.67 11.79,88.67 v2(13.18,87.27) 13.61,86.85 19.45,86.85 19.72,86.58 19.72,82.64 22.01,80.36 24.52,80.36 24.72,80.56 U11.11
MDP_PEQ: length 4.3
  TOP w0.102: v1(26.26,76.78) 26.33,76.72 R2532.1 27.24,75.18 R2535.1 27.28,74.08 v2(27.35,74.01)
  BOTTOM w0.102: v1(26.26,76.78) 25.99,77.06 U11.4
MDP_RST#: length 9.2
  TOP w0.102: R2534.1 31.28,76.16 30.9,76.16 C2021.1 29.89,76.67 29.64,76.42 v2(28.95,76.42) 28.5,76.42 v1(28.03,75.95)
  BOTTOM w0.102: U11.35 31.61,76.06 31.51,76.16 30.92,76.16 30.31,75.55 28.43,75.55 v1(28.03,75.95)
MEM_TEMP0: length 93.6
  TOP w0.076: UE1.B13 162.28,20.82 161.96,21.13 161.96,21.32 161.77,21.51 161.77,21.52 161.57,21.72
  TOP w0.102: 161.57,21.72 161.48,21.82 161.48,22.4 v3(161.53,22.45) ; v1(133.64,46.05) 133.64,44.54 v2(133.62,44.51)
  GND1 w0.102: v3(161.53,22.45) 161.06,22.45 v5(160.74,22.14)
  IN1 w0.102: v5(160.74,22.14) 160.27,21.66 152.26,21.66 151.7,22.22 151.7,23.47 153.04,24.81 153.04,30.02 148.71,34.35 148.71,43.94 140.36,52.29 v4(140.36,52.72)
  IN2 w0.102: v1(133.64,46.05) 134.22,46.05 140.36,52.19 v4(140.36,52.72)
  BOTTOM w0.102: RT5.1 HT1.1 107.6,53.53 108.01,53.94 108.01,55.46 108.47,55.92 115.58,55.92 125.44,46.05 v1(133.64,46.05)
MEM_TEMP1: length 106.6
  TOP w0.089: v3(161.4,16.69) 161.62,16.91 162.03,16.91 UE1.B6
  TOP w0.102: v1(138.47,50.88) 138.47,51.57 v2(138.44,51.6)
  GND1 w0.076: v5(160.97,16.77) 161.31,16.77 v3(161.4,16.69)
  IN1 w0.076: v5(160.97,16.77) 160.97,16.83 160.65,17.15
  IN1 w0.102: v1(138.47,50.88) 145.66,43.69 145.66,27.39 147.26,25.78 147.26,21.37 149.66,18.97 156.95,18.97 157.42,19.44 158.88,19.44 159.45,18.86 159.45,17.59 159.84,17.21 160.59,17.21 160.65,17.15
  BOTTOM w0.102: v1(138.47,50.88) 177.24,50.88 HT3.1 186.81,60.44 RT3.1
MIC1_VREF: length 16.7
  TOP w0.203: 19.57,43.4 19.57,43.39 20.98,41.99 U15.30
  TOP w0.254: RA95.2 16.27,39.06 18.01,39.06 18.45,38.62 20.54,38.62 v1(20.71,38.44) ; v1(19.19,43.83) 19.19,43.79 19.57,43.4
  IN1 w0.254: v1(19.19,43.83) 19.19,43.79 20.57,42.4 20.57,38.58 v1(20.71,38.44)
  BOTTOM w0.102: v2(20.79,43.8) 20.38,43.39 19.62,43.39 v1(19.19,43.83)
MIC2_VREF: length 22.1
  TOP w0.203: U15.1 28.75,39.59 v1(28.98,39.36)
  TOP w0.254: v1(15.49,41.98) 15.49,42.41 RA93.1
  BOTTOM w0.254: v1(15.49,41.98) 15.61,41.87 15.61,41.14 15.91,40.84 16.89,40.84 17.4,40.33 17.4,38.96 17.69,38.67 17.69,37.73 18,37.43 19.42,37.43 20.59,36.26 27.6,36.26 28.38,37.04 28.38,38.77 v2(28.6,38.98) v1(28.98,39.36)
MIC2L: length 15.9
  TOP w0.203: U15.47 26.76,38.81 26.76,38.09 v1(26.5,37.84)
  TOP w0.254: v1(16.15,41.96) 16.55,41.96 CA68.1
  BOTTOM w0.254: 16.95,41.78 v2(16.95,41.77) ; 16.95,41.78 18.11,40.62 18.11,39.26 18.4,38.96 18.4,38.54 18.76,38.19 19.67,38.19 20.88,36.97 25.26,36.97 26.13,37.84 v1(26.5,37.84) ; 16.95,41.78 16.78,41.96 v1(16.15,41.96)
MIC2L_C: length 1.1
  TOP w0.254: RA92.1 CA68.2
MIC2R: length 16.5
  TOP w0.203: U15.48 27.16,38.81 v1(27.16,37.86)
  TOP w0.254: v1(16.13,41.35) CA69.1
  BOTTOM w0.254: v1(27.16,37.86) 27.16,37.81 v2(26.47,37.12) 25.96,36.61 20.74,36.61 19.54,37.81 18.35,37.81 18.05,38.11 18.05,38.82 17.75,39.11 17.75,40.47 16.88,41.35 v1(16.13,41.35)
MIC2R_C: length 1.2
  TOP w0.254: CA69.2 16.57,40.33 RA94.1
MINI3CLK_REQ#: length 62.9
  TOP w0.102: RPH25.6 261.08,16.16 261.23,16.01 262.34,16.01 v3(262.63,16.3)
  GND1 w0.102: v3(262.63,16.3) 262.63,16.66 v4(262.54,16.76)
  IN4 w0.089: 277.14,23.03 276.17,24 274.71,24 274.46,24.25 272.96,24.25 271.87,25.34 270.27,25.34 269.71,24.79 269.4,24.79 268.97,24.36 268.97,23.59 v6(268.82,23.44)
  IN4 w0.102: 277.14,23.03 277.29,22.88 v6(277.48,22.88) ; v6(268.57,9.84) 268.87,9.53 271.94,9.53 272.43,10.02 272.43,11.44 272.68,11.7 274.29,11.7 277.53,14.94 v6(278.55,14.94) ; v4(262.54,16.76) 262.95,16.35 263.43,16.35 264.76,17.69 277.7,17.69 v6(277.94,17.93)
  GND3 w0.089: v7(268.63,23.11) 268.63,23.25 268.82,23.44 v6(268.82,23.44)
  GND3 w0.102: v7(279.13,15.53) v6(278.55,14.94) ; v7(277.81,22.82) 277.54,22.82 v6(277.48,22.88) ; v7(267.7,10.4) 268.01,10.4 v6(268.57,9.84) ; v7(278.7,17.93) v6(277.94,17.93)
  BOTTOM w0.089: v7(268.63,23.11) 268.65,23.09 U7.T3
  BOTTOM w0.102: JTB1.18 267.7,9.79 267.8,9.9 267.8,10.29 v7(267.7,10.4) ; v7(277.81,22.82) 278.04,22.59 280.06,22.59 280.33,22.87 282.01,22.87 282.55,22.33 282.55,21.37 282.38,21.2 281.21,21.2 280.74,20.74 280.74,19.26 279.41,17.93 v7(278.7,17.93) 279.13,17.5 v2(279.13,16.16) v7(279.13,15.53)
MONO_IN: length 2.4
  TOP w0.102: CA17.1 29.86,39.25 v2(29.13,39.98) 29.12,39.99 U15.2
MULTI_STRAP_REF0_GND: length 4
  BOTTOM w0.089: 223.53,77.32 223.26,77.59 223.26,78.06 UV1.J1
  BOTTOM w0.102: 223.53,77.32 223.53,76.59 223.83,76.29 v2(223.83,75.78) 223.83,75.45 223.53,75.16 223.53,75.03 RV318.1
MUTE#: length 22.7
  IN3 w0.102: v1(13.63,33.8) 13.4,33.8 12.65,33.05 7.83,33.05 6.5,31.72 5.16,31.72 4.84,31.39 4.84,29.94 4.99,29.79 v1(5.37,29.79)
  BOTTOM w0.102: RA102.1 15.68,34.09 15.48,33.89 14.72,33.89 RA100.1 14.16,34.42 13.63,33.89 v1(13.63,33.8) ; QA2.1 3.3,27.17 RZ38.2 3.76,28.66 v2(3.99,28.89) 4.89,29.79 v1(5.37,29.79) ; v1(5.37,29.79) 5.37,29.34 5.62,29.09 UA5.1 ; v1(5.37,29.79) 5.51,29.79 6.27,29.03 UA5.2
NFC_DET#: length 184.6
  TOP w0.089: v3(266.84,20.16) 266.79,20.21 266.35,20.21 265.8,19.66
  TOP w0.102: v1(247.56,12.58) 247.56,14.28 v2(247.74,14.46) 247.97,14.69 252.57,14.69 252.72,14.84 254.42,14.84 254.81,14.45 254.81,13.7 255.2,13.3 259.09,13.3 259.84,12.56 264.82,12.56 v3(265.3,12.07) ; RPH24.8 265.8,18.73 265.8,18.73 265.8,19.66
  GND1 w0.089: v4(267.42,20.02) 266.98,20.02 v3(266.84,20.16)
  GND1 w0.102: v3(265.3,12.07) v5(264.81,12.07)
  IN1 w0.076: 267.06,19.66 v4(267.42,20.02)
  IN1 w0.102: 267.06,19.66 266.97,19.56 266.97,18.68 266.23,17.94 266.23,16.16 265.97,15.91 265.14,15.91 264.37,15.14 264.37,12.51 v5(264.81,12.07) ; v1(247.56,12.58) 247.56,12.38 246.31,11.13 235.93,11.13 235.4,11.67 233.91,11.67 233.27,11.02 219.31,11.02 218.87,11.46 218.87,13.32 216.98,15.22 214.39,15.22 212.19,13.03 v4(210.59,13.03)
  IN3 w0.102: v4(210.59,13.03) 210.1,12.53 207.88,12.53 207.84,12.49 205.45,12.49 204.42,13.52 201.35,13.52 200.52,12.69 195.3,12.69 193.93,14.07 191.94,14.07 191.01,15 189.91,15 187.38,17.53 184.65,17.53 183.74,16.62 175.92,16.62 172.19,20.36 172.19,21.46 171.59,22.05 167.65,22.05 166.79,21.2 156.37,21.2 155.45,20.28 152.87,20.28 152.48,20.66 148.93,20.66 148.61,20.98 147.13,20.98 146.83,21.29 142.53,21.29 141.65,22.16 129.81,22.16 128.94,23.03 127.49,23.03 126.83,22.37 118.31,22.37 v4(117.72,21.78)
  GND3 w0.089: v4(267.42,20.02) 267.42,20.47 v7(267.36,20.53)
  GND3 w0.102: v4(117.72,21.78) v7(117.72,21.35)
  BOTTOM w0.089: U7.Y3 267.03,22.08 267.32,21.78 267.32,20.57 v7(267.36,20.53)
  BOTTOM w0.102: JNFC1.12 117.3,20.93 RN7.1 117.43,21.35 v7(117.72,21.35)
NFC_IRQ: length 187.8
  TOP w0.102: RN1.2 RH65.1 275.21,13.88 v2(274.88,14.21) 274.45,14.21 v3(274.1,13.86)
  GND1 w0.102: v4(272.96,13.8) 273.01,13.86 v3(274.1,13.86)
  IN1 w0.076: v1(273.11,23.57) 272.68,23.13 272.68,22.68 272.76,22.59 272.76,20.88 272.92,20.72 272.92,20.01 272.57,19.66
  IN1 w0.102: v4(272.96,13.8) 272.6,14.17 272.6,14.89 273.49,15.79 273.49,16.43 272.57,17.35 272.57,19.66 272.57,19.66
  IN2 w0.102: v4(118.47,21.78) 119.38,22.69 121.33,22.69 121.93,23.28 131.26,23.28 132.64,21.91 147.47,21.91 v4(147.89,21.48)
  IN3 w0.102: v4(199.56,13.1) 195.53,13.1 190.13,18.5 177.73,18.5 176.58,19.66 173.46,19.66 172.59,20.52 172.59,21.63 171.74,22.49 167.51,22.49 167.25,22.23 160.67,22.23 160.04,21.6 154.99,21.6 154.45,21.06 149.53,21.06 148.69,21.91 148.31,21.91 v4(147.89,21.48)
  IN4 w0.102: v4(199.56,13.1) 201.28,11.38 210.9,11.38 214.54,15.02 216.93,15.02 221.13,10.82 233.86,10.82 234.47,11.43 236.28,11.43 236.89,10.82 244,10.82 244.43,11.25 249.01,11.25 249.4,10.87 249.74,10.87 250.06,11.19 252.87,11.19 253.11,11.42 256.24,11.42 256.53,11.14 258.52,11.14 258.71,11.34 260.83,11.34 261.41,10.75 263.66,10.75 264.76,11.85 264.76,12.6 265.17,13.01 268.43,13.01 269.09,13.67 272.83,13.67 v4(272.96,13.8)
  GND3 w0.102: v7(118.34,21.16) 118.47,21.28 v4(118.47,21.78)
  BOTTOM w0.089: U7.H6 273.09,23.59 v1(273.11,23.57)
  BOTTOM w0.102: JNFC1.11 117.8,20.62 v7(118.34,21.16)
NFC_RST#: length 173.9
  TOP w0.089: 256.44,19.66 v8(256.44,20) 256.44,21.34 257.3,22.21 260.69,22.21 261.77,21.13 262.06,21.13 262.34,20.85 262.34,19.96 262.57,19.73 v3(264.95,19.73) 265.01,19.66
  TOP w0.102: 265.01,19.66 265.25,19.42 265.25,17.32 265.42,17.15 267.07,17.15 267.3,17.38 RPH24.5 ; v1(246.58,18.32) 246.34,18.08 246.34,17.13 247.96,15.51 252.25,15.51 252.53,15.79 254.64,15.79 255.7,16.85 255.7,18.73 256.44,19.46 256.44,19.66
  GND1 w0.089: v4(264.7,20.02) 264.7,19.97 v3(264.95,19.73)
  IN2 w0.102: v4(185.33,16.71) 185.74,17.12 193.08,17.12 193.28,16.92 198.38,16.92 199.36,17.9 202.18,17.9 203.31,19.04 212.56,19.04 213.29,19.77 223.55,19.77 224.06,19.25 230.26,19.25 232.52,16.99 240.6,16.99 241.45,17.84 246.1,17.84 v1(246.58,18.32)
  IN3 w0.102: v4(185.33,16.71) 184.93,17.12 184.53,17.12 183.82,16.42 175.84,16.42 171.98,20.27 171.98,21.38 171.51,21.85 168.24,21.85 167.38,20.99 156.46,20.99 155.54,20.07 152.78,20.07 152.4,20.45 148.84,20.45 148.53,20.76 147.06,20.76 146.74,21.08 142.44,21.08 141.57,21.95 129.71,21.95 128.84,22.82 127.57,22.82 126.89,22.14 120.38,22.14 v4(120.02,21.78)
  GND3 w0.089: v4(264.7,20.02) 264.89,20.21 v7(264.89,20.39)
  GND3 w0.102: v7(120.49,21.25) 120.48,21.25 120.02,21.71 v4(120.02,21.78)
  BOTTOM w0.089: U7.AE4 264.99,22.51 264.72,22.23 264.72,21.98 264.89,21.81 v7(264.89,20.39)
  BOTTOM w0.102: v7(120.49,21.25) 120.3,21.06 JNFC1.6
