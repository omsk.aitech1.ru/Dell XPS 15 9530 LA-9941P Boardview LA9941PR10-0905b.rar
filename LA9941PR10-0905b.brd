# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D21: length 38.8
  IN1 w0.094: v1(224.66,104.4) 224.22,104.85 221.2,104.85 219.85,106.2 217.99,106.2 211.71,112.47 211.71,125.44 213.18,126.91 215.68,126.91 216.53,126.06 216.91,126.06 217.5,125.47 v1(217.5,124.87)
  BOTTOM w0.089: v1(224.66,104.4) 225.11,104.4 225.51,104 UV1.F32
  BOTTOM w0.102: v1(217.5,124.87) UV5.N13
FBA_D22: length 39.8
  IN1 w0.094: v1(217.51,124.08) 217.9,124.47 217.9,125.58 217.1,126.37 217.1,126.63 216.48,127.26 213.04,127.26 211.36,125.58 211.36,112.33 218.9,104.79 220.21,104.79 220.6,104.4 v1(223.77,104.4)
  BOTTOM w0.089: UV1.H33 224.17,104.8 v1(223.77,104.4) ; UV5.M11 217.51,124.06 v1(217.51,124.08)
FBA_D23: length 39.7
  IN1 w0.094: v1(223.77,103.64) 223.35,104.06 219.14,104.06 211.02,112.18 211.02,125.73 212.89,127.6 216.64,127.6 217.55,126.69 v1(217.55,126.5)
  BOTTOM w0.089: UV1.H32 224.13,104 v1(223.77,103.64)
  BOTTOM w0.102: v1(217.55,126.5) 217.55,125.62 UV5.M13
FBA_D24: length 17.2
  IN4 w0.094: v1(214.32,117.7) 214.81,117.7 215.5,117 215.5,115.88 215.3,115.68 214.92,115.68 214.67,115.43 214.67,114.5 215.48,113.69 216.78,113.69 219.52,110.95 219.52,106.01 v1(219.7,105.83)
  BOTTOM w0.089: v1(219.7,105.83) 219.46,105.6 UV1.P34 ; UV5.U4 213.94,118.07 v1(214.32,117.7)
FBA_D25: length 16.5
  IN4 w0.094: v1(214.32,116.05) 214.02,116.05 213.49,115.52 213.49,114.08 216.43,111.15 217.4,111.15 218.59,109.95 218.59,105.48 v1(219.65,104.42)
  BOTTOM w0.089: UV1.P32 219.22,104 v1(219.65,104.42) ; v1(214.32,116.05) 213.9,116.47 UV5.U2
FBA_D26: length 19.2
  IN4 w0.094: v1(219.67,103.61) 217.96,105.32 217.96,107.27 217.49,107.74 217.49,109.59 213.15,113.93 213.15,117.32 v1(214.29,118.47)
  BOTTOM w0.089: v1(219.67,103.61) 219.26,103.2 UV1.P31 ; v1(214.29,118.47) 214.69,118.07 UV5.T4
FBA_D27: length 16.1
  IN4 w0.094: v1(219.65,105.24) 219.17,105.71 219.17,110.81 216.64,113.34 215.18,113.34 213.85,114.66 213.85,115.4 214.1,115.64 214.48,115.64 214.92,116.08 v1(215.09,116.08)
  BOTTOM w0.089: UV1.P33 219.21,104.8 v1(219.65,105.24) ; v1(215.09,116.08) UV5.T2
FBA_D28: length 17.9
  IN4 w0.094: v1(217.5,117.66) 217.89,117.26 218.33,117.26 218.69,116.91 218.69,114.38 221.26,111.81 221.26,109.72 v1(221.76,109.22)
  BOTTOM w0.089: v1(217.5,117.66) 217.1,118.06 UV5.N4
  BOTTOM w0.127: v1(221.76,109.22) v2(222.5,108.48) 222.72,108.26 222.72,106.54 222.36,106.17 222.36,105.44 222.14,105.21 222.14,103.95 221.7,103.51 UV1.L31
FBA_D29: length 13.4
  IN4 w0.094: v1(217.5,116.07) 217.1,115.68 217.1,114.98 220.56,111.53 220.56,109.17 v1(221.8,107.93)
  BOTTOM w0.089: v1(217.5,116.07) UV5.N2
  BOTTOM w0.127: UV1.L34 221.45,105.85 v2(221.45,107.27) 221.45,107.59 v1(221.8,107.93)
FBA_D30: length 19.4
  IN4 w0.094: v1(217.54,118.49) 217.93,118.88 220,118.88 220.28,118.6 220.28,118.29 220.25,118.27 220.25,113.31 221.74,111.82 v1(221.74,109.87)
  BOTTOM w0.089: v1(217.54,118.49) 217.9,118.13 UV5.M4
  BOTTOM w0.127: v1(221.74,109.87) 221.07,109.2 v2(221.07,109.05) 221.07,105.91 221.3,105.69 221.3,104.69 221.7,104.29 UV1.L32
FBA_D31: length 15
  IN4 w0.094: v1(221.8,108.59) 220.91,109.48 220.91,111.67 217.93,114.65 217.93,116.44 v1(217.5,116.87)
  BOTTOM w0.089: v1(217.5,116.87) UV5.M2
  BOTTOM w0.127: UV1.L33 221.7,105.09 222.07,105.46 222.07,105.91 221.94,106.04 221.94,106.29 222.31,106.67 222.31,108.08 v1(221.8,108.59)
FBA_D32: length 27.8
  IN4 w0.089: v1(208.71,101.15) 208.71,100.4 209.23,99.88 210.63,99.88 210.85,100.1 ; v1(208.28,118.44) 209.68,118.44
  IN4 w0.094: 210.85,100.1 211.03,100.29 211.29,100.29 211.73,100.73 211.73,102.88 213.45,104.6 213.45,105.09 214.58,106.22 214.58,109.44 211.25,112.77 211.25,116.86 209.68,118.44
  BOTTOM w0.089: UV6.A4 208.64,118.07 v1(208.28,118.44) ; v1(208.71,101.15) 208.4,100.84 UV1.AG28
FBA_D33: length 19.2
  IN4 w0.094: v1(208.77,101.95) 208.79,101.95 208.8,101.96 208.8,101.98 210.13,103.31 210.13,104.57 211.33,105.77 211.33,107.95 207.64,111.63 v1(207.64,113.67)
  BOTTOM w0.089: UV1.AF29 209.17,101.55 v1(208.77,101.95)
  BOTTOM w0.127: UV6.A2 209.04,116.47 209.26,116.25 209.26,114.74 208.19,113.67 v1(207.64,113.67)
FBA_D34: length 20.4
  IN4 w0.094: v1(207.58,114.31) 207.17,113.9 207.17,111.61 210.98,107.8 210.98,105.68 209.94,104.64 209.94,103.38 208.9,102.34 208.45,102.34 v1(208.04,101.93)
  BOTTOM w0.089: UV1.AG29 208.4,101.57 v1(208.04,101.93)
  BOTTOM w0.127: UV6.B4 208.28,117.66 208.28,115.01 v1(207.58,114.31)
FBA_D35: length 19.8
  IN4 w0.089: 208.26,114.78 207.89,115.15 207.89,115.65 v1(207.47,116.07)
  IN4 w0.094: v1(209.62,101.93) 209.62,102.29 210.5,103.16 210.5,104.43 211.82,105.75 212.36,105.75 212.58,105.96 212.58,106.36 212.03,106.92 212.03,109.04 208.39,112.67 208.39,114.65 208.26,114.78
  BOTTOM w0.089: v1(209.62,101.93) 209.62,101.12 UV1.AF28 ; v1(207.47,116.07) UV6.B2
FBA_D36: length 25.2
  IN4 w0.089: 209.26,118.06 208.11,118.06 207.85,118.32 207.07,118.32 206.81,118.06 205.48,118.06 v1(205.04,118.5)
  IN4 w0.094: v1(211.31,101.96) 211.34,101.99 211.34,102.75 213.26,104.68 213.26,105.16 214.23,106.13 214.23,107.17 213.77,107.64 213.77,109.76 210.9,112.63 210.9,116.42 209.26,118.06
  BOTTOM w0.089: UV1.AD30 211.31,101.98 v1(211.31,101.96)
  BOTTOM w0.102: UV6.E4 205.47,118.06 205.04,118.48 v1(205.04,118.5)
FBA_D37: length 22.2
  IN4 w0.089: v1(205.9,116.06) 206.89,116.06 207.3,116.47 207.64,116.47 208.25,115.86 208.25,115.24 208.71,114.78
  IN4 w0.094: 208.71,114.78 209.51,113.99 209.51,112.05 212.37,109.18 212.37,107.06 212.84,106.6 212.84,105.93 212.48,105.56 211.9,105.56 210.68,104.35 210.68,103.09 210.21,102.61 210.21,101.79 210.49,101.51 v1(210.49,101.13)
  BOTTOM w0.089: UV1.AD29 210.9,101.54 v1(210.49,101.13) ; v1(205.9,116.06) 205.47,116.49 205.47,116.49 UV6.E2
FBA_D38: length 25.6
  IN4 w0.089: 211.79,103.59 210.95,102.75 210.95,101.49 v1(211.29,101.15) ; 208.3,117.58 208.14,117.58 207.66,118.07 207.2,118.07 207.07,117.94 207.07,117.53 206.79,117.25 205.48,117.25 v1(205.07,117.67)
  IN4 w0.094: 208.3,117.58 209.06,116.82 209.41,116.82 210.55,115.68 210.55,112.48 213.42,109.61 213.42,107.49 213.88,107.03 213.88,106.04 213.08,105.24 213.08,104.88 211.79,103.59
  BOTTOM w0.089: v1(211.29,101.15) 211.69,101.55 UV1.AC29
  BOTTOM w0.102: UV6.F4 v1(205.07,117.67)
FBA_D39: length 22.4
  IN4 w0.089: v1(205.07,116.07) 205.47,115.67 205.47,114.99 205.67,114.79 207.76,114.79 207.76,114.78
  IN4 w0.094: 207.76,114.78 208.05,114.5 208.05,111.72 211.68,108.09 211.68,105.86 210.31,104.49 210.31,103.23 209.23,102.15 209.23,101.57 v1(210.49,100.31)
  BOTTOM w0.089: v1(205.07,116.07) UV6.F2 ; v1(210.49,100.31) 210.88,100.7 UV1.AD28
FBA_D40: length 25.2
  IN1 w0.094: v1(207.06,101.93) 207.19,102.06 207.19,103.14 208,103.95 208,104.59 208.75,105.34 208.75,107.01 209.52,107.77 209.52,110.43 208.13,111.82 208.13,113.79 209.52,115.18 209.52,122.04 v1(208.29,123.27)
  BOTTOM w0.089: v1(208.29,123.27) 208.67,123.65 UV6.A11 ; UV1.AJ29 206.65,101.73 206.85,101.93 v1(207.06,101.93)
FBA_D41: length 28.2
  IN1 w0.094: v1(208.24,125.67) 207.89,125.31 207.89,120.42 208.74,119.56 208.74,118.2 208.07,117.53 208.07,115.07 207.76,114.75 207.35,114.75 207.08,114.48 207.08,112.37 208.79,110.67 208.79,107.68 207.95,106.84 207.95,105.91 207.56,105.52 207.56,103.99 206.81,103.24 206.81,102.44 206.5,102.14 206.46,102.14 206.26,101.93 v1(206.23,101.93)
  BOTTOM w0.089: v1(208.24,125.67) 208.64,125.27 UV6.A13 ; 205.83,101.53 v1(206.23,101.93)
  BOTTOM w0.102: UV1.AK29 205.83,101.53
FBA_D42: length 23.6
  IN1 w0.094: v1(206.26,102.8) 206.26,103.13 207.23,104.09 207.23,105.45 207.6,105.82 207.6,106.98 208.44,107.82 208.44,110.52 206.68,112.29 206.68,114.71 207.07,115.11 207.07,122.84 v1(207.49,123.26)
  BOTTOM w0.089: v1(207.49,123.26) 207.87,123.63 UV6.B11 ; v1(206.26,102.8) 206.66,102.4 UV1.AJ30
FBA_D43: length 29.7
  IN1 w0.094: v1(208.28,124.87) 209.87,123.28 209.87,115.03 208.48,113.65 208.48,111.96 209.87,110.58 209.87,105.72 208.95,104.8 208.57,104.8 208.28,104.51 208.28,103.66 207.5,102.89 207.5,101.74 207.29,101.53 205.85,101.53 v1(205.42,101.1)
  BOTTOM w0.089: UV6.B13 207.88,125.27 v1(208.28,124.87) ; UV1.AK28 205.8,100.72 v1(205.42,101.1)
FBA_D44: length 26.3
  IN1 w0.094: v1(203.8,101.11) 203.81,101.11 204.77,102.07 204.77,103.34 205.91,104.48 205.91,106.89 207.22,108.21 207.22,110.27 204.66,112.83 204.66,120.1 205.52,120.96 205.52,122.64 205.09,123.07 v1(205.09,123.26)
  BOTTOM w0.089: UV1.AM29 204.19,101.5 v1(203.8,101.11) ; UV6.E11 205.47,123.63 v1(205.09,123.26)
FBA_D45: length 28.5
  IN1 w0.094: v1(203.8,102.77) 203.8,103.94 204.8,104.94 204.8,107.26 206.08,108.54 206.08,109.63 202.27,113.44 202.27,122.29 203.07,123.09 203.07,125.1 203.25,125.28 204.69,125.28 v1(205.08,125.67)
  BOTTOM w0.089: v1(203.8,102.77) 204.17,103.15 UV1.AM31 ; UV6.E13 205.47,125.28 v1(205.08,125.67)
FBA_D46: length 26.9
  IN1 w0.094: v1(204.26,124.08) 203.45,123.28 203.45,119.01 203.07,118.63 203.07,113.3 206.46,109.91 206.46,108.43 205.18,107.15 205.18,104.79 204.2,103.81 204.2,102.62 203.97,102.39 203.52,102.39 v1(203,101.87)
  BOTTOM w0.089: v1(203,101.87) 203.37,101.5 UV1.AN29 ; v1(204.26,124.08) UV6.F11
FBA_D47: length 27.3
  IN1 w0.094: v1(204.25,124.86) 204.7,124.41 204.7,123.13 204.34,122.77 204.34,121.74 203.85,121.24 203.85,113.02 206.84,110.02 206.84,108.32 205.56,107.04 205.56,104.66 204.46,103.56 204.46,102.31 204.08,101.93 v1(203.78,101.93)
  BOTTOM w0.089: UV1.AM30 204.15,102.3 v1(203.78,101.93) ; v1(204.25,124.86) 204.67,125.27 UV6.F13
FBA_D48: length 26.3
  IN1 w0.094: v1(196.27,123.27) 196.26,123.27 195.15,123.27 194.94,123.07 194.94,121.16 194.27,120.48 194.27,114.53 200.91,107.89 200.91,105.58 202.35,104.14 202.35,103.53 v1(202.42,103.46)
  BOTTOM w0.102: UV6.U11 v1(196.27,123.27)
  BOTTOM w0.127: UV1.AN31 202.73,103.15 v1(202.42,103.46)
FBA_D49: length 27.7
  IN1 w0.094: v1(196.27,125.67) 196.66,125.28 197.28,125.28 197.47,125.09 197.47,123.11 196.34,121.97 196.14,121.97 195.88,121.72 195.88,120.78 195.03,119.93 195.03,114.8 201.61,108.22 201.61,106.33 202.2,105.74 202.2,105.21 v1(203.01,104.4)
  BOTTOM w0.089: UV1.AN32 203.4,104.01 v1(203.01,104.4)
  BOTTOM w0.102: v1(196.27,125.67) UV6.U13
FBA_D50: length 27.5
  IN1 w0.094: v1(201.87,103.86) 200.56,105.17 200.56,107.74 193.89,114.42 193.89,120.66 194.52,121.29 194.52,123.25 194.92,123.65 195.85,123.65 v1(196.27,124.07)
  BOTTOM w0.102: UV6.T11 v1(196.27,124.07)
  BOTTOM w0.127: UV1.AP30 201.97,102.93 201.97,103.76
  BOTTOM w0.132: 201.97,103.76 v1(201.87,103.86)
FBA_D51: length 26.2
  IN1 w0.094: v1(196.27,124.87) 196.67,124.47 196.67,123.02 196.52,122.86 195.66,122.86 195.41,122.62 195.41,121.04 194.65,120.28 194.65,114.64 201.26,108.03 201.26,105.87 v1(201.64,105.49)
  BOTTOM w0.102: v1(196.27,124.87) UV6.T13
  BOTTOM w0.127: v1(201.64,105.49) 201.64,104.96 UV1.AP32
FBA_D52: length 23.7
  IN1 w0.094: v1(199.47,123.27) 199.47,123.09 199.06,122.69 199.06,121.51 197.47,119.92 197.47,114.1 203.22,108.35 203.22,107.58 v1(202.4,106.76)
  BOTTOM w0.102: UV6.N11 v1(199.47,123.27)
  BOTTOM w0.127: v1(202.4,106.76) 203.11,106.76 203.8,106.07 203.8,105.36 204.2,104.96 UV1.AM33
FBA_D53: length 28.6
  IN1 w0.094: v1(199.47,125.67) 199.85,125.29 201.23,125.29 201.47,125.05 201.47,123.7 201.36,123.59 201.36,122.45 201.5,122.32 201.5,120.33 201.74,120.09 201.74,119.01 201.48,118.75 201.48,111.56 204.32,108.72 204.32,107.09 204.42,106.99 204.42,105.07 203.77,104.42 203.77,104.36 v1(203,103.59)
  BOTTOM w0.102: v1(199.47,125.67) UV6.N13
  BOTTOM w0.127: UV1.AL31 204.61,103.59 v1(203,103.59)
FBA_D54: length 24.4
  IN1 w0.094: v1(199.47,124.07) 199.86,123.68 199.86,121.79 197.89,119.82 197.89,119.28 198.27,118.91 198.27,113.79 203.57,108.49 203.57,107.17 v1(203.57,107.17)
  BOTTOM w0.102: UV6.M11 v1(199.47,124.07)
  BOTTOM w0.127: v1(203.57,107.17) 204.03,107.17 205.45,105.74 205.45,105.56 205.9,105.11 UV1.AK33
FBA_D55: length 24.5
  IN1 w0.094: v1(203.97,106.61) 203.97,108.58 200.67,111.88 200.67,124.28 200.46,124.49 199.85,124.49 v1(199.47,124.87)
  BOTTOM w0.102: v1(199.47,124.87) UV6.M13
  BOTTOM w0.127: v1(203.97,106.61) 203.97,106.43 205.47,104.93 205.47,104.43 UV1.AK32
FBA_D56: length 27.5
  IN4 w0.094: v1(210.62,106.34) 210.62,107.65 204.67,113.6 204.67,116.4 204.69,116.41 204.69,117.02 203.89,117.82 203.89,119.12 202.34,120.66 200.47,120.66 200.14,120.99 197.51,120.99 195.5,118.98 v1(195.5,118.47)
  BOTTOM w0.089: v1(195.5,118.47) 195.87,118.11 UV6.U4
  BOTTOM w0.132: v1(210.62,106.34) 210.62,106.29 210.87,106.03 210.87,105.63 UV1.AD34
FBA_D57: length 30.9
  IN4 w0.094: v1(209.56,104.4) 209.56,105.52 209.84,105.8 209.84,107.19 205.41,111.63 203.63,111.63 203.01,112.25 203.01,115.84 203.06,115.89 203.06,117.02 202.78,117.3 202.47,117.3 202.27,117.51 202.27,119.08 201.53,119.82 200.39,119.82 199.9,120.31 198.51,120.31 197.15,118.95 196.87,118.95 196.66,118.74 196.66,116.46 v1(196.28,116.08)
  BOTTOM w0.089: v1(196.28,116.08) 195.89,116.47 UV6.U2 ; v1(209.56,104.4) 210.5,104.4 UV1.AD32
FBA_D58: length 28.3
  IN4 w0.094: v1(197.07,117.67) 197.07,117.85 198.33,119.11 200.62,119.11 200.77,118.96 201.21,118.96 201.48,118.68 201.48,117.5 202.23,116.75 202.23,112.53 203.49,111.28 205.26,111.28 209.48,107.06 209.48,105.85 209.16,105.53 209.16,104.05 v1(209.58,103.63)
  BOTTOM w0.089: v1(209.58,103.63) 210.09,103.63 210.53,103.19 210.53,103.04 210.78,102.79 211.04,102.79 211.42,102.4 UV1.AC30 ; v1(197.07,117.67) UV6.T4
FBA_D59: length 29.4
  IN4 w0.094: v1(210.15,105.36) 210.19,105.41 210.19,107.33 205.22,112.3 204.38,112.3 203.85,112.83 203.85,117.05 203.6,117.29 203.29,117.29 203.07,117.51 203.07,118.7 201.49,120.28 200.39,120.28 199.99,120.68 197.78,120.68 196.06,118.97 196.06,118.29 195.87,118.09 195.87,117.27 v1(196.27,116.87)
  BOTTOM w0.089: v1(210.15,105.36) 210.71,104.8 UV1.AD33 ; v1(196.27,116.87) UV6.T2
FBA_D60: length 21.3
  IN4 w0.094: v1(198.67,117.67) 198.67,117.43 198.28,117.05 198.28,116.29 199.07,115.5 199.07,114.31 199.18,114.2 199.18,110.82 200.87,109.12 203.01,109.12 205.27,106.87 205.27,106.62 207.7,104.19 208.24,104.19 v1(208.83,103.61)
  BOTTOM w0.089: v1(198.67,117.67) UV6.N4 ; UV1.AF31 209.2,103.24 v1(208.83,103.61)
FBA_D61: length 17.6
  IN4 w0.094: v1(208.36,106.12) 207.55,106.93 207.55,107.51 204.89,110.17 201.3,110.17 200.35,111.12 200.35,114.66 200.64,114.95 200.64,115.35 200.27,115.72 v1(200.27,116.07)
  BOTTOM w0.089: UV6.N2 199.47,116.07 v1(200.27,116.07) ; v1(208.36,106.12) 208.36,105.64 UV1.AG34
FBA_D62: length 20.3
  IN4 w0.094: v1(199.47,117.67) 199.07,117.28 199.07,116.68 199.43,116.31 199.43,114.6 199.58,114.45 199.58,110.9 201.01,109.47 203.15,109.47 205.74,106.89 205.74,106.69 207.78,104.65 208.52,104.65 v1(208.8,104.37)
  BOTTOM w0.089: UV1.AG32 208.43,104 v1(208.8,104.37) ; v1(199.47,117.67) UV6.M4
FBA_D63: length 18.5
  IN4 w0.094: v1(200.27,116.87) 199.83,116.44 199.83,114.86 199.97,114.73 199.97,111.01 201.16,109.82 204.73,109.82 205.96,108.6 205.96,107.16 v1(207.96,105.16)
  BOTTOM w0.089: v1(207.96,105.16) 208.04,105.16 UV1.AG33 ; v1(200.27,116.87) UV6.M2
FBA_DBI0: length 17.7
  IN4 w0.089: 221.8,105.29 221.8,103.18 220.55,101.93 v1(220.47,101.93)
  IN4 w0.094: v1(223.9,116.07) 223.52,115.69 223.52,114.31 223.59,114.24 223.59,107.08 221.8,105.29
  BOTTOM w0.089: v1(220.47,101.93) 219.67,101.93 UV1.P30
  BOTTOM w0.102: UV5.D2 v1(223.9,116.07)
FBA_DBI1: length 29.6
  IN1 w0.089: 228.01,106.53 228.01,106.24 227.71,105.94 227.22,105.94 225.91,104.63 225.91,103.82 225.49,103.4 v1(225.49,102.75)
  IN1 w0.094: v1(224.71,125.66) 224.9,125.66 225.61,126.37 227.46,126.37 228.21,125.62 228.21,121.05 228.01,120.85 228.01,106.53
  BOTTOM w0.089: UV1.F31 225.9,103.16 v1(225.49,102.75) ; UV5.D13 224.33,125.27 v1(224.71,125.66)
FBA_DBI2: length 31.6
  IN1 w0.094: v1(215.9,124.87) 214.9,124.87 214.41,125.36 213.1,125.36 212.76,125.01 212.76,114.4 217.78,109.37 219.73,109.37 222.99,106.12 v1(225.61,106.12)
  BOTTOM w0.089: v1(215.9,124.87) UV5.P13 ; UV1.F34 225.9,105.89 225.68,106.12 v1(225.61,106.12)
FBA_DBI3: length 15.4
  IN4 w0.094: v1(216.7,116.07) 216.28,115.65 216.28,114.98 216.42,114.84 216.61,114.84 220.21,111.24 220.21,107.83 v1(220.59,107.45)
  BOTTOM w0.089: v1(216.7,116.07) UV5.P2
  BOTTOM w0.127: UV1.M32 220.83,104 220.51,104.32 220.51,104.99 220.23,105.27 220.23,105.87 220.03,106.08 220.03,107.01 220.48,107.45 v1(220.59,107.45)
FBA_DBI4: length 21.2
  IN4 w0.089: 209.34,116.39 209,116.39 208.14,117.25 207.22,117.25 207.05,117.08 207.05,116.67 206.82,116.44 206.34,116.44 v1(205.93,116.85)
  IN4 w0.094: 209.34,116.39 210.2,115.54 210.2,112.34 213.07,109.47 213.07,107.35 213.53,106.88 213.53,105.95 212.89,105.31 212.89,104.94 211.58,103.64 v1(211.33,103.64)
  BOTTOM w0.089: v1(205.93,116.85) 206.27,116.51 UV6.D2 ; v1(211.33,103.64) 210.9,103.21 UV1.AD31
FBA_DBI5: length 26.7
  IN1 w0.094: v1(205.88,124.87) 205.5,124.49 205.5,123.09 205.83,122.77 205.83,120.3 205.48,119.96 205.48,112.5 207.63,110.35 207.63,108.12 206.31,106.8 206.31,104.3 205.03,103.01 205.03,102.31 v1(205.41,101.93)
  BOTTOM w0.089: v1(205.41,101.93) 205.41,101.87 205.04,101.5 UV1.AL29 ; v1(205.88,124.87) 206.27,125.26 UV6.D13
FBA_DBI6: length 28.8
  IN1 w0.094: v1(202.4,107.42) 202.87,107.9 202.87,108.2 196.66,114.42 196.66,118.35 196.62,118.38 196.62,120.81 197.74,121.92 198.02,121.92 198.27,122.18 198.27,122.69 198.45,122.86 198.5,122.86 198.5,122.86 198.83,122.86 198.83,122.86 198.87,122.86 199.07,123.07 199.07,125.11 198.91,125.28 198.26,125.28 v1(197.87,125.67)
  BOTTOM w0.102: UV6.P13 v1(197.87,125.67)
  BOTTOM w0.127: v1(202.4,107.42) 201.92,106.94 201.92,106.48 202.63,105.77 202.63,105.62 203.03,105.21 203.59,105.21 203.75,105.06 203.75,104.42 204.17,104 UV1.AM32
FBA_DBI7: length 24.2
  IN4 w0.094: v1(197.87,116.07) 197.47,116.46 197.47,117.81 198.51,118.85 199.86,118.85 200.69,118.02 200.69,117.46 200.89,117.25 201.23,117.25 201.85,116.63 201.85,111.4 202.35,110.9 205.15,110.9 209.12,106.93 v1(209.12,106.12)
  BOTTOM w0.089: v1(197.87,116.07) UV6.P2 ; UV1.AF34 209.2,105.83 209.12,105.91 v1(209.12,106.12)
FBA_EDC0: length 17.6
  IN4 w0.089: 222.13,105.13 222.13,103.13 221.3,102.29 v1(221.3,101.93)
  IN4 w0.094: v1(224.72,116.09) 224.28,115.65 224.28,114.5 223.94,114.16 223.94,106.93 222.13,105.13
  BOTTOM w0.089: UV1.M31 221.3,102.8 v1(221.3,101.93)
  BOTTOM w0.102: v1(224.72,116.09) UV5.C2
FBA_EDC1: length 32.4
  IN1 w0.089: v1(224.67,102.74) 224.67,102.83 225.73,103.9 225.73,104.7 227.15,106.12 227.51,106.12 227.66,106.26 227.66,106.53
  IN1 w0.094: v1(224.73,124.87) 225.14,125.28 225.74,125.28 225.89,125.43 225.89,125.86 226.1,126.07 227.27,126.07 227.87,125.47 227.87,122.3 227.66,122.09 227.66,119.65 227.57,119.56 227.18,119.56 227.09,119.46 227.09,119.28 227.18,119.18 227.57,119.18 227.66,119.09 227.66,118.9 227.57,118.81 227.18,118.81 227.09,118.71 227.09,118.52 227.18,118.43 227.57,118.43 227.66,118.34 227.66,118.15 227.57,118.05 227.18,118.05 227.09,117.96 227.09,117.77 227.18,117.68 227.57,117.68 227.66,117.58 227.66,106.53
  BOTTOM w0.089: v1(224.73,124.87) 225.1,125.25 UV5.C13 ; v1(224.67,102.74) 225.05,103.12 UV1.G31
FBA_EDC2: length 33.9
  IN1 w0.094: v1(215.9,125.67) 215.52,125.29 214.88,125.29 214.47,125.7 212.96,125.7 212.41,125.15 212.41,113.96 217.9,108.47 220.14,108.47 222.94,105.67 v1(225.16,105.67)
  BOTTOM w0.089: v1(225.16,105.67) 225.3,105.67 225.8,105.16 226.12,105.16 226.49,104.8 UV1.E33 ; v1(215.9,125.67) UV5.R13
FBA_EDC3: length 14.5
  IN4 w0.094: v1(215.9,116.07) 215.9,115.82 215.45,115.37 215.45,115.1 216.42,114.13 216.83,114.13 219.87,111.1 219.87,107.53 v1(220.52,106.87)
  BOTTOM w0.089: v1(215.9,116.07) UV5.R2
  BOTTOM w0.127: UV1.M33 220.9,105.06 220.52,105.44 v1(220.52,106.87)
FBA_EDC4: length 21.3
  IN4 w0.089: v1(207.47,116.87) 208.14,116.87 209.34,115.67
  IN4 w0.094: 209.34,115.67 209.85,115.16 209.85,112.19 212.72,109.33 212.72,107.2 213.19,106.74 213.19,106.01 212.71,105.53 212.71,105.02 212.04,104.35 211.16,104.35 210.91,104.1 210.91,103.05 210.53,102.67 210.53,102.02 v1(210.57,101.98)
  BOTTOM w0.089: v1(207.47,116.87) UV6.C2
  BOTTOM w0.102: UV1.AE31 210.06,103.2 210.57,102.69 v1(210.57,101.98)
FBA_EDC5: length 26.2
  IN1 w0.094: v1(206.67,125.67) 206.29,125.29 206.29,124.51 206.11,124.34 206.11,123.87 206.29,123.7 206.29,117.38 206.37,117.29 206.37,116.55 206.29,116.47 206.29,112.19 208.06,110.41 208.06,108.06 206.66,106.66 206.66,104 v1(205.46,102.8)
  BOTTOM w0.089: UV1.AK30 205.8,102.46 v1(205.46,102.8) ; UV6.C13 v1(206.67,125.67)
FBA_EDC6: length 26.2
  IN1 w0.094: v1(202.4,108.11) 202.4,108.18 195.87,114.71 195.87,118.12 196.37,118.62 196.37,121.16 197.26,122.05 197.26,122.46 197.66,122.86 197.7,122.86 197.7,122.86 198.03,122.86 198.03,122.86 198.07,122.86 198.27,123.07 198.27,124.47 v1(197.87,124.87)
  BOTTOM w0.102: UV6.R13 v1(197.87,124.87)
  BOTTOM w0.127: UV1.AN33 203.12,104.8 202.35,105.57 202.2,105.57 201.48,106.28 201.48,107.19 v1(202.4,108.11)
FBA_EDC7: length 22.6
  IN4 w0.094: v1(197.87,116.87) 197.87,117.09 198.26,117.48 198.26,117.82 198.53,118.09 199.58,118.09 199.86,117.81 199.86,117.36 199.95,117.28 200.47,117.28 200.67,117.07 200.67,115.83 200.9,115.6 201.32,115.6 201.47,115.45 201.47,111.24 202.2,110.52 205.04,110.52 208.35,107.2 v1(208.35,106.67)
  BOTTOM w0.089: UV1.AF33 209.2,104.81 208.72,105.29 208.72,106.3 208.49,106.53 ; v1(197.87,116.87) UV6.R2
  BOTTOM w0.127: 208.49,106.53 v1(208.35,106.67)
FBA_SEN0: length 5
  TOP w0.089: v1(219.9,123.26) 220.09,123.26 220.47,122.88 221.3,122.88 221.55,122.63 221.55,122.05 v2(222.06,121.54) 222.44,121.17 RV353.2
  BOTTOM w0.089: UV5.J10 220.3,122.93 219.97,123.26 v1(219.9,123.26)
FBA_SEN2: length 6.7
  TOP w0.089: 201.17,126.97 201.45,126.69 v2(201.45,126.14) 201.45,122.32 v1(201.88,121.9)
  TOP w0.102: RV366.2 201.17,126.97
  BOTTOM w0.102: UV6.J10 202.27,122.29 v1(201.88,121.9)
FBA_WCK01: length 26.2
  BOTTOM w0.089: 222.78,105.52 222.78,105.5 222.8,105.49 222.8,105.1 222.89,105.01 222.89,103.23 222.77,103.11 222.64,103.11 UV1.K31
  BOTTOM w0.114: 222.78,105.52 222.78,105.89 223.28,106.39 223.28,110.44 223.39,110.55 223.39,110.58 223.78,110.97 223.81,110.97 v9(225.06,112.22) 227.65,114.8 227.65,120.07 227.19,120.53 224.72,120.53 224.52,120.32 224.52,119.18 224.69,119.01 224.69,118.63 224.57,118.51 223.95,118.51 223.84,118.4 223.84,118.19 223.96,118.07 UV5.D4
FBA_WCK01#: length 26.3
  BOTTOM w0.089: UV1.L30 222.15,102.85 222.78,102.85 223.08,103.15 223.08,105.09 222.99,105.18 222.99,105.49 223,105.5 223,105.52
  BOTTOM w0.114: 223,105.52 223,105.79 223.5,106.29 223.5,110.35 v9(223.75,110.61) 225,111.86 225.03,111.86 225.42,112.25 225.42,112.28 227.86,114.71 227.86,120.16 227.28,120.75 224.64,120.75 224.3,120.41 UV5.D5
FBA_WCK23: length 29.8
  IN4 w0.107: v1(215.89,118.47) 216.17,118.75 216.17,118.96 216.37,119.16 216.37,119.67 216.95,120.25 218.6,120.25 219.23,120.88 225.01,120.88 227.87,118.02 227.87,114.34 226.73,113.2 226.73,112.54 v1(226.94,112.33)
  BOTTOM w0.089: v1(215.89,118.47) 216.29,118.07 UV5.P4
  BOTTOM w0.114: UV1.H34 224.2,105.61 224.07,105.74 224.07,105.95 224.38,106.26 224.38,110.16 224.81,110.6 225.53,110.6 226.76,111.83 226.76,112.15 v1(226.94,112.33)
FBA_WCK23#: length 29.9
  IN4 w0.107: v1(226.36,112.33) 226.51,112.48 226.51,113.29 227.65,114.43 227.65,117.93 224.92,120.66 219.33,120.66 218.69,120.02 217.04,120.02 216.6,119.58 216.6,119.07 216.4,118.87 216.4,118.69 216.62,118.47 v1(216.7,118.47)
  BOTTOM w0.089: v1(216.7,118.47) UV5.P5
  BOTTOM w0.114: v1(226.36,112.33) 226.54,112.15 226.54,111.92 225.44,110.82 224.72,110.82 224.16,110.25 224.16,106.35 223.85,106.04 223.85,105.42 223.79,105.35 223.48,105.35 223.4,105.43 UV1.J34
FBA_WCK45: length 25.5
  IN1 w0.107: v1(208.99,113.4) 209.35,113.04 209.54,113.04 210.17,112.42 210.17,111.7 211.21,110.66 211.21,104.42 209.8,103.01 208.91,103.01 208.81,102.91 v1(208.81,102.8)
  BOTTOM w0.089: UV1.AG30 208.4,102.68 208.52,102.8 v1(208.81,102.8)
  BOTTOM w0.114: UV6.D4 206.69,118.49 206.69,119.62 206.97,119.9 208.48,119.9 209.77,118.6 209.77,113.44 209.46,113.13 209.26,113.13 v1(208.99,113.4)
FBA_WCK45#: length 25.6
  IN1 w0.107: v1(208.99,112.82) 209.45,112.82 209.94,112.32 209.94,111.61 210.99,110.57 210.99,104.52 209.71,103.24 208.4,103.24 v1(207.94,102.77)
  BOTTOM w0.089: UV1.AG31 208.36,103.2 v1(207.94,102.77)
  BOTTOM w0.114: UV6.D5 206.48,119.08 206.48,119.71 206.88,120.11 208.57,120.11 209.99,118.69 209.99,113.35 209.55,112.91 209.08,112.91 v1(208.99,112.82)
FBA_WCK67: length 30.4
  TOP w0.114: v1(198.3,119.49) 198.3,119.79 197.7,120.39 195.59,120.39 195.35,120.15 195.35,119.21 194.99,118.84 194.99,114.9 197.42,112.47 200.98,112.47 203.54,109.9 203.8,109.9 203.82,109.93 204.38,109.93 204.4,109.9 204.71,109.9 205.19,109.42 205.19,108.77 v1(205.38,108.58)
  BOTTOM w0.114: v1(198.3,119.49) 197.92,119.1 197.92,118.42 UV6.P4 ; v1(205.38,108.58) 205.19,108.39 205.19,108.03 204.78,107.62 204.78,107.44 205.11,107.1 205.29,107.1 205.91,107.72 206.27,107.72 206.63,107.36 206.63,107 206.08,106.45 206.08,106.3 206.31,106.07 206.31,105.64 206.46,105.49 206.59,105.49 UV1.AJ34
FBA_WCK67#: length 30.2
  TOP w0.114: v1(198.81,119.87) 198.53,119.87 197.79,120.6 195.5,120.6 195.13,120.24 195.13,119.3 194.77,118.93 194.77,114.81 197.33,112.25 200.89,112.25 203.45,109.69 v9(204.1,109.69) 204.62,109.69 204.98,109.33 204.98,108.78 v1(204.75,108.55)
  BOTTOM w0.114: UV1.AK34 206.1,105.79 206.1,105.98 205.87,106.21 205.87,106.54 206.41,107.09 206.41,107.27 206.18,107.5 206,107.5 205.38,106.89 205.02,106.89 204.56,107.35 204.56,107.71 204.98,108.12 204.98,108.32 v1(204.75,108.55) ; UV6.P5 198.32,118.87 198.81,119.36 v1(198.81,119.87)
FBB_CMD0: length 40.1
  BOTTOM w0.127: UV1.D13 228.01,87.74 228.63,87.74 228.79,87.57 228.79,87.19 229.11,86.88 230.71,86.88 231.04,86.54 231.47,86.54 232.22,85.8 v2(234.66,85.8) 235.91,85.8 237.93,87.82 237.93,89.82 238.49,90.38 240.9,90.38 241.13,90.61 241.13,93.89 241.76,94.52 246.28,94.52 247.31,93.49 247.31,85.91 247.71,85.5 249.53,85.5 249.72,85.69 250.93,85.69 251.37,85.24 UV9.G12
FBB_CMD1: length 34.6
  TOP w0.127: v1(249.27,85.96) 248.84,85.96 247.45,84.57 247.45,82.59 247.61,82.43 248.11,82.43 248.25,82.29 248.25,81.82 248.11,81.69 247.57,81.69 247.45,81.56 247.45,79.96 247,79.52 238.43,79.52 236.72,81.22 232.79,81.22 230.06,83.95 230.06,85.67 v8(228.62,87.11) v1(227.19,88.54)
  BOTTOM w0.089: v1(249.27,85.96) 249.35,86.05 UV9.H10
  BOTTOM w0.102: v1(227.19,88.54) 226.79,88.94 226.79,89 UV1.E14
FBB_CMD2: length 38.7
  TOP w0.127: v1(250.2,86.41) 250.2,86.31 249.4,85.5 248.89,85.5 247.8,84.41 247.8,83.16 248.12,82.85 248.5,82.85 248.75,82.59 248.75,81.58 248.02,80.85 248.02,79.61 247.44,79.03 238.23,79.03 236.98,80.27 233.17,80.27 v8(229.2,84.25) 228.28,85.16 228.28,86.75 227.55,87.48 226.91,87.48 226.76,87.64 226.76,88.72 226.5,88.97 226.01,88.97 v1(225.56,89.41)
  BOTTOM w0.089: v1(250.2,86.41) 250.57,86.05 UV9.H11
  BOTTOM w0.102: v1(225.56,89.41) 225.95,89.03 UV1.F14
FBB_CMD3: length 39.5
  BOTTOM w0.127: UV1.A12 230.82,87.3 231.2,86.92 231.73,86.92 232.47,86.18 233.11,86.18 233.24,86.3 233.24,87.16 233.36,87.28 233.62,87.28 233.75,87.16 233.75,86.3 233.87,86.18 234.13,86.18 234.25,86.3 234.25,87.16 234.38,87.28 234.63,87.28 234.76,87.16 234.76,86.3 234.89,86.18 235.76,86.18 237.55,87.97 237.55,90.63 237.68,90.76 v2(238.03,90.76) 240.63,90.76 240.75,90.89 240.75,94.08 241.6,94.92 246.42,94.92 246.73,94.61 246.73,94.6 247.61,93.72 247.61,87.1 247.86,86.85 248.63,86.85 248.97,87.19 250.13,87.19 UV9.K11
FBB_CMD4: length 29.8
  TOP w0.127: v1(249.23,87.62) 248.65,87.04 248.65,86.42 247.05,84.82 247.05,80.81 246.19,79.95 239.99,79.95 v8(239.46,80.48) 233.31,86.63 v1(232.69,86.63)
  BOTTOM w0.089: UV9.K10 249.26,87.65 v1(249.23,87.62) ; 230.88,87.64 229.54,87.64 UV1.B12
  BOTTOM w0.127: 230.88,87.64 231.03,87.64 231.36,87.3 232.02,87.3 v1(232.69,86.63)
FBB_CMD5: length 39.9
  BOTTOM w0.127: UV1.C14 228.7,89 229.11,88.59 229.55,88.59 229.72,88.42 229.88,88.42 230.29,88.02 231.18,88.02 231.52,87.68 236.72,87.68 237.17,88.13 237.17,91.07 237.82,91.72 238,91.72 238.39,91.33 238.57,91.33 238.75,91.51 238.75,91.69 238.36,92.08 238.36,92.26 238.54,92.44 238.72,92.44 239.11,92.05 239.29,92.05 239.47,92.22 239.47,92.4 239.08,92.8 239.08,92.98 239.26,93.16 239.44,93.16 239.83,92.76 240.01,92.76 240.19,92.94 240.19,93.12 v2(239.98,93.34) 239.8,93.52 239.8,93.7 241.43,95.33 246.55,95.33 247.12,94.77 247.12,94.76 247.92,93.96 247.92,87.61 248.07,87.46 248.65,87.46 248.83,87.64 248.83,87.8 249.08,88.04 250.67,88.04 251.07,88.45 UV9.L12
FBB_CMD6: length 37.9
  IN1 w0.089: v1(245.39,87.25) 245.55,87.25 245.98,87.69 248.19,87.69 v1(248.48,87.98)
  BOTTOM w0.089: UV9.K4 245,87.65 v1(245.39,87.25)
  BOTTOM w0.127: UV1.B14 229.45,89 229.81,88.64 229.97,88.64 230.21,88.4 231.34,88.4 231.68,88.07 233.55,88.07 234.19,88.71 234.37,88.71 234.81,88.27 234.99,88.27 235.17,88.45 235.17,88.62 234.73,89.07 234.73,89.24 234.91,89.42 235.09,89.42 235.53,88.98 235.71,88.98 235.89,89.16 235.89,89.34 235.45,89.78 235.45,89.96 235.63,90.14 235.81,90.14 236.25,89.7 236.43,89.7 236.61,89.88 236.61,90.06 236.17,90.5 236.17,90.68 241.25,95.76 246.66,95.76 247.5,94.92 247.5,94.92 248.48,93.93 v1(248.48,87.98)
FBB_CMD7: length 40.1
  TOP w0.127: v1(225.72,90.27) 226.15,89.84 226.65,89.84 227.06,89.42 227.63,89.42 227.82,89.61 231.04,89.61 231.96,90.53 236.1,90.53 v8(236.3,90.72) 236.64,91.07 236.64,91.25 236.16,91.72 236.16,91.9 236.34,92.08 236.52,92.08 237,91.61 237.18,91.61 237.36,91.79 237.36,91.97 236.88,92.44 236.88,92.62 237.06,92.8 237.24,92.8 237.72,92.32 237.9,92.32 238.08,92.5 238.08,92.68 237.6,93.16 237.6,93.34 237.78,93.52 237.96,93.52 238.44,93.04 238.62,93.04 238.8,93.22 238.8,93.4 238.32,93.88 238.32,94.06 238.5,94.24 238.68,94.24 239.16,93.76 239.34,93.76 239.52,93.94 239.52,94.12 239.04,94.6 239.04,94.78 239.22,94.96 239.4,94.96 239.88,94.48 240.06,94.48 240.75,95.18 245.44,95.18 247.35,93.27 247.35,89.77 246.24,88.65 v1(246.24,88.07)
  BOTTOM w0.089: v1(246.24,88.07) 245.82,87.65 UV9.K5
  BOTTOM w0.102: v1(225.72,90.27) 225.24,89.8 UV1.G15
FBB_CMD8: length 34.5
  TOP w0.127: v1(226.34,90.22) 226.6,90.22 227.03,89.78 227.49,89.78 227.82,90.11 231.01,90.11 236.45,95.56 v8(237.37,95.56) 245.6,95.56 247.74,93.42 247.74,89.67 246.86,88.79 246.86,86.96 246.47,86.57 245.51,86.57 v1(245.39,86.45)
  BOTTOM w0.089: v1(245.39,86.45) 245,86.85 UV9.J4 ; v1(226.34,90.22) 225.95,89.83 UV1.F15
FBB_CMD9: length 39
  TOP w0.127: v1(226.36,89.42) 226.6,89.19 v8(228.18,89.19) 231.17,89.19 232.12,90.14 237.54,90.14 237.7,90.31 237.7,90.49 237.24,90.95 237.24,91.13 237.42,91.31 237.6,91.31 238.06,90.85 238.24,90.85 238.42,91.03 238.42,91.21 237.96,91.67 237.96,91.85 238.14,92.03 238.32,92.03 238.78,91.56 238.96,91.56 239.14,91.74 239.14,91.92 238.68,92.39 238.68,92.57 238.86,92.75 239.04,92.75 239.5,92.28 239.68,92.28 239.86,92.46 239.86,92.64 239.4,93.1 239.4,93.28 239.58,93.46 239.76,93.46 240.22,93 240.4,93 240.58,93.18 240.58,93.36 240.12,93.82 240.12,94 240.3,94.18 240.48,94.18 240.94,93.72 241.12,93.72 242.19,94.8 245.06,94.8 246.8,93.06 246.8,89.67 245.78,88.65 245.78,87.56 v1(246.32,87.02)
  BOTTOM w0.089: v1(226.36,89.42) 226.74,89.8 UV1.E15 ; v1(246.32,87.02) 246.14,86.85 UV9.J5
FBB_CMD10: length 36.9
  TOP w0.127: v1(240,95.98) 240.51,96.49 v8(242.81,96.49) 245.75,96.49 248.47,93.76 248.47,88.72 247.89,88.13 247.89,86.47 247.12,85.69 245.39,85.69 v1(245.34,85.64)
  BOTTOM w0.089: UV1.D15 227.71,89.8 228.03,89.48 229.8,89.48 ; UV9.H4 245.34,85.69 v1(245.34,85.64)
  BOTTOM w0.127: v1(240,95.98) 239.58,95.98 233.55,89.95 233.55,89.45 232.93,88.83 231.99,88.83 231.66,89.16 230.46,89.16 230.17,89.46 229.82,89.46 229.8,89.48
FBB_CMD11: length 32
  TOP w0.127: v1(240.7,95.98) 240.79,96.07 v8(245.27,96.07) 245.63,96.07 248.12,93.58 248.12,89.31 247.25,88.45 247.25,86.46 246.91,86.11 v1(246.32,86.11)
  BOTTOM w0.089: v1(246.32,86.11) 246.25,86.05 UV9.H5
  BOTTOM w0.127: UV1.A14 230.22,88.78 231.5,88.78 231.83,88.45 233.09,88.45 233.93,89.29 233.93,89.8 239.58,95.45 240.17,95.45 v1(240.7,95.98)
FBB_CMD12: length 35.4
  TOP w0.127: v1(244.59,84.84) 244.59,84.86 244.19,85.25 240.88,85.25 240.75,85.12 240.75,84.16 240.62,84.03 240.37,84.03 240.24,84.16 240.24,85.12 240.12,85.25 239.86,85.25 239.74,85.12 239.74,81.25 239.61,81.13 239.35,81.13 239.23,81.25 239.23,85.12 239.1,85.25 238.85,85.25 238.72,85.12 238.72,82.27 238.59,82.14 238.34,82.14 238.21,82.27 238.21,85.12 238.08,85.25 235.25,85.25 231.95,88.55 v8(230.21,88.55) v1(227.98,88.55)
  BOTTOM w0.089: v1(244.59,84.84) UV9.G3
  BOTTOM w0.102: v1(227.98,88.55) 227.93,88.55 227.6,88.87 UV1.D14
FBB_CMD13: length 39.6
  TOP w0.127: v1(232.93,89.64) 237.06,89.64 237.18,89.52 v8(237.18,88.65) 237.18,87.37 237.31,87.25 237.54,87.25 237.67,87.37 237.67,88.98 237.79,89.11 238.05,89.11 238.17,88.98 238.17,87.37 238.3,87.25 238.56,87.25 238.68,87.37 238.68,88.98 238.81,89.11 239.06,89.11 239.19,88.98 239.19,87.37 239.32,87.25 239.57,87.25 239.7,87.37 239.7,90.42 239.83,90.55 240.08,90.55 240.21,90.42 240.21,87.37 240.33,87.25 240.59,87.25 240.71,87.37 240.71,90.29 240.84,90.42 241.1,90.42 241.22,90.29 241.22,87.37 241.35,87.25 v1(242.99,87.25)
  BOTTOM w0.089: v1(242.99,87.25) 242.45,87.25 241.7,87.99
  BOTTOM w0.127: v1(232.93,89.64) 232.49,89.21 232.15,89.21 231.82,89.54 230.46,89.54 230.21,89.8 UV1.A15 ; 241.7,87.99 241.63,88.07 RV418.1
  BOTTOM w0.132: v1(242.99,87.25) UV9.J2
FBB_CMD14: length 41.1
  TOP w0.127: v1(243.79,86.45) v8(237.86,86.45) 237.35,86.45 237.16,86.25 237.16,85.76 237.03,85.63 236.78,85.63 236.65,85.76 236.65,88.97 236.52,89.1 236.27,89.1 236.14,88.97 236.14,85.76 236.02,85.63 235.76,85.63 235.63,85.76 235.63,88.97 235.51,89.1 235.25,89.1 235.13,88.97 235.13,86.42 235,86.3 234.75,86.3 234.62,86.42 234.62,88.97 234.49,89.1 234.24,89.1 234.11,88.97 234.11,87.44 233.98,87.31 233.73,87.31 233.6,87.44 233.6,88.97 233.48,89.1 233.22,89.1 233.09,88.97 233.09,88.45 232.97,88.33 232.71,88.33 232.59,88.45 232.59,88.97 232.28,89.28 v1(232.28,89.67)
  BOTTOM w0.089: v1(243.79,86.45) 242.2,86.45 242.06,86.3 241.7,86.3
  BOTTOM w0.127: UV1.B15 229.49,89.8 229.83,90.14 230.32,90.14 230.51,89.95 232,89.95 v1(232.28,89.67) ; 241.7,86.3 239.58,86.3 239.32,86.57 RV410.1
  BOTTOM w0.132: v1(243.79,86.45) UV9.J3
FBB_CMD15: length 35.6
  IN1 w0.089: v1(244.58,88.84) 244.99,89.25 246.94,89.25 247.75,90.06 v1(248.91,90.06)
  BOTTOM w0.089: v1(244.58,88.84) 244.19,88.45 UV9.L3
  BOTTOM w0.102: 232.34,90.37 230.69,90.37 230.63,90.43 229.68,90.43 229.49,90.24 228.09,90.24 227.96,90.37 227.96,90.81 227.84,90.94 227.84,91.19 228.14,91.5 UV1.C17
  BOTTOM w0.127: v1(248.91,90.06) 248.9,90.07 248.9,94.06 246.49,96.47 238.97,96.47 232.87,90.37 232.34,90.37
FBB_CMD16: length 32.4
  BOTTOM w0.102: 232.61,90.81 232.55,90.75 229.8,90.75 229.42,91.13 229.04,91.13 228.79,91.38 228.79,91.64 228.47,91.96 228.03,91.96 227.68,92.3 UV1.D18
  BOTTOM w0.127: 232.61,90.81 v2(236.63,94.83) 237.65,95.85 238.65,96.85 247.59,96.85 248.63,97.9 248.63,102.37 249.01,102.75 249.49,102.75 249.6,102.85 250.96,102.85 UV10.G12
FBB_CMD17: length 47.1
  BOTTOM w0.127: 249.39,104.47 249.21,104.65 248.33,104.65 248.21,104.78 248.21,112.75 248.08,112.88 242.4,112.88 240.61,111.08 240.61,107.77 239.59,106.74 237.33,106.74 234.66,104.07 v2(234.66,103.77) 234.66,97.83 230.87,94.04 230.87,94.03 230.5,93.66 229.04,93.66 228.84,93.86 228.84,94.25 228.71,94.38 227.38,94.38 227.19,94.19 227.19,92.92 226.8,92.53 UV1.E18
  BOTTOM w0.132: 249.39,104.47 249.78,104.08 UV10.H10
FBB_CMD18: length 47.7
  BOTTOM w0.127: UV1.F18 226.23,92.3 226.58,91.96 226.94,91.96 227.14,92.16 227.14,92.36 227.52,92.74 228.46,92.74 228.74,92.46 228.87,92.46 229.17,92.76 229.44,92.76 229.53,92.86 230.25,92.86 235.22,97.83 v2(235.22,101.68) 235.22,103.87 237.7,106.36 239.75,106.36 240.99,107.61 240.99,110.91 242.58,112.5 247.69,112.5 247.82,112.37 247.82,104.34 247.95,104.21 248.87,104.21 249.44,103.64 250.15,103.64
  BOTTOM w0.132: UV10.H11 250.15,103.64
FBB_CMD19: length 41.8
  BOTTOM w0.127: UV1.A20 230.28,94 234,97.71 v2(234,99.93) 234,104.23 236.9,107.13 239.43,107.13 240.22,107.93 240.22,111.26 242.23,113.27 248.23,113.27 248.59,112.91 248.59,106 249.3,105.29 250.2,105.29 UV10.K11
FBB_CMD20: length 42
  BOTTOM w0.127: 249.14,106.01 248.98,106.18 248.98,113.06 248.38,113.65 242.01,113.65 239.84,111.48 239.84,108.09 239.26,107.51 236.45,107.51 v2(236.28,107.35) 233.36,104.43 233.36,97.62 230.08,94.35 229.55,94.35 UV1.B20
  BOTTOM w0.132: 249.14,106.01 249.47,105.68 UV10.K10
FBB_CMD21: length 32.9
  TOP w0.127: v1(250.99,106.05) 250.42,106.05 248.07,103.7 248.07,97.77 247.52,97.23 v8(239.76,97.23) 236.34,97.23 v1(232.86,93.74)
  BOTTOM w0.127: UV1.C18 228.47,92.3 228.84,91.93 230.13,91.93 230.26,92.05 231.28,92.05 232.41,93.19 232.41,93.58 232.57,93.74 v1(232.86,93.74)
  BOTTOM w0.132: UV10.L12 251.39,106.45 v1(250.99,106.05)
FBB_CMD22: length 34.5
  TOP w0.127: v1(231.48,93.46) 231.5,93.48 231.5,95.32 233.5,97.32 233.5,98.6 233.98,99.08 234.16,99.08 v8(234.53,98.71) 235.08,98.16 235.26,98.16 235.44,98.34 235.44,98.52 234.52,99.44 234.52,99.62 234.7,99.8 234.88,99.8 235.8,98.88 235.98,98.88 236.16,99.06 236.16,99.24 235.24,100.16 235.24,100.34 235.42,100.52 235.6,100.52 236.52,99.6 236.7,99.6 236.88,99.78 236.88,99.96 235.96,100.88 235.96,101.06 236.14,101.24 236.32,101.24 237.23,100.32 237.41,100.32 237.59,100.5 237.59,100.68 236.68,101.6 236.68,101.78 240.18,105.28 v1(244.59,105.28)
  BOTTOM w0.127: v1(231.48,93.46) 231.48,93.36 230.99,92.87 230.69,92.87 230.47,92.64 229.68,92.64 229.34,92.3 UV1.B18
  BOTTOM w0.132: v1(244.59,105.28) UV10.K4
FBB_CMD23: length 43.8
  TOP w0.127: v1(225.51,92.71) 226.03,93.23 226.55,93.23 v8(229.07,95.76) 230.08,96.77 230.08,100.76 234.03,104.71 234.03,105.81 241.93,113.7 246.06,113.7 248.45,111.31 248.45,107.49 v1(246.19,105.23)
  BOTTOM w0.089: v1(246.19,105.23) 245.79,105.63 UV10.K5
  BOTTOM w0.102: UV1.G18 v1(225.51,92.71)
FBB_CMD24: length 45.4
  TOP w0.127: v1(245.43,104.49) 244.98,104.94 244.98,105.57 245.1,105.68 245.58,105.68 247.75,107.86 247.75,110.8 245.62,112.93 242.25,112.93 234.8,105.48 234.8,103.8 v8(234.06,103.07) 232.74,101.75 232.74,97.65 227.24,92.15 226.59,92.15 225.98,91.54 225.09,91.54 v1(224.73,91.9)
  BOTTOM w0.089: UV10.J4 245.04,104.88 v1(245.43,104.49)
  BOTTOM w0.102: v1(224.73,91.9) 224.73,91.87 UV1.G17
FBB_CMD25: length 43.9
  TOP w0.127: v1(225.51,92) 225.89,92.38 226.78,92.38 v2(227.89,93.49) 232.36,97.96 232.36,102.15 234.42,104.2 234.42,105.64 242.09,113.32 245.78,113.32 248.04,111.06 248.04,107.69 245.63,105.28 v1(245.39,105.28)
  BOTTOM w0.089: UV10.J5 v1(245.39,105.28)
  BOTTOM w0.102: UV1.F17 225.95,91.57 v1(225.51,92)
FBB_CMD26: length 33.7
  TOP w0.127: v1(244.58,104.47) 244.95,104.1 246.39,104.1 247.5,102.99 247.5,98.91 246.23,97.65 241.17,97.65 240.45,98.37 236.57,98.37 232.41,94.21 232.41,93.21 230.59,91.39 228.4,91.39 v8(228,90.99) v1(227.25,90.25)
  BOTTOM w0.089: UV1.D16 227.6,90.6 v1(227.25,90.25)
  BOTTOM w0.132: v1(244.58,104.47) 244.59,104.47 UV10.H4
FBB_CMD27: length 40.4
  BOTTOM w0.127: UV1.A18 230.63,92.3 230.79,92.46 231.14,92.46 232.02,93.35 232.02,93.77 235.85,97.59 v2(235.85,99.65) 235.85,103.59 238.21,105.95 239.91,105.95 241.4,107.44 241.4,110.76 242.75,112.11 247.23,112.11 247.36,111.98 247.36,104.81 246.63,104.08 UV10.H5
FBB_CMD28: length 31.6
  TOP w0.127: v1(244.59,102.88) 244.65,102.94 245.93,102.94 245.97,102.98 246.61,102.98 247.1,102.49 247.1,99.19 245.94,98.03 241.32,98.03 240.59,98.77 v8(237.93,98.77) 236.4,98.77 232.03,94.4 232.03,93.37 230.3,91.64 227.75,91.64 v1(227.22,91.1)
  BOTTOM w0.102: v1(227.22,91.1) 227.6,91.49 UV1.D17
  BOTTOM w0.132: UV10.G3 244.19,103.27 244.57,102.88 v1(244.59,102.88)
FBB_CMD29: length 38
  TOP w0.089: 241.71,104.38 242.87,104.38 v1(242.96,104.47)
  TOP w0.127: RV414.1 241.71,104.38
  BOTTOM w0.102: UV10.J2 243.37,104.88
  BOTTOM w0.127: v1(242.96,104.47) 242.94,104.5 242.94,105.01 242.69,105.25 238.82,105.25 236.97,103.4 236.97,102.57 237.1,102.44 v2(237.45,102.44) 239.05,102.44 239.18,102.32 239.18,102.06 239.05,101.93 237.1,101.93 236.97,101.81 236.97,101.55 237.1,101.43 239.05,101.43 239.18,101.3 239.18,101.05 239.05,100.92 237.1,100.92 236.97,100.79 236.97,100.54 237.1,100.41 239.05,100.41 239.18,100.28 239.18,100.03 239.05,99.9 237.1,99.9 236.97,99.78 236.97,96.36 232.31,91.7 231.68,91.7 231.52,91.54 230.04,91.54 UV1.A17
  BOTTOM w0.132: 243.37,104.88 v1(242.96,104.47)
FBB_CMD30: length 37.9
  TOP w0.089: v1(243.8,104.5) 243.38,104.92 v2(242.5,104.92) 241.79,104.92 241.71,104.83
  TOP w0.127: 241.71,104.83 240.96,104.83 240.45,104.32 RV409.1
  BOTTOM w0.127: v1(243.8,104.5) 243.83,104.47 243.83,103.84 243.62,103.64 242.39,103.64 242.16,103.41 241.58,103.41 240.64,102.47 240.64,101.7 239.56,100.62 239.56,99.52 239.43,99.39 237.48,99.39 237.36,99.27 237.36,99.01 237.48,98.89 239.43,98.89 239.56,98.76 239.56,98.51 239.43,98.38 237.48,98.38 237.36,98.25 237.36,98 237.48,97.87 239.43,97.87 239.56,97.74 239.56,97.49 239.43,97.36 237.48,97.36 237.36,97.24 237.36,96.2 232.47,91.32 231.84,91.32 231.65,91.13 229.8,91.13 229.44,91.5 UV1.B17
  BOTTOM w0.132: v1(243.8,104.5) 244.18,104.88 UV10.J3
FBB_CMD31: length 38.9
  TOP w0.127: v1(226.38,91.11) 227.16,91.89 229.34,91.89 v8(229.95,92.5) 230.43,92.98 230.43,94.79 233.12,97.48 233.12,100.09 233.93,100.9 234.11,100.9 234.59,100.42 234.77,100.42 234.95,100.6 234.95,100.78 234.47,101.26 234.47,101.44 234.65,101.62 234.83,101.62 235.31,101.14 235.49,101.14 235.67,101.32 235.67,101.49 235.19,101.98 235.19,102.16 235.37,102.34 235.55,102.34 236.03,101.85 236.21,101.85 236.39,102.03 236.39,102.21 235.91,102.7 235.91,102.88 236.09,103.06 236.27,103.06 236.75,102.57 236.93,102.57 237.11,102.75 237.11,102.93 236.63,103.41 236.63,103.59 236.81,103.77 236.99,103.77 237.47,103.29 237.65,103.29 237.83,103.47 237.83,103.65 237.35,104.13 237.35,104.31 237.53,104.49 237.71,104.49 238.19,104.01 238.37,104.01 238.55,104.19 238.55,104.37 238.07,104.85 238.07,105.03 238.25,105.21 238.42,105.21 238.91,104.73 239.09,104.73 239.27,104.91 239.27,105.09 238.78,105.57 238.78,105.75 239.11,106.08 v1(243.79,106.08)
  BOTTOM w0.102: UV1.E17 226.8,91.55 226.67,91.67 226.42,91.67 226.29,91.55 226.29,91.2 v1(226.38,91.11)
  BOTTOM w0.132: v1(243.79,106.08) UV10.L3
FBB_D0: length 26.7
  IN4 w0.089: 230.88,80.49 230.14,80.49 229.2,81.44 229.2,82.06 226.49,84.76 225.09,84.76 v1(224.63,85.22)
  IN4 w0.094: v1(234.54,79.22) 234.38,79.38 232.69,79.38 231.58,80.49 230.88,80.49
  BOTTOM w0.089: UV1.G9 225.05,84.8 v1(224.63,85.22)
  BOTTOM w0.127: UV9.A4 244.99,80.14 244.47,79.62 239.84,79.62 237.51,77.29 235.52,77.29 234.54,78.27 v1(234.54,79.22)
FBB_D1: length 22
  IN4 w0.089: v1(226.34,84.4) 226.51,84.4 228.76,82.15 228.76,81.34 229.96,80.15 230.88,80.15
  IN4 w0.094: v1(236.23,78.19) 235.86,78.57 233.01,78.57 231.43,80.15 230.88,80.15
  BOTTOM w0.089: UV1.E9 226.74,84.8 v1(226.34,84.4)
  BOTTOM w0.127: v1(236.23,78.19) 238.87,80.83 v2(239.36,80.83) 243,80.83 UV9.A2
FBB_D2: length 25.1
  IN4 w0.089: v1(225.51,84.36) 225.84,84.03 226.5,84.03 228.41,82.12 228.41,81.14 229.75,79.8 230.88,79.8
  IN4 w0.094: 230.88,79.8 231.29,79.8 232.92,78.16 v1(235.62,78.16)
  BOTTOM w0.089: UV1.G8 225.15,84 v1(225.51,84.36)
  BOTTOM w0.127: UV9.B4 244.59,80.85 244.59,80.36 244.23,80 239.41,80 v2(238.68,79.27) 237.1,77.68 236.1,77.68 v1(235.62,78.16)
FBB_D3: length 24.2
  IN4 w0.089: 230.88,81.37 230.61,81.37 227.29,84.69 227.12,84.69 226.73,85.08 226.73,85.5 226.55,85.68 225.79,85.68 225.63,85.52 v1(225.63,85.26)
  IN4 w0.094: 230.88,81.37 231.81,81.37 233.45,79.74 234.71,79.74 234.99,79.46 234.99,79.1 235.16,78.93 235.65,78.93 236.05,79.33 v1(236.08,79.33)
  BOTTOM w0.089: UV1.F9 225.95,84.94 v1(225.63,85.26)
  BOTTOM w0.127: UV9.B2 243,81.63 241.53,81.63 240.98,82.17 237.99,82.17 236.08,80.26 v1(236.08,79.33)
FBB_D4: length 25.3
  IN4 w0.089: v1(226.34,86.09) 226.65,86.41 227.29,86.41 227.7,86 ; v1(245.39,84.04) 244.98,83.64 244.98,83.08 244.74,82.84 243.29,82.84 243.05,83.08
  IN4 w0.094: 227.7,86 227.7,85.86 231.06,82.5 232.17,82.5 233.13,81.53 236.6,81.53 239.29,84.22 241.34,84.22 241.67,83.89 241.67,83.32 241.77,83.22 242.91,83.22 243.05,83.08
  BOTTOM w0.089: v1(245.39,84.04) UV9.E4 ; v1(226.34,86.09) 225.95,86.48 UV1.F11
FBB_D5: length 23.4
  IN4 w0.089: v1(242.99,84.04) 242.99,84.26 242.54,84.7 242.54,84.98 242.37,85.15 241.91,85.15 241.74,84.98 241.7,84.98 ; v1(225.52,86.13) 225.94,86.56 225.94,86.96 226.36,87.38 227.39,87.38 230.88,83.9
  IN4 w0.094: 230.88,83.9 231.49,83.29 232.36,83.29 233.36,82.29 236.29,82.29 238.98,84.98 241.7,84.98
  BOTTOM w0.089: v1(225.52,86.13) 225.15,86.5 UV1.G11 ; UV9.E2 v1(242.99,84.04)
FBB_D6: length 23.3
  IN4 w0.089: 241.7,84.57 241.74,84.57 241.96,84.35 242.44,84.35 242.61,84.18 242.61,83.88 242.84,83.65 244.19,83.65 v1(244.59,84.04) ; v1(226.36,86.84) 227.35,86.84 230.88,83.32
  IN4 w0.094: 241.7,84.57 239.15,84.57 236.46,81.88 233.28,81.88 232.22,82.94 231.25,82.94 230.88,83.32
  BOTTOM w0.089: v1(226.36,86.84) 225.95,87.25 UV1.F12 ; v1(244.59,84.04) UV9.F4
FBB_D7: length 24.6
  IN4 w0.089: v1(225.52,86.84) 225.52,87.13 226.1,87.71 227.57,87.71 230.88,84.41 ; v1(243.79,84.84) 243.41,85.22 243.41,86.02 243.29,86.14 241.7,86.14
  IN4 w0.094: 230.88,84.41 231.62,83.66 232.48,83.66 233.5,82.64 236.14,82.64 239.64,86.14 241.7,86.14
  BOTTOM w0.089: v1(243.79,84.84) UV9.F2 ; v1(225.52,86.84) 225.1,87.25 UV1.G12
FBB_D8: length 40.1
  IN1 w0.089: 223.25,76.59 223.25,81.19 224.34,82.28 224.83,82.28 225.25,82.7 v1(225.48,82.7)
  IN1 w0.094: 223.25,76.59 225.46,74.38 236.08,74.38 240.74,79.04 250.59,79.04 251.07,79.51 v1(251.07,80.02)
  BOTTOM w0.089: v1(225.48,82.7) 225.05,82.27 UV1.G6 ; UV9.A11 250.64,80.44 v1(251.07,80.02)
FBB_D9: length 39.7
  IN1 w0.089: v1(225.44,81.8) 224.38,81.8 223.61,81.03 223.61,77.68
  IN1 w0.094: 223.61,77.68 226.56,74.73 235.74,74.73 240.4,79.39 250.36,79.39 250.61,79.64 250.61,80.15 250.89,80.43 252.15,80.43 v1(252.55,80.84)
  BOTTOM w0.089: UV1.F5 225.84,81.4 v1(225.44,81.8) ; v1(252.55,80.84) 252.19,80.47 UV9.A13
FBB_D10: length 35.9
  IN1 w0.089: v1(226.38,81.8) 225.73,81.16 224.88,81.16 224.27,80.55 224.27,78.7
  IN1 w0.094: 224.27,78.7 224.27,78.19 227.03,75.42 234.98,75.42 240.36,80.81 242.23,80.81 242.71,80.32 245.55,80.32 246.05,80.83 v1(250.19,80.83)
  BOTTOM w0.089: v1(250.19,80.83) 250.59,81.22 UV9.B11 ; v1(226.38,81.8) 226.8,82.23 UV1.E6
FBB_D11: length 39
  IN1 w0.089: 223.91,77.96 223.91,80.88 224.47,81.44 225.59,81.44 225.87,81.72 225.87,82.24 226.25,82.62 v1(226.35,82.62)
  IN1 w0.094: v1(251.76,80.85) 250.79,80.85 250.38,80.45 250.15,80.45 249.49,79.79 240.03,79.79 235.32,75.08 226.8,75.08 223.91,77.96
  BOTTOM w0.089: v1(226.35,82.62) 225.98,82.25 UV1.F6 ; UV9.B13 252.16,81.24 v1(251.76,80.85)
FBB_D12: length 35.6
  IN1 w0.094: v1(226.3,80.22) 225.87,79.78 225.87,79 227.52,77.35 230.69,77.35 233.49,80.14 237.43,80.14 238.89,81.61 238.89,81.74 238.58,82.05 238.58,82.19 238.71,82.32 238.84,82.32 239.16,82.01 239.29,82.01 239.42,82.14 239.42,82.27 239.11,82.59 239.11,82.72 239.24,82.85 239.38,82.85 239.69,82.54 239.82,82.54 239.95,82.67 239.95,82.8 239.64,83.12 239.64,83.25 239.77,83.38 239.91,83.38 240.22,83.07 240.35,83.07 240.49,83.2 240.49,83.34 240.17,83.65 240.17,83.78 240.41,84.02 242.38,84.02 242.76,83.64 245.68,83.64 246.06,83.26 246.82,83.26 247.19,83.62 250.59,83.62 v1(250.98,83.24)
  BOTTOM w0.089: UV9.E11 250.59,83.63 v1(250.98,83.24) ; v1(226.3,80.22) 225.92,80.6 UV1.F4
FBB_D13: length 35.1
  IN1 w0.089: v1(225.49,80.21) 225.49,79.07
  IN1 w0.094: 225.49,79.07 227.51,77.05 231.8,77.05 232.69,77.93 232.69,78.06 232.42,78.33 232.42,78.47 232.55,78.6 232.68,78.6 232.95,78.33 233.09,78.33 233.22,78.46 233.22,78.6 232.95,78.87 232.95,79 233.08,79.13 233.21,79.13 233.48,78.86 233.62,78.86 233.75,78.99 233.75,79.13 233.48,79.4 233.48,79.53 233.61,79.66 233.75,79.66 234.02,79.39 234.15,79.39 234.49,79.73 237.51,79.73 240.87,83.09 241.64,83.09 241.77,83.22 242.33,83.22 242.72,82.84 251.42,82.84 v1(251.83,83.24)
  BOTTOM w0.089: v1(225.49,80.21) 225.1,80.6 UV1.G4 ; UV9.E13 252.19,83.6 v1(251.83,83.24)
FBB_D14: length 32.8
  IN1 w0.089: 227.82,78.19 227.39,78.62 v1(227.21,78.62)
  IN1 w0.094: 227.82,78.19 230.46,78.19 233.1,80.84 236.09,80.84 240.5,85.25 241.11,85.25 241.2,85.16 241.2,84.81 241.3,84.72 241.48,84.72 241.58,84.81 241.58,85.16 241.67,85.25 245.76,85.25 246.22,85.72 246.91,85.72 247.01,85.62 247.01,84.87 247.1,84.78 247.29,84.78 247.38,84.87 247.38,85.62 247.48,85.72 247.67,85.72 247.76,85.62 247.76,84.87 247.85,84.78 248.04,84.78 248.14,84.87 248.14,85.62 248.23,85.72 248.86,85.72 249.22,85.35 250.5,85.35 v1(250.99,84.87)
  BOTTOM w0.089: v1(227.21,78.62) 226.83,79 UV1.E2 ; UV9.F11 250.59,84.46 v1(250.99,84.87)
FBB_D15: length 34
  IN1 w0.089: v1(226.28,79.4) 226.28,79.04 227.56,77.76
  IN1 w0.094: 227.56,77.76 230.51,77.76 233.25,80.49 236.26,80.49 236.51,80.74 236.64,80.74 236.89,80.49 237.03,80.49 237.15,80.62 237.15,80.76 236.91,81 236.91,81.14 237.04,81.27 237.17,81.27 237.55,80.9 237.69,80.9 237.81,81.02 237.81,81.16 237.44,81.54 237.44,81.67 237.57,81.8 237.71,81.8 238.08,81.43 238.22,81.43 238.34,81.55 238.34,81.7 237.97,82.07 237.97,82.2 240.14,84.37 242.57,84.37 242.64,84.44 245.73,84.44 246.04,84.74 246.53,84.74 246.82,84.45 251.36,84.45 v1(251.79,84.88)
  BOTTOM w0.089: v1(251.79,84.88) 252.19,84.48 UV9.F13
  BOTTOM w0.102: UV1.F3 225.9,79.78 v1(226.28,79.4)
FBB_D16: length 36.5
  IN1 w0.089: 230.88,88.18 230.74,88.18 230.73,88.18 230.09,88.18 228.38,86.47 228.38,83.42 227.75,82.79 227.75,80.63 227.6,80.48 227.6,79.3 227.83,79.07 228.41,79.07 v1(228.85,78.62)
  IN1 w0.094: 230.88,88.18 234.34,88.18 237.79,91.63 239.07,91.63 241.89,94.46 247.8,94.46 248.59,93.67 v1(251.01,93.67)
  BOTTOM w0.089: UV1.C2 228.47,79 v1(228.85,78.62)
  BOTTOM w0.102: v1(251.01,93.67) 250.59,93.25 UV9.U11
FBB_D17: length 34.4
  IN1 w0.089: 230.88,87.83 230.19,87.83 228.59,86.23 228.59,83.33 227.96,82.71 v1(227.96,80.21)
  IN1 w0.094: 230.88,87.83 234.48,87.83 237.94,91.29 239.21,91.29 242.03,94.11 247.46,94.11 248.33,93.24 251.39,93.24 v1(251.79,92.85)
  BOTTOM w0.089: v1(227.96,80.21) 227.6,80.57 UV1.D4
  BOTTOM w0.102: v1(251.79,92.85) UV9.U13
