# Allegro board LA9941PR10-0905b.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.05VSDGPU: length 51.4
  TOP w0.508: LV21.1 233.24,110.49 CV3512.1 233.16,111.87 232.55,112.48 v1(230.08,112.48) ; v1(212.22,78.56) 212.22,78.6 213.23,79.62 LV14.2
  GND1 w0.254: v7(208.67,90.22) 208.67,90.17 v4(208.3,89.8) ; v3(208.7,95.22) 208.7,95.2 v4(208.3,94.8) ; v4(208.3,92.3) v7(208.72,92.72) ; v3(207.9,95.22) 207.9,95.2 v4(207.5,94.8) ; v4(207.5,92.3) v7(207.92,92.72) ; v7(207.87,90.22) 207.87,90.17 v4(207.5,89.8)
  IN1 w0.508: v4(217.93,103.77) 216.72,103.77 216.03,104.47 212.98,104.47 211.06,102.55
  IN2 w0.508: v1(204.28,74.05) 206.03,74.05 207.07,75.09 208.75,75.09 v1(212.22,78.56)
  IN3 w0.508: v1(230.08,112.48) 229.37,113.19 225.89,113.19 223.2,110.5 221.17,110.5 217.93,107.26 v4(217.93,103.77)
  GND3 w0.102: v7(207.92,92.72) v4(207.5,92.3) ; v4(207.5,94.8) 207.5,94.82 v7(207.9,95.22) ; v4(208.3,92.3) v7(208.72,92.72) ; v4(208.3,94.8) 208.3,94.82 v7(208.7,95.22) ; v7(208.67,90.22) 208.67,90.17 v4(208.3,89.8) ; v7(207.87,90.22) 207.87,90.18 v4(207.5,89.8)
  BOTTOM w0.254: UV1.AN28 UV1.AM28
  vias: v1(200.09,82.71) v1(200.06,82.13) v1(200.72,82.71) v1(200.7,82.13) v1(201.33,82.13) v1(201.36,82.71) v1(201.99,82.71) v1(201.97,82.13) v1(202.37,74.05) v1(202.37,72.97) v1(203.01,74.05) v1(203.01,72.97) v1(203.64,74.05) v1(203.64,72.97) v1(204.28,72.97) v1(206.31,101.12) v1(207.14,100.21) v1(207.08,98.57) v1(207.9,98.57) v1(207.9,97.72) v1(208.73,97.72) v1(208.98,97.16) v1(208.96,92.27) v1(209.02,89.79) v1(209.1,95.64) v1(209.08,94.67) v1(209.16,90.61) v1(209.36,88.65) v1(209.55,92.27) v1(209.61,97.16) v1(209.68,89.8) v8(202.68,75.01)
+1.35V: length 70.7
  BOTTOM w0.356: v1(208.3,24.57) JDIMM2.76 ; JDIMM1.82 135.6,25 135.37,24.77 ; JDIMM1.117 146.1,33.35 145.62,32.86 144.57,32.86 v1(144.51,32.92) 144.3,33.13 JDIMM1.111 ; 142.49,24.77 142.8,25.08 JDIMM1.106 ; 139.51,24.79 139.2,25.1 JDIMM1.94 ; v1(218.44,32.84) 218.8,33.2 JDIMM2.111 ; v1(140.55,32.9) 140.7,33.05 JDIMM1.99 ; v1(133.57,32.73) 133.5,32.8 JDIMM1.75 ; v1(208.59,32.87) 208.36,32.87 208,33.23 JDIMM2.75 208,35.42 208.41,35.82 209.48,35.82 209.8,35.51 JDIMM2.81 ; JDIMM2.117 220.6,33.26 v1(220.17,32.83) ; JDIMM2.123 222.4,33.22 222.02,32.83 v1(221.69,32.83) ; JDIMM2.106 v1(217.3,24.57) ; 141.29,24.78 141,25.07 JDIMM1.100 ; JDIMM2.82 210.1,24.7 v1(209.97,24.57) ; JDIMM1.76 133.8,25.08 134.11,24.77 134.58,24.77 ; JDIMM1.105 142.5,33.32 142.12,32.94 v1(142.12,32.88) ; v1(135.56,32.77) 135.3,33.03 JDIMM1.81 ; JDIMM1.88 137.39,26.09 137.39,25.16 136.96,24.72 ; v1(137.54,32.27) 137.1,32.71 JDIMM1.87 ; JDIMM1.118 146.4,24.74 ; v1(213.99,24.58) 213.7,24.87 JDIMM2.94 ; v1(146.96,32.06) 147.11,32.06 147.9,32.85 JDIMM1.123 ; 147.95,24.74 147.95,24.77 148.2,25.02 JDIMM1.124 ; JDIMM1.93 138.9,33.13 139.19,32.84 v1(139.51,32.84) ; JDIMM1.112 144.6,24.75 ; JDIMM2.93 213.4,33.32 v1(213,32.93) 212.93,32.85 211.8,32.85 211.6,33.05 JDIMM2.87 ; v1(211.9,24.57) JDIMM2.88 ; JDIMM2.105 v1(217,32.82) ; JDIMM2.100 v1(215.5,24.57) ; 144.57,24.75 144.52,24.7 ; JDIMM2.118 v1(220.9,24.52) ; JDIMM2.112 v1(219.1,24.52) ; JDIMM2.124 v1(222.7,24.68)
  BOTTOM w0.381: JDIMM2.99 v1(215.2,32.82)
  BOTTOM w0.508: RU72.1 144.71,57.48 v1(144.91,57.28)
  vias: v1(138.97,22.72) v1(143.04,22.94) v1(164.25,68.05) v1(164.25,67.47) v1(164.25,66.89) v1(164.25,66.3) v8(136.33,24.95)
+1.35V_CPU_VDDQ: length 66.1
  TOP w0.508: 176.89,70.37 177.44,69.82 180.36,69.82 185,74.46 185,78.55 185.74,79.29 RU83.1
  IN3 w0.508: 152.39,75.86 152.39,72.94 151.35,71.89 149.52,71.89 148.48,70.85 147.46,70.85 144.18,74.13 138.12,74.13 v1(136.05,72.07) ; 153.23,77.03 154.3,78.1 154.3,79.64 154.7,80.03 v1(155.24,80.03)
  BOTTOM w0.254: v1(159,79.28) 158.68,78.96 U6.AW33 ; v1(159,80.78) 159.28,81.06 U6.AT32 159.48,81.58 159.49,81.59 ; U6.BE18 168.14,74.76 v1(167.85,75.04) ; U6.BD22 165.9,75.38 165.9,74.83 U6.BE22 165.76,74.76 v1(165.41,74.41) ; U6.BB27 U6.BB26 163.44,76.86 v1(163.79,76.51) ; 159.49,81.59 159.07,81.59 U6.AR33 ; 159.49,81.59 160.06,81.59 U6.AR31 ; v1(167.83,81.59) 167.94,81.47 U6.AT19 ; U6.AW22 166.26,79.15 v1(166.54,79.15) ; U6.BB34 157.49,76.65 157.08,76.65 U6.BB36 156.7,76.86 v1(156.21,77.35) ; U6.BE30 160.89,74.76 v1(160.54,75.11) 160.89,75.46 U6.BD30 ; U6.AT27 v1(162.3,81.61) 161.81,81.61 U6.AR29 ; U6.AT23 165.1,81.08 v1(165.1,81.61) ; U6.AT36 156.29,80.69 v1(156.18,80.69) ; U6.BB21 U6.BB22 165.76,76.86 v1(165.41,76.51) ; U6.AY18 169.02,78.26 v1(169.34,78.58) ; U6.AV37 155.62,79.66 v1(155.24,80.03) ; U6.BB31 160.19,76.86 v1(160.54,76.51) 160.89,76.86 U6.BB30 ; U6.AW29 161.5,78.96 v1(161.82,79.28) ; U6.BD33 158.45,75.46 v1(158.1,75.11) 158.45,74.76 U6.BE33 ; v1(172.12,81.49) 171.7,81.08 U6.AT13 171.79,81.06 v1(172.16,80.68) ; U6.BD26 163.33,75.46 v1(162.98,75.11) 163.33,74.76 U6.BE26 ; v1(164.64,79.28) 164.32,78.96 U6.AW25
  BOTTOM w0.508: RU60.1 135.61,71.63 v1(136.05,72.07)
  vias: v1(172.75,70.42) v8(155.97,70.44)
+1.35V_MEN_P: length 30.4
  TOP w0.203: PU400.5 124.33,19.98 124.06,20.25 v2(123.79,20.25) v3(123,20.25)
  TOP w0.508: v3(123,20.25) 122.46,20.78 PR405.2 PC412.2
  GND1 w0.508: v3(123,20.25) 123,19.69 v4(123.12,19.57)
  IN1 w0.508: v1(127.7,19.7) 130,19.7 131.3,20.99 139.13,20.99 142.25,17.87 142.25,14.54 v1(142.86,13.93)
  IN2 w0.508: v1(127.7,19.7) 123.26,19.7 v4(123.12,19.57)
  vias: v9(138.33,11.89) v9(138.33,11.26) v9(138.96,11.89) v9(138.96,11.26) v9(139.6,11.89) v9(139.6,11.26) v9(140.23,11.89) v9(140.23,11.26) v9(140.87,11.89) v9(140.87,11.26) v9(141.34,14.33) v9(141.34,13.7) v9(141.34,13) v9(141.54,11.9) v9(141.52,11.26)
+1.35V_PWROK: length 59.4
  TOP w0.102: v1(130.39,61.22) 130.39,61.32 131.23,62.16 v8(131.23,62.24)
  TOP w0.203: v1(122.16,15.32) 122.41,15.32 122.74,15.65 122.74,16.14 123.24,16.64 PU400.10
  IN1 w0.508: v1(130.39,61.22) 130.39,46.9 128.65,45.16 128.65,35.12 127.63,34.11 127.63,25.18 122.13,19.68 122.13,15.35 v1(122.16,15.32)
  BOTTOM w0.508: v1(130.39,61.22) 131.92,62.75 RU53.1
+2.5V_5505LDO_S: length 5.8
  TOP w0.254: U12.43 19.17,21.74
  TOP w0.508: CA67.1 RA62.2 18.93,18.69 19.35,19.11 CA77.1 CA79.1 v2(19.35,21.24) 19.35,21.56 19.17,21.74
+3.3V_RUN_VDD33:
  vias: v1(221.3,83.51) v1(222.12,83.45) v2(220.08,83.65)
+3V_MSATA: length 17.7
  TOP w0.508: v1(280.54,15.31) 280.22,14.99 CM12.1 281.1,14.63 CM13.1
  IN1 w0.508: v1(280.54,15.31) 280.85,15 JSSD.2
  IN2 w0.61: JSSD.24 281.75,27 281.68,26.93
  IN2 w1.016: 281.68,15.12 281.68,26.93
  vias: v1(280.63,34.03) v1(280.63,33.45) v1(281.37,39.7) v1(281.95,39.7) v8(281.62,38.97)
+3V_NFC: length 18
  BOTTOM w0.305: RN8.1 118.93,22.36 118.49,22.8 116.9,22.8 115.86,21.76 v8(115.86,21.12) 115.8,21.05 JNFC1.15 115.8,18 116.5,17.3 117.43,17.3 118.81,15.91 120.21,15.91 121.85,17.56 121.85,18.35
  BOTTOM w0.508: RN5.2 C1135.1
+3V_PCH: length 248.7
  TOP w0.102: v1(123.25,24.77) 123.1,24.77 v8(122.29,23.96)
  TOP w0.254: RPH14.8 252.27,16.02 252.17,15.92 v1(251.76,15.92) 251.77,15.93 RPH14.7
  TOP w0.457: v1(263.28,34.08) 263.28,34.42 CH61.1
  TOP w0.508: v1(275.8,33.39) 275.78,33.39 275.78,33.35 275.34,32.91 CH93.1 275.38,32.81 RH23.1
  GND1 w0.508: v4(271.68,15.54) 271.75,15.47 v3(271.75,15.04) ; v4(265.73,16.37) 265.73,16.37 265.82,16.28 v7(265.82,15.82)
  IN1 w0.508: v4(251.76,12.86) v1(251.76,15.92)
  IN2 w0.508: v1(263.28,34.08) 265.27,34.08 266.04,33.32 266.04,32.99 266.57,32.46 266.63,32.46 268.6,30.49 v1(268.6,30.02) 269.3,30.02 270.47,31.18 273.55,31.18 275.77,33.4 275.78,33.4 275.78,33.39 v1(275.8,33.39) ; v4(251.76,12.86) 251.76,10.64 252.74,9.66 271.98,9.66 272.38,10.06 272.38,10.8 272.77,11.2 v1(273.01,11.2)
  IN3 w0.508: v1(123.25,24.77) 123.25,25.18 125.31,27.24 125.31,30.04 126.42,31.14 137.8,31.14 138.8,32.14 145.73,32.14 146.11,31.76 146.11,28.05 146.58,27.59 147.72,27.59 148.15,28.01 148.15,31.43 148.85,32.14 164.69,32.14 165.48,31.34 168.89,31.34 176.17,24.06 176.84,24.06 179.36,21.53 182.94,21.53 184,20.48 186.34,20.48 186.86,21 189.48,21 195.08,15.4 197.55,15.4 198.21,14.74 202.41,14.74 204.01,16.34 205.07,16.34 205.34,16.07 206.94,16.07 207.55,15.45 208.97,15.45 209.62,14.8 211.99,14.8 214.43,17.25 221.15,17.25 221.87,16.53 225.42,16.53 v1(225.78,16.17) 226.08,15.87 233.74,15.87 234.25,15.36 236.42,15.36 236.83,15.77 240.74,15.77 241.31,15.2 v1(242.59,15.2) 244.58,15.2 245.53,14.24 250.39,14.24 251.78,12.86 v4(251.76,12.86)
  IN4 w0.508: v1(275.8,33.39) 275.78,33.39 275.78,33.41 275.8,33.4 275.83,33.4 275.86,33.42 277.67,33.42 278.95,32.14 v4(279.27,32.14) 279.56,31.85 280.95,31.85 281.99,30.81 281.99,25.33 281.64,24.98 281.64,15.52 280.47,14.35 v1(278.87,14.35) 278.68,14.35 275.53,11.2 v1(273.65,11.2)
  GND3 w0.508: v4(279.27,32.14) 279.16,32.02 v7(279.16,31.5) ; v7(265.82,15.82) 265.82,16.28 265.73,16.37 v4(265.73,16.37) ; v7(251.09,12.97) 251.73,12.97 251.76,12.94 v4(251.76,12.86) ; v7(271.05,15.54) v4(271.68,15.54)
  BOTTOM w0.203: U7.AJ32 263.65,34.45 v1(263.28,34.08) 263.65,33.71 U7.AJ30 ; U7.R20 268.93,29.68 v1(268.6,30.02) 268.93,30.35 U7.R22
  BOTTOM w0.254: U7.A26 275.45,32.52 275.45,32.81 275.49,32.85 275.49,33.05 275.78,33.35 275.78,33.39 v1(275.8,33.39)
  BOTTOM w0.508: RN5.1 124.27,22.49 123.25,23.5 v1(123.25,24.77) ; RH40.1 v7(251.09,12.97) ; v1(251.76,15.92) 251.79,15.92 251.79,15.82 251.67,15.7 RH33.1
  vias: v1(275.8,30.2)
+3V_PCH_APL:
  vias: v2(225.61,13.55)
+3V_PS8723: length 27.5
  TOP w0.203: UI5.9 30.2,62.75 v1(30.33,62.88) ; UI5.25 v1(25.41,60.35)
  TOP w0.508: RI463.2 RI462.2 27.98,55.06 v1(28.33,54.7) 29.42,54.7 29.88,55.16 RI461.2 RI460.2 ; RI464.2 RI465.2 RI467.2 RI466.2 26.6,68.54 v2(26.91,68.84) 27.09,69.02 v1(27.55,69.02) ; v1(23.56,60.21) 23.27,60.5 RI468.2
  IN2 w0.508: v1(25.41,60.35) 25.41,59.61 28.33,56.68 v1(28.33,54.7)
  BOTTOM w0.508: v1(25.41,60.35) 23.7,60.35 v1(23.56,60.21) ; RI74.2 27.76,65.93 26.73,66.96 26.73,68.43 27.33,69.02 v1(27.55,69.02)
+3V_THERMAL: length 428.8
  TOP w0.102: v1(134.03,118.16) v8(134.03,118.85)
  TOP w0.508: v1(97.66,45.35) 97.66,44.84 CT22.2 96.77,43.95 U4.5 ; RT1.2 v1(193.08,80.91)
  IN1 w0.508: v1(117.89,123.14) 119.28,121.75 131.9,121.75 134.03,119.62 v1(134.03,118.16) 134.03,117.27 133.26,116.51 133.26,114.76 129.09,110.6 129.09,102.59 125.91,99.41 125.91,71.4 123.46,68.94 123.46,66.63 117.42,60.6 113.61,60.6 105.92,52.9 v1(104.66,52.9) 97.66,45.9 v1(97.66,45.35)
  IN2 w0.508: v1(193.08,80.91) 193.08,80.36 201.08,72.36 207.6,72.36 209.89,74.64 218.69,74.64 219.39,75.34 221.25,75.34 221.66,74.92 222.65,74.92 223.66,75.93 226.33,75.93 227.09,75.17 231.17,75.17 233,73.34 235.76,73.34 237.09,74.66 247.27,74.66 247.9,75.29 247.9,92.18 250.08,94.37 251.27,94.37 254.91,98.01 254.91,103.7 254.07,104.54 254.07,112.06 253.44,112.69 252.07,112.69 252.06,112.68 250.46,112.68 247.18,115.96 247.18,121.68 v1(249.21,123.71) 248.45,124.48 242.63,124.48 238.88,128.23 227.12,128.23 226.5,127.6 222.01,127.6 221.39,128.23 215.38,128.23 214.58,127.43 206,127.43 205.2,128.23 195.44,128.23 194.5,127.29 193.33,127.29 192.59,128.03 v1(189.14,128.03) ; v1(190.16,90.94) 190.16,90.44 189.59,89.87 184.76,89.87 179.81,94.82 179.81,103 178.55,104.25 177.76,104.25 174.66,107.36 145.26,107.36 142.61,110.02 139.08,110.02 138.08,111.01 138.08,114.5 136.89,115.68 135.7,115.68 134.03,117.36 v1(134.03,118.16)
  IN3 w0.508: v1(190.16,90.94) 190.16,90.28 189.55,89.67 189.55,88.51 193.08,84.98 v1(193.08,80.91)
  BOTTOM w0.508: v1(249.21,123.71) 249.77,123.15 RT4.2 ; RT5.2 105.78,54.44 104.66,53.33 v1(104.66,52.9) ; v1(117.89,123.14) 117.83,123.2 RT2.2 ; v1(193.08,80.91) 197.21,76.78 197.21,70.69 198.44,69.46 198.44,64.84 200.29,62.99 200.29,61.32 199.24,60.27 193.78,60.27 190.64,63.41 RT3.2 ; RT6.2 v1(189.14,128.03)
+3V_VCCPSPI: length 12.7
  TOP w0.457: v1(265.01,26.28) 265.46,26.28 CH54.1
  TOP w0.508: v3(263.83,17.85) 263.82,17.84 v2(263.82,16.59) 263.82,16.01
  GND1 w0.508: v5(264.11,18.51) 264.11,18.13 v3(263.83,17.85)
  IN1 w0.254: v1(265.01,26.28) 265.21,26.28 265.59,25.89 265.59,23.73 265.22,23.36 265.22,21.64 264.11,20.53 v5(264.11,18.51)
  BOTTOM w0.254: v1(265.01,26.28) 265.31,26.57 U7.AD12
+3VALW: length 385.8
  TOP w0.254: RPH4.2 v3(278.4,15.79) ; RPH7.3 v3(271.06,9.66) ; v3(278.01,17.28) 278.01,17.03 277.77,16.79 RPH4.4
  TOP w0.457: 272.12,20.71 272.98,20.71 273.11,20.58 273.82,20.58 275.32,22.08 v1(275.75,22.08)
  TOP w0.508: 142.77,83.88 140.7,83.88 136.73,79.91 136.73,67.98 135.28,66.53 v1(132.1,66.53) 130.57,66.53 v1(129.91,65.87) ; v1(143.7,22.85) 144.42,22.13 145.16,22.13 RE64.1 RE33.2 ; v1(170.75,24.77) 170.75,24.77 170.74,24.76 170.74,23.87 170.31,23.44 RE60.1 ; PR282.1 111.52,15.25 PR110.1 111.5,15.59 v1(111.86,15.95) ; CH55.1 276.22,28.41 276.82,28.41 v1(276.94,28.53) 277.89,27.57 v3(279.25,27.57) ; U5.2 7.87,83.7 8.53,84.35 R28.1 9.15,84.35 C17.1 10.44,84.35 10.91,84.82 10.91,86.32 11.72,87.13 v1(12.43,87.13) ; 272.12,20.71 271.78,20.37 CH71.1 ; RH121.1 279.79,22.25 280.22,21.82 v1(280.72,21.82) ; v1(223.89,15.78) 224.39,15.78 v8(225.8,17.19) 226.43,17.81 226.43,20.47 v8(227.78,21.82) 230.13,24.17 231.69,24.17 232.18,24.66 232.18,29.94 232.47,30.23 232.47,45.98 229.8,48.65 213.87,48.65 209.92,52.6 v8(209.92,58.12) 209.92,60.07 210.42,60.57 RZ3.1 212.41,59.68 RZ12.1 ; RI32.1 v1(23.06,81.43)
  GND1 w0.508: v3(279.25,27.57) 279.27,27.55 v5(279.27,26.68) ; v3(271.06,9.66) 271.16,9.66 271.45,9.95 v4(271.45,10.29) ; v3(278.4,15.79) v5(278.4,15.4) ; v3(278.01,17.28) 278.32,16.98 v5(278.4,16.98) ; v3(276.35,9.91) v4(276.35,10.77)
  IN1 w0.508: 131,26.55 133.91,23.63 143.41,23.63 143.7,23.35 v1(143.7,22.85) ; 131,26.55 129.87,26.55 123.73,20.42 123.73,19.31 122.9,18.47 122.9,15.1 122.1,14.3 117.16,14.3 116.42,15.03 112.77,15.03 v1(111.86,15.95) ; 131,26.55 131,62.57 129.91,63.66 v1(129.91,65.87) ; v5(279.27,26.68) 279.27,25.91 278.89,25.53 278.89,22.96 280.15,21.7 280.61,21.7 v1(280.72,21.82) 280.72,19.3 v5(278.4,16.98) v5(278.4,15.4) 278.01,15.02 278.01,13.4 276.35,11.73 v4(276.35,10.77)
  IN2 w0.508: v1(12.43,87.13) 15.28,87.13 20.97,81.43 v1(23.06,81.43)
  IN3 w0.508: v1(170.75,24.77) 170.75,25.08 170.37,25.46 160.69,25.46 159.14,23.9 153.65,23.9 153.44,24.11 144.61,24.11 143.7,23.2 v1(143.7,22.85) ; 261.28,9.94 271.09,9.94 v4(271.45,10.29) 271.92,10.76 271.92,11.29 272.48,11.84 275.27,11.84 v4(276.35,10.77) ; v1(23.06,81.43) 22.15,81.43 20.99,80.27 20.99,75.35 22.03,74.32 22.03,69.56 24.76,66.83 24.76,64.01 24.37,63.62
  IN4 w0.508: v1(46.14,38.98) 45.34,38.98 40.6,43.73 36.11,43.73 35.42,43.04 35.42,41.79
  BOTTOM w0.254: v1(276.94,28.53) 275.97,28.53 275.57,28.12 U7.A16 ; U7.K8 271.38,24.4 271.53,24.4 v1(271.54,24.39)
  BOTTOM w0.406: UU3.5 133.53,67.13 132.93,66.53 v1(132.1,66.53)
  BOTTOM w0.508: R29.1 130.49,65.04 129.91,65.62 v1(129.91,65.87) 129.9,65.88 RU76.1 ; PR102.1 47.19,39.33 46.84,38.98 v1(46.14,38.98) 45.98,38.82 PR292.1 ; v1(170.75,24.77) 170.75,24.77 170.74,24.76 170.74,24.44 170.13,23.84 169.72,23.84 RE52.1 RE61.2 ; v1(20.59,52.15) RI17.1 ; v1(280.72,21.82) 280.03,21.13 277.09,21.13 276.13,22.08 v1(275.75,22.08)
  BOTTOM w1.524: 211.01,11.77 211.01,14.33 213.68,17 217.21,17 217.64,16.57 ; 164.55,11.54 185.46,11.54 186.79,12.87 188.95,12.87 190.31,11.51 193.94,11.51
  vias: v1(21.63,53.17) v1(22.24,53.17) v1(24.04,62.66) v1(24.73,62.66) v1(24.8,63.25) v1(34.02,41.94) v1(34.15,41.36) v1(34.63,41.94) v1(34.73,41.36) v1(147,12.46) v1(147,11.82) v1(147,11.23) v1(220.74,15.91) v1(221.19,15.48) v1(221.63,15.02) v1(259.87,10.45) v1(260.45,10.45) v4(153.94,12.59) v4(153.94,11.82) v4(153.96,11.11) v4(248.6,12.87) v4(249.19,12.87) v4(249.75,12.88) v7(154.98,12.59) v7(154.98,11.82) v7(154.98,11.19) v9(32.8,27.32) v9(32.8,26.56) v9(33.44,27.32) v9(33.44,26.56) v9(34.07,27.32) v9(34.07,26.56) v9(34.71,27.32) v9(34.71,26.56) v9(35.34,27.32) v9(35.34,26.56)
+3VALW_EC: length 120.4
  TOP w0.152: v1(166.01,15.57) 166.01,15.77 165.82,15.96 165.82,16.12 UE1.J4
  TOP w0.203: UE1.M12 166.84,19.72 v1(166.83,19.72) 166.59,19.72 166.28,20.02 UE1.K12 ; v1(165.25,17.58) 165.32,17.66 UE1.J7 UE1.K7
  TOP w0.254: RPE2.3 176.78,16.83 177.19,17.25 v1(177.19,17.93) 176.59,17.33 RPE2.4 ; UE36.24 147.93,15.95 147.88,15.9 v1(147.86,15.9)
  TOP w0.508: LE1.1 156.6,23.83 v1(157.54,24.77) 158.88,23.43 RE9.1 ; RE11.1 166.81,25.15 166.37,25.6 163.7,25.6 v1(162.84,24.73) ; RE66.1 146.37,12.89 147.63,14.15 147.63,14.17 147.86,14.4 v1(147.86,15.9) ; RE55.1 RE71.1 RE69.1 RE72.1 194.83,17.64 v1(194.69,17.77) ; v1(110.64,19.12) 110.26,18.74 v8(107.25,18.74) 104.9,18.74 103.54,20.1 PR114.2
  IN1 w0.508: v1(194.69,17.77) 193.73,18.74 181.21,18.74 180.41,17.93 v1(177.19,17.93) 176.28,17.93 175.64,18.57 173.93,18.57 173.54,18.95 167.85,18.95 167.51,18.61
  IN3 w0.508: 147.74,16.78 147.3,16.34 146.74,16.34 146.3,16.78 144.77,16.78 144.49,16.5 143.25,16.5 140.46,19.29 128.46,19.29 128.06,18.88 127.34,18.88 126.76,19.46 124.36,19.46 123.65,18.75 121.72,18.75 121.63,18.85 116.68,18.85 116.41,19.12 v1(110.64,19.12)
  BOTTOM w0.508: 163.26,23.88 158.43,23.88 v1(157.54,24.77) ; v1(147.86,15.9) 148.02,16.06 CE15.1 148.17,16.7 148.72,17.24 148.72,19.12 147.76,20.07 RE74.2
  vias: v1(156.02,17.1)
+3VALWP: length 24.4
  TOP w0.254: 35.12,20.99 35.12,23.86 v2(36.62,25.36) 39.44,28.18 40.53,28.18 41.94,29.59 41.94,34.57 43.96,36.58 46.69,36.58 PR300.1 PC301.1
  vias: v9(31.46,21.22) v9(31.46,20.54) v9(31.46,19.9) v9(31.46,19.27) v9(31.46,18.63) v9(32.09,21.22) v9(32.09,20.54) v9(32.09,19.9) v9(32.09,19.27) v9(32.09,18.63)
+3VLP: length 307.3
  TOP w0.203: UE1.J6 165.53,17.16 v3(165.4,17.03)
  TOP w0.508: RE48.1 176.14,14.42 176.18,14.38 176.18,14.2 177.05,13.33 RE47.1 177.04,13.14 RE49.1 178.99,12.15 179.65,11.49 RE59.1 180.71,10.8 185.18,10.8 RE50.1 ; RE48.1 176.13,14.98 176.4,15.25 178.43,15.25 178.73,15.54 178.73,21.47 179.93,22.68 181.91,22.68 v1(182.62,23.39) ; RE48.1 175.62,14.42 v1(175.5,14.54) ; RTCD1.3 255.04,58.15 254.66,57.77 v1(254.66,57.45) ; PR335.1 50.46,37.51 50.93,37.98 57.28,37.98 v8(59.36,35.89) 60.22,35.03 60.22,32.68 62.76,30.14 v1(62.76,28.33) ; RE56.1 169.67,24.33 v1(170.11,24.77) ; v1(172.27,14.55) 171.83,14.1 RE32.2 ; v1(110.06,16.89) 110.06,17.36 111.76,19.06 111.76,20.77 v1(113.66,22.68)
  GND1 w0.203: v3(165.4,17.03) v5(165.99,17.03)
  IN1 w0.508: v1(118.81,31.31) 118.81,30.87 119.89,29.79 119.89,24.75 118.07,22.93 117.41,22.93 116.14,21.66 114.68,21.66 v1(113.66,22.68)
  IN2 w0.508: 139.48,31.04 138.47,31.04 138.11,31.4 135.44,31.4 135.24,31.2 132.37,31.2 131.74,31.83 123.25,31.83 122.73,31.31 v1(118.81,31.31) ; v1(254.66,57.45) 254.66,56.61 254.13,56.08 252.66,56.08 251.29,57.46 v1(232.61,57.46) ; v1(182.62,23.39) 181.75,24.26 178.17,24.26 177.1,23.19 170.91,23.19 170.11,23.99 v1(170.11,24.77) 168.33,26.56 168.33,30.54 167.45,31.42 149.23,31.42 148.16,30.35 148.16,28.35 147.3,27.48 146.27,27.48 145.8,27.95 145.8,30.54 145.06,31.28 144.41,31.28
  IN3 w0.508: v1(223.01,58.62) 231.44,58.62 v1(232.61,57.46)
  IN4 w0.508: v1(62.76,28.33) 63.37,27.72 64.03,27.72 64.81,28.49 66.57,28.49 68.09,26.97 70.15,26.97 70.5,27.32 71.84,27.32 73.32,25.84 75.52,25.84 79.56,21.81 104.44,21.81 109.37,16.89 v1(110.06,16.89) ; v1(182.62,23.39) 182.62,23.06 182.88,22.8 186.37,22.8 187.09,23.53 187.09,31.29 186.35,32.04 186.35,38.74 188.21,40.61 206.56,40.61 223.01,57.06 v1(223.01,58.62)
  BOTTOM w0.508: v1(172.07,18.28) 171.51,17.72 171.51,15.25 172.22,14.55 v1(172.27,14.55) 172.27,14.88 172.64,15.25 175.13,15.25 175.54,14.85 175.54,14.58 v1(175.5,14.54)
+3VS: length 418.7
  TOP w0.203: v1(29.12,43.71) 29,43.59 U15.11 ; v1(21.57,45.54) 22.01,45.99 22.58,45.99 23.15,45.41 U15.23 ; CV745.1 25.34,98.1 25.34,98.42 26.21,99.3 U22.37 ; v1(28.98,41.84) 28.83,41.99 U15.7 ; U22.11 32.59,98.1 v1(33.02,97.67)
  TOP w0.254: U12.42 18.67,21.15 v1(18.74,21.09) ; RPH9.3 268.75,13.17 v3(269.05,13.47) 268.84,13.67 RPH9.4 ; v1(208.27,18.3) 208.27,18.02 207.89,17.64 C5.1 ; 24.01,27.24 24.01,27.23 U12.9 ; RPH19.1 155.97,18.54 155.97,18.28 156.21,18.04 RPH19.2 ; v1(20.17,30.42) U12.16 ; UN2.1 225.12,64 v1(224.98,64.14) 224.98,65.1 225.74,65.86 227.71,65.86 227.96,65.61 UN2.14 ; v1(21.17,30.36) U12.14
  TOP w0.305: UN2.7 227.46,60.52 ; 227.96,60.52 227.96,60.53 UN2.8
  TOP w0.381: QH2.2 QH2.5 248.6,20.01 248.85,20.26 ; C3.1 198.69,13.85 199.12,14.28 U1.10 ; 248.17,9.47 247.92,9.23 244.59,9.23 243.98,9.84 243.98,10.83 243.67,11.13 240.7,11.13 ; 249,10.31 249,12.96 249.82,13.77 CM31.1 ; U1.19 207.55,14.28 C4.1 ; 240.7,11.13 240.69,11.14 240.69,14.04 241.22,14.58 241.22,15.34 243.15,17.26 243.15,23.41 v1(241.85,24.71) ; 240.7,11.13 239.81,11.13 239.6,11.35 UH3.5 ; C1.1 198.23,17.53 U1.5 ; U1.24 207.8,17.53 C5.1
  TOP w0.457: CH73.1 265.01,27.03 264.64,27.41 v1(264.64,27.58)
  TOP w0.508: v1(208.27,18.3) 208.27,18.85 208.42,19.01 R72.1 208.42,19.53 C6.1 208.42,20.63 207.52,21.53 v1(207.52,21.79) 207.52,22.82 206.93,23.4 205.36,23.4 203.8,21.84 199.36,21.84 198.2,20.68 v1(198.2,19.17) C2.1 C1.1 ; RV444.1 29.13,106.46 v1(29.13,106.68) ; RV460.1 23.65,99.44 23.63,99.42 v1(23.62,99.42) ; RU36.1 142.58,113.01 v1(142.43,113.16) ; RE34.2 145.25,14.17 v1(145.26,14.16) ; v1(156.44,19.82) 155.97,19.35 155.97,18.54 ; C3.1 198,14.74 197.28,15.46 R1.2 196.58,16.58 196.14,17.02 v1(196.14,17.53) ; C4.1 208.04,14.23 v1(208.47,14.23) ; v1(131.25,111.58) 130.9,111.22 RU35.2 ; CA92.1 CA87.1 25.58,31.39 25.87,31.68 v1(26.05,31.68) ; v1(269.27,34.06) 269.29,34.03 CH33.1 ; RA4.2 5.46,32.91 RA44.1 5.09,33.84 v1(4.38,34.55) ; v1(262.66,34.08) 262.12,33.54 CH98.1 ; v1(35.37,99.26) 34.92,99.7 RV429.1 ; v1(178.57,23.19) 178.57,22.18 178.12,21.72 178.12,16.45 177.86,16.2 ; RZ484.2 250.65,50.59 v1(250.96,50.91) ; CV745.1 24.7,98 24.7,98.2 v1(24.55,98.36) ; v3(254.35,28.42) RH75.1
  GND1 w0.305: v3(259.73,15.12) 259.4,15.44 v4(259.37,15.44)
  GND1 w0.508: v5(12.25,35.44) 12.71,35.9 v3(12.71,35.75) ; v3(254.37,27.44) 254.37,28.4 v3(254.35,28.42) ; v3(269.05,13.47) v4(269.05,14.26) ; v3(24.9,33.28) v5(25.61,33.28)
  IN1 w0.508: v5(25.61,33.28) 25.61,32.11 v1(26.05,31.68) ; v1(133.6,32.01) 133.28,32.01 132.65,32.64 132.65,64.7 131.33,66.02 131.33,71.25 v1(133.56,73.49) ; v1(4.38,34.55) 5.27,33.66 v1(8.57,33.66) 9.4,33.66 9.87,33.19 10.84,33.19 11.54,33.89 11.54,34.73 v5(12.25,35.44) ; v4(158,28.08) 158,27.38 155.69,25.07 v1(155.69,24.74)
  IN2 w0.508: v1(17.03,33.79) 17.54,33.28 18.22,33.28 20,31.5 ; v1(4.38,34.55) 4.61,34.55 7.71,31.45 11.14,31.45 13.73,28.87 19.47,28.87 19.5,28.89 ; v1(133.56,73.49) 131.56,73.49 129.28,75.76 129.28,96.37 130.4,97.49 130.4,101.25 v1(130.11,101.54) 130.11,109.96 131.25,111.11 v1(131.25,111.58) 129.73,113.1 129.73,119.58 128.5,120.81 122.46,120.81 121.93,121.34 121.93,122.89 121.55,123.27 v1(121.35,123.27)
  IN2 w1.016: 21.12,23.05 21.93,23.86 21.93,27.14
  IN3 w0.508: v1(20.83,92.4) 20.83,93.82 24.55,97.54 v1(24.55,98.36) ; v1(254.21,13.55) 254.39,13.37 260.06,13.37 260.38,13.05 263.95,13.05 264.5,12.5 268.8,12.5 270.21,13.91 271.65,13.91 v4(271.86,14.12)
  IN3 w1.524: 33.27,70.87 33.27,82.42 34.02,83.17 34.02,91.27 32,93.29 32,96.46
  GND3 w0.305: v7(258.78,15.62) 259.2,15.62 v4(259.37,15.44)
  GND3 w0.508: v4(251.45,21.1) 251.45,20.65 251.77,20.33 252.21,20.33 v7(252.27,20.39)
  BOTTOM w0.203: U7.L24 270.66,31.41 v1(270.66,31.77) ; U7.R30 268.93,33.72 269.27,34.06 v1(269.27,34.06) ; v1(262.66,34.08) 262.99,34.41 U7.AK32 ; U7.AG14 264.31,27.25 v1(264.64,27.58) 264.97,27.25 U7.AE14 264.97,27.02 U7.AF12
  BOTTOM w0.254: v1(262.66,34.08) 262.66,34 262.99,33.67 U7.AK30 ; U7.R32 268.93,34.39 v1(269.27,34.06) ; UA2.B2 11.68,33.84
  BOTTOM w0.305: JTP.6 207.25,22.26 207.52,21.99 v1(207.52,21.79)
  BOTTOM w0.356: v1(247.46,37.35) 246.19,37.35 245.2,36.36 JDIMM2.199 ; JDIMM1.199 v1(170.7,32.85)
  BOTTOM w0.381: v1(130.11,101.54) 130.38,101.28 UU2.5 ; v1(248.79,23.25) 248.79,23.17 249.17,22.79 QH3.2 QH3.5 ; CE19.1 155.23,17.71 UE2.5
  BOTTOM w0.457: CA7.1 28.92,41.78 v1(28.98,41.84)
  BOTTOM w0.508: RE51.1 v1(27.82,70.88) ; v1(145.26,14.16) 145.3,14.19 145.3,14.49 145.78,14.97 147.79,14.97 149.36,16.54 149.36,20.43 152.56,23.63 153.76,23.63 154.77,24.65 155.6,24.65 v1(155.69,24.74) 155.69,23.7 156.44,22.95 v1(156.44,19.82) 155.97,19.35 155.97,19.28 155.26,18.57 CE19.1 ; v1(131.25,111.58) 133.58,111.58 134.5,110.66 RU42.1 136.44,111.3 136.94,111.81 141.07,111.81 v1(142.43,113.16) ; v1(20.83,92.4) 20.55,92.68 RV491.2 ; RV431.1 RV448.1 v1(34.67,103.45) ; PR711.1 121.42,123.53 121.35,123.46 v1(121.35,123.27) ; DV9.2 17.13,96.23 16.42,95.52 16.09,95.52 RV452.1 ; RV5.1 18.5,109.33 18.84,108.99 JTS.1 20.51,108.49 v1(20.51,107.7) ; v1(8.57,33.66) 8.62,33.61 8.62,33.28 8.93,32.98 9.87,32.98 10.23,33.35 CA29.2 10.39,33.73 11.57,33.73 11.68,33.84 ; v1(280.06,33.04) 279.69,33.41 279.16,33.41 RH167.1 ; RA42.2 16.57,34.17 16.95,33.79 v1(17.03,33.79) ; RV450.1 v1(35.56,103.45)
  BOTTOM w1.524: 30.27,49.16 30.27,50.18 31.46,51.37 31.46,54.87 32.67,56.08 33.3,56.08 34.15,56.93 34.15,63.39 33.92,63.61
  vias: v1(19.79,55.13) v1(19.79,54.55) v1(20.76,21.45) v1(21.4,21.45) v1(23.22,101.49) v1(23.22,100.85) v1(23.22,100.22) v1(26.33,28.48) v1(27.39,45.99) v1(27.98,45.99) v1(28.56,28.9) v1(28.82,44.97) v1(29.14,28.9) v1(32.38,97.61) v1(32.86,69.8) v1(32.86,69.22) v1(32.86,68.63) v1(33.08,97.04) v1(37.21,37.35) v1(37.21,36.71) v1(37.84,37.35) v1(37.84,36.71) v1(38.48,37.35) v1(38.48,36.71) v1(55.76,42.5) v1(56.42,42.48) v1(56.58,41.87) v1(57.19,41.59) v1(213.55,69.92) v1(213.55,69.29) v1(230.76,61.6) v1(232.34,61.29) v1(247.46,37.96) v1(249.93,24.39) v1(253.58,13.55) v1(257.49,52.01) v1(257.52,48.85) v1(258.73,28.19) v1(259.32,28.21) v1(267.33,46.77) v1(267.92,46.77) v1(275.18,43.07) v1(275.84,43.09) v1(279.39,39.23) v1(279.61,38.62) v1(280.4,27.75) v1(280.39,27.13) v7(257.83,15.62) v8(38.67,39.63)
+3VS_DELAY: length 206.4
  TOP w0.254: v1(222.06,67) 222.06,66.17 221.3,65.41 221.3,60.52 220.03,59.25 QV42.5 220.03,57.03 220.53,56.52 220.53,56.08 220.03,55.57 QV42.2
  TOP w0.381: v1(250.21,48.99) 247.62,46.4 247.62,42.39 247.35,42.11 243.82,42.11 243.26,42.67 UH4.5
  TOP w0.508: RZ6.1 207.07,64.14 207.71,63.51 v8(208.04,63.51) v1(209.23,63.51) ; RV302.2 222.31,67.25 v1(222.06,67) ; v1(224.66,67) 224.13,67.53 RV303.2 ; RV307.2 v1(217.09,67.75) ; RV306.2 v1(220.53,67)
  IN2 w0.508: v1(142.58,114.88) 146.08,114.88 150.99,109.97 178.5,109.97 184.49,103.98 184.49,95.48 186.24,93.74 190.73,93.74 195.03,89.44 195.03,86.09 v1(197.29,83.83)
  IN3 w0.508: v1(211.71,71.45) 211.03,72.12 211.03,85.71 209.86,86.88 v1(207.89,86.88) ; v1(224.75,66.3) 224.19,65.74 224.19,61.27 225.32,60.14 233.04,60.14 240.73,52.46 248.65,52.46 250.21,50.9 v1(250.21,48.99)
  IN4 w0.508: v1(209.23,63.51) 211.14,65.41 211.14,70.87 v1(211.71,71.45) ; v1(207.89,86.88) 205.3,86.88 202.25,83.83 v1(197.29,83.83)
  BOTTOM w0.254: RPH32.5 221.41,64.86 221.11,65.16 ; RPH33.8 219.34,71.99 v1(219.59,71.74) 219.84,71.98 RPH33.7 ; RPH33.6 v1(220.34,71.95) ; RPH32.6 221.91,65.16
  BOTTOM w0.305: UV1.AH12 207.5,87.27 v1(207.89,86.88) 208.3,87.3 UV1.AG12
  BOTTOM w0.381: QV21.5 QV21.2 v1(211.71,71.45)
  BOTTOM w0.406: 221.11,65.16 221.11,66.23 220.53,66.81 v1(220.53,67) ; 221.91,65.16 221.91,66.85 v1(222.06,67)
  BOTTOM w0.508: v1(197.29,83.83) 197.29,83.13 196.85,82.68 196.85,79.89 197.42,79.32 RV320.1 ; PR803.1 141.82,115.64 v1(142.58,114.88) ; RV319.2 v1(216.18,75.53) ; RV308.2 v1(223.26,69.35) ; RV301.2 v1(222.25,71.19)
  vias: v1(195.68,65.86) v1(196.19,65.48) v1(215.14,71.06) v1(215.14,70.45) v1(215.45,68.94) v1(215.45,68.33) v1(215.45,67.72) v1(222.31,76.14) v1(222.31,75.53)
+3VS_DP: length 1.4
  BOTTOM w0.102: DPF1.2 9.53,98.44 v2(9.36,98.61)
+3VS_MDPR: length 16.6
  TOP w0.508: v1(24.35,75.22) 24.4,75.17 25.08,75.17 C43.1 25.27,75.18 R2532.2
  IN3 w0.508: v1(26.26,80.91) 26.91,80.27 26.91,78.42 26.55,78.06 v1(26.27,78.06) 25.94,78.06 25.46,77.58 25.46,75.95 24.73,75.22 v1(24.35,75.22)
  BOTTOM w0.254: v1(24.35,75.22) 24.47,75.22 24.81,75.56 U11.1 ; v1(31.09,80.72) 31.47,80.72 31.81,81.06 U11.25 ; v1(31.1,77.81) 31.38,77.81 31.63,77.56 U11.32 ; v1(26.26,80.91) 25.95,80.91 25.8,81.06 U11.12 ; U11.36 31.74,75.56 31.56,75.74 v1(31.1,75.74) ; U11.6 v1(26.27,78.06)
  vias: v8(32.55,80.17)
+3VS_RD: length 29.8
  TOP w0.508: v1(35.81,29.4) 35.81,30.2 36.1,30.49 v8(36.1,34.78) 36.1,39.44 v1(35.08,40.47)
  IN2 w0.508: v1(40.85,32.78) 36.71,32.78 35.81,31.88 v1(35.81,29.4)
  BOTTOM w0.508: CN28.1 v1(40.85,32.78) RN19.2 ; 36.08,40.47 v1(35.08,40.47) 34.87,40.47 34.33,39.93 RN10.1 RN18.2 CN29.1 ; 36.08,40.47 37.63,40.47 37.87,40.23 RN11.1 RN16.2 ; 36.08,40.47 36.09,40.46 RN12.1 ; v1(35.81,29.4) 35.72,29.48 RN4.2
+5V_CHGUSB_1:
  vias: v1(21.04,60.82) v1(21.6,61.71) v1(21.6,61.13) v1(21.63,60.54) v1(25.84,55.84) v1(25.87,55.2) v1(26.45,55.84) v1(26.48,55.2) v8(20.97,61.37)
+5V_CHGUSB_3: length 2.3
  TOP w0.102: v1(15.19,80.92) 16.08,80.92 v8(17.05,81.9)
  vias: v1(14.74,80.5) v1(19.84,75.86) v1(20.36,76.15) v1(20.36,75.53) v1(20.36,74.92)
+5V_HDMI_DDC: length 6.4
  TOP w0.508: v1(23.7,102.27) 23.72,102.24 RV445.1 RV447.1
  BOTTOM w0.508: DV11.1 20.24,102.48 v2(20.74,102.48) 23.49,102.48 v1(23.7,102.27)
+5VALW: length 233.6
  TOP w0.203: PU400.12 124.73,15.28 124.23,14.78 v1(124.23,14.09)
  TOP w0.508: v1(30.47,19.95) R33.1 R34.1 ; R25.1 R26.1 25.46,12.89 v1(25.82,12.53) ; PC407.2 124.76,11.06 122.94,11.06 v1(122.78,11.21) 122.34,11.66 PR402.1 ; LED9.2 2.29,15.56 v1(3.81,14.04) ; v1(20.3,81.23) 20.01,81.52 18.18,81.52 17.62,80.95 RE65.1 RE68.1 RI30.1 ; v1(4.13,26.87) 3.44,27.55 LED3.1 ; v1(2.83,23.46) 2.12,22.74 LED7.2 ; v1(3.84,19.02) 3.74,19.12 LED8.2 ; v1(189.5,127.36) 189.27,127.14 PC604.2 ; LED6.2 2.98,11.94 v1(3.81,12.77) ; R32.1 19.9,16.29 20.51,16.29 v1(20.71,16.09) ; v1(234.35,73.96) 234.88,73.43 PR510.2 v8(232.24,70.62) 230.47,68.84 230.47,65.37 234.19,61.65 234.19,50.11 238.65,45.65 v8(238.65,41.28) 238.65,30.6 239.14,30.11 239.14,25.77 238.48,25.12 v1(238.48,18.73) ; R27.1 v1(14.03,17.1) ; v1(26.48,107.87) 25.83,108.52 R67.2 R66.2
  IN2 w0.508: v1(231.89,114.43) 231.89,112.62 236.51,108 236.51,84.31 237.53,83.29 237.53,78.49 234.35,75.32 v1(234.35,73.96)
  IN4 w0.508: v1(189.5,127.36) 189.5,127.52 190.03,128.05 192.59,128.05 193.64,127.01 195.87,127.01 196.99,128.13 204.91,128.13 205.61,127.43 209.09,127.43 209.1,127.44 228.69,127.44 231,125.13 231,115.32 v1(231.89,114.43)
  IN4 w1.524: 53.63,30.14 53.63,32.61 52.48,33.76 51.09,33.76 48.02,36.84 47.43,36.84 ; 45.34,37.22 44.19,37.22 40.13,41.28
  BOTTOM w0.203: v1(189.5,127.36) 189.27,127.14 PU600.18 ; UZ4.4 36.26,42.15 v1(36.31,42.1)
  BOTTOM w0.508: PR105.2 47.61,43.39 PD100.3 49.08,41.92 49.08,40.08 47.32,38.31 v1(46.43,38.31) ; v1(23.28,17.64) R12.1 R11.1 ; v1(71.25,31) 71.25,31.5 70.67,32.08 CN34.1 69.85,33.16 UN3.5 UN3.4 ; RE63.1 21.19,54.01 RE62.1 RI19.1 20.57,54.88 v1(20.56,54.87) ; v1(25.82,12.53) R18.1 R17.1 R21.1 R20.1
  vias: v1(23.25,76.17) v1(23.26,75.59) v1(23.84,76.17) v1(23.85,75.59) v1(27.01,51.57) v1(27.01,50.96) v1(27.6,51.54) v1(27.6,50.94) v1(37.4,41.66) v1(38.03,41.66) v1(38.67,41.66) v1(253.05,10.32) v1(253.38,10.81) v1(253.68,10.32) v1(254.01,10.81) v1(254.32,10.32) v1(254.65,10.81) v1(254.95,10.32) v1(255.28,10.81) v1(255.59,10.32) v1(255.92,10.81) v4(5.33,27.31) v4(5.33,26.68) v4(5.97,27.31) v4(5.97,26.68) v8(54.09,28.23) v9(52.84,26.14) v9(53.12,26.73) v9(53.48,26.2) v9(53.81,26.75) v9(54.11,26.2) v9(54.44,26.75) v9(54.75,26.2) v9(55.08,26.75) v9(55.38,26.2) v9(55.71,26.75) v9(56.02,26.2) v9(56.35,26.75) v9(56.65,26.2) v9(56.98,26.75) v9(57.29,26.17) v9(57.62,26.75) v9(57.92,26.17)
+5VALWP: length 33.5
  TOP w0.203: v1(49.15,29.73) 49.17,29.75 PU300.14
  TOP w0.254: v1(59.07,22.26) 59.07,26.6 57.9,27.77 57.9,33.92 v2(56.17,35.65) 54.65,37.17 PR301.2 PC302.2
  IN4 w0.508: v9(54.39,23.58) 52.71,23.58 51.42,24.87 51.42,30.13 50.63,30.92 49.39,30.92 49.03,30.56 49.03,29.84 v1(49.15,29.73)
  vias: v9(54.39,22.82) v9(55.03,23.58) v9(55.03,22.82) v9(55.66,23.58) v9(55.66,22.82) v9(56.3,23.58) v9(56.3,22.82) v9(56.93,23.58) v9(56.93,22.82)
+5VS: length 609.9
  TOP w0.508: PR712.1 123.33,109.85 123.82,109.35 126.3,109.35 PR730.2 127.44,109.82 v1(128.12,109.13) ; 94.04,42.05 94.8,42.81 v1(95.06,42.81) ; 94.04,42.05 94.04,40.33 95.31,39.06 v1(95.95,39.06) ; 94.04,42.05 U4.3 91.93,42.05 CT44.1 ; v1(94.17,44.2) 93.91,43.95 U4.1 ; RN23.1 231.65,50.17 236.63,45.19 236.63,30.46 236.41,30.23 236.41,25.47 235.89,24.95 235.89,21.29 235.32,20.72 235.32,18.64 233.97,17.29 233.97,12.28 v3(234.57,11.68)
  TOP w1.016: 27.42,34.7 28.95,34.7 29.32,34.34 32.89,34.34 33.64,35.09
  GND1 w0.508: v4(234.99,11.02) 234.57,11.44 v3(234.57,11.68)
  IN1 w0.508: v1(251.85,9.69) 251.95,9.58 257.57,9.58 v1(258.28,10.29) ; v1(182.56,121.04) 182.56,120.79 180.67,118.9 170.3,118.9 169.25,119.95 160.06,119.95 158.99,118.88 154.29,118.88 153.85,119.32 149.36,119.32 v1(147.41,117.37) ; v1(95.06,42.81) 94.17,43.7 v1(94.17,44.2) 96.2,46.24 97.13,46.24 104.5,53.6 105.75,53.6 113.36,61.21 117.17,61.21 122.82,66.86 122.82,69.17 125.3,71.65 125.3,99.66 128.26,102.62 128.26,109 v1(128.12,109.13) ; v1(223.94,18.51) 223.94,18.81 223.63,19.12 217.21,19.12 212.6,23.73 206.5,23.73 205.01,25.22 v1(177.35,25.22)
  IN2 w0.508: 170.83,25.61 171.79,24.65
  IN2 w0.762: 171.79,24.65 172.51,23.93 176.38,23.93 177.35,24.9 v1(177.35,25.22) ; 27.62,67.44 27.62,66.02 29.59,64.05 29.59,60.8 31.41,58.98 31.41,55.5 40.09,46.82 ; 41.97,46.16 43.17,46.16 48.4,40.93 53.57,40.93 55.57,38.92 61.28,38.92 61.68,38.51 65.8,38.51 66.76,37.56 69.23,37.56 70.09,36.7 75.66,36.7 76.09,37.12 94.01,37.12 v1(95.95,39.06) 96.21,39.33 97.93,39.33 103.31,33.94 137.24,33.94 139.12,32.06 145.02,32.06 147.01,34.05 167.21,34.05 169.84,31.43 169.84,26.58 170.81,25.61 170.83,25.61
  IN2 w1.016: 28.18,81.82 26.02,83.98 23.46,83.98 19.72,87.71 19.72,93.07 21.6,94.95 21.6,98.59 19.47,100.72 19.47,104.34
  IN3 w0.508: v1(251.85,9.69) 251.45,9.28 244.46,9.28 243.93,9.81 243.93,10.85 243.75,11.02 v4(234.99,11.02) ; 32.45,44.36 32.13,44.36 29.84,46.65 26.52,46.65 24.99,45.12 24.65,45.12 22.11,42.58 20.16,42.58 12.25,34.68 5.73,34.68 4,32.95 4,30.61 3.55,30.17 v4(3.55,27.63)
  IN3 w1.016: 39.69,45.22 38.75,44.28 33.95,44.28
  IN4 w0.508: v1(147.41,117.37) 145.74,115.7 136.13,115.7 134.17,113.75 131.79,113.75 128.12,110.08 v1(128.12,109.13)
  IN4 w1.016: 51.38,36.44 51.31,36.44 49.71,38.04 49.71,38.72 47.17,41.26 45.32,41.26 41.37,45.2
  GND3 w0.508: v7(234.26,11.08) 234.28,11.06 234.96,11.06 v4(234.99,11.02) ; v7(2.84,27.63) v4(3.55,27.63)
  BOTTOM w0.508: v1(147.41,117.37) 148.68,118.64 148.68,123.55 148.01,124.22 PR821.2 ; CE57.1 28.24,67.81 RE53.1 28.05,68.34 v1(27.57,68.34) ; v7(234.26,11.08) 228.41,11.08 227.06,12.43 227.06,13.62 227.39,13.96 228.1,13.96 228.43,14.29 228.43,17.23 227.52,18.14 224.31,18.14 v1(223.94,18.51) 223.94,18.85 223.36,19.44 217.92,19.44 217.04,20.32 C11.1 217.09,21.75 F1.2 ; QZ24.3 170.65,22.95 171.59,23.88 175.56,23.88 176.89,25.22 v1(177.35,25.22) ; CM33.1 251.75,9.79 v1(251.85,9.69)
  vias: v1(18.48,105.9) v1(18.5,105.29) v1(33.39,40.72) v1(33.97,40.72) v1(40.73,46.45) v1(40.73,45.82) v6(52.08,35.92) v6(52.51,35.92) v7(52.08,35.47) v7(52.51,35.47) v8(34.43,40.17)
+5VS_HDD: length 38.2
  IN2 w1.27: 61.23,31.71 58.66,31.71 57.01,33.36 52.62,33.36 51.94,34.03 44.97,34.03 44.13,33.19 44.13,32.9 42.73,31.5 40.19,31.5 39.05,30.36
  IN4 w1.27: 37.81,28.33 37.81,27.27 35.81,25.28 30.16,25.28
  BOTTOM w0.254: JHDD.16 28.68,25.36 28.75,25.29 ; JHDD.15 28.68,25.86 28.75,25.79 ; JHDD.14 28.78,26.36 28.88,26.26
  vias: v1(29.11,25.84) v1(29.11,25.23) v1(29.11,24.62) v1(37.15,29.5) v1(37.29,30.18) v1(37.9,30.18) v1(61.36,32.84) v1(61.97,32.84) v1(62.57,32.82) v8(38.16,29.5)
+5VS_KBL:
  vias: v8(223.91,21.88)
+5VS_TPS:
  vias: v2(37.25,46.31)
+V1.05S_VCCP_PWRGOOD: length 195.4
  TOP w0.508: v3(195.8,11.02) 195.8,15.72 195.47,16.06 v2(195.47,18.32) 195.47,19.19 198.31,22.03 198.31,22.99 198.72,23.4 v1(200.21,23.4) ; v1(156.18,11.74) 155.99,11.55 RE27.1
  GND1 w0.508: v5(194.98,11.02) v3(195.8,11.02)
  IN1 w0.254: v1(156.18,11.74) 156.25,11.74 156.73,12.23 156.73,12.64 155.04,14.34 155.04,15.24 152.88,17.39 147.9,17.39 147.71,17.58 145.7,17.58 145.2,18.08 145.2,23.3 144.38,24.12 134.12,24.12 131.48,26.75 131.48,63.99 v1(131.3,64.17)
  IN1 w0.508: v5(194.98,11.02) 194.77,11.23 190.55,11.23 189.96,11.82 185.38,11.82 184.59,11.02 156.79,11.02 156.18,11.63 v1(156.18,11.74)
  IN4 w0.508: v1(200.21,23.4) 200.21,38.49 201.72,40 207.14,40 223.71,56.57 223.71,59.32 224.27,59.88 224.27,64.76 226.06,66.56 v1(226.06,66.81)
  BOTTOM w0.254: 229.1,66.51 229.48,66.89 PU500.1
  BOTTOM w0.508: v1(226.06,66.81) 226.06,65.78 226.68,65.16 228.79,65.16 229.1,65.47 229.1,66.51 ; RU50.1 131.67,64.54 v1(131.3,64.17)
+V1.05V_B+:
  vias: v2(238.45,64.96) v9(240.55,63.33) v9(241.18,63.33) v9(241.82,63.33) v9(242.45,63.33) v9(243.09,63.33)
+V18R: length 1.5
  TOP w0.102: v2(169.7,12.99) 169.63,13.05 CE17.1
+VCC_CORE: length 5.4
  TOP w0.102: v8(125.33,93.96) 125.18,93.81 v9(124.37,93.81)
  TOP w0.508: v1(145.67,108.26) 146.14,108.74 RU96.1
  BOTTOM w0.254: v1(173.72,99.51) 173.89,99.69 U6.H9 ; v1(165.76,100.53) 165.77,100.54 165.77,101.1 U6.F22 ; v1(152.69,81.55) U6.AP42 ; v1(176.33,97.93) U6.L6 ; v1(174,94.67) U6.R9 ; v1(176.33,97.12) U6.M6
  vias: v1(148.64,98.79) v1(148.68,105.03) v1(148.66,103.6) v1(148.66,102.9) v1(148.66,102.2) v1(148.66,101.49) v1(148.66,100.8) v1(148.66,100.1) v1(148.66,99.38) v1(149.46,105.03) v1(149.46,103.6) v1(149.46,102.9) v1(149.46,102.2) v1(149.46,101.5) v1(149.46,100.8) v1(149.46,100.1) v1(149.46,99.4) v1(149.5,98.63) v1(150.25,105.03) v1(150.25,103.6) v1(150.25,102.9) v1(150.25,102.2) v1(150.25,101.5) v1(150.25,100.8) v1(150.25,100.1) v1(150.25,99.4) v1(150.27,98.71) v1(151.02,98.72) v1(150.97,93.67) v1(150.97,92.27) v1(150.97,90.87) v1(150.97,89.47) v1(150.97,88.07) v1(150.97,86.67) v1(150.97,85.27) v1(150.97,83.87) v1(151.61,95.59) v1(151.61,94.99) v1(151.82,105.01) v1(151.82,103.6) v1(151.82,102.9) v1(151.82,102.2) v1(151.82,101.5) v1(151.84,100.79) v1(151.82,100.1) v1(151.82,99.4) v1(151.82,98.63) v1(152.22,95.02) v1(152.61,105.01) v1(152.61,103.6) v1(152.61,102.9) v1(152.61,102.2) v1(152.61,101.5) v1(152.61,100.79) v1(152.61,100.1) v1(152.69,93.62) v1(152.69,91.84) v1(152.69,90.06) v1(152.69,87.78) v1(152.69,85.75) v1(152.69,84.86) v1(152.69,84.22) v1(152.69,83.6) v1(153.04,95.4) v1(153.32,94) v1(153.32,91.97) v1(153.32,89.94) v1(153.32,87.9) v1(153.32,85.87) v1(153.34,83.93) v1(153.43,100.05) v1(153.43,99.33) v1(153.83,95.4) v1(154.04,83.6) v1(154.19,105.01) v1(154.19,103.6) v1(154.19,102.9) v1(154.19,102.2) v1(154.19,101.5) v1(154.23,100.74) v1(154.61,95.14) v1(154.74,83.93) v1(154.97,105) v1(154.97,103.6) v1(154.97,102.9) v1(154.97,102.2) v1(154.97,101.5) v1(154.97,100.78) v1(155.4,95.33) v1(155.44,83.6) v1(156.14,95.33) v1(156.55,104.99) v1(156.55,103.6) v1(156.55,102.9) v1(156.55,102.2) v1(156.55,101.5) v1(156.52,100.78) v1(156.79,83.45) v1(157.35,104.98) v1(157.34,103.6) v1(157.34,102.9) v1(157.34,102.2) v1(157.34,101.5) v1(157.37,100.78) v1(157.75,98.79) v1(158.19,83.45) v1(158.39,96.18) v1(159.32,98.79) v1(159.3,96.18) v1(159.54,83.45) v1(159.73,105.04) v1(159.7,103.6) v1(159.7,102.9) v1(159.7,102.2) v1(159.7,101.5) v1(159.67,100.75) v1(160.5,96.16) v1(160.87,98.79) v1(160.94,83.6) v1(161.26,89.06) v1(161.26,86.86) v1(161.64,83.93) v1(162.03,105) v1(162.08,103.6) v1(162.08,102.9) v1(162.08,102.2) v1(162.08,101.5) v1(162.1,96.41) v1(162.11,95.7) v1(162.37,100.61) v1(162.37,98.79) v1(162.41,84.19) v1(162.39,83.6) v1(163.74,83.6) v1(163.95,98.79) v1(164.13,96.18) v1(164.17,94.64) v1(164.17,92.6) v1(164.17,90.57) v1(164.17,88.54) v1(164.17,86.76) v1(164.17,85.05) v1(164.44,83.93) v1(164.71,98.41) v1(165.12,96.18) v1(165.14,83.6) v1(165.52,98.76) v1(166.03,96.18) v1(166.49,83.6) v1(167.09,98.79) v1(167.19,83.93) v1(167.86,98.41) v1(167.89,83.6) v1(168.07,96.18) v1(168.64,98.81) v1(169.1,83.64) v1(169.18,96.18) v1(170.1,96.18) v1(170.14,90.83) v1(170.14,88.92) v1(170.14,87.02) v1(170.14,85.11) v1(170.19,98.82) v1(170.96,98.44) v1(171.15,94.76) v1(171.15,92.73) v1(171.16,83.71) v1(171.72,98.79) v1(172.13,96.18) v1(172.82,95.46) v1(172.84,84.09) v1(173.19,98.79) v1(173.49,84.06) v1(173.49,83.48) v1(173.64,98.32) v1(173.62,91.08) v1(173.62,89.58) v1(173.7,97.3) v1(173.7,94.13) v1(173.7,92.41) v1(174,96.07) v1(174.01,83.17) v4(155.62,82.95) v4(164.38,83.09) v9(121.77,93.81) v9(121.77,82.94) v9(122.46,93.81) v9(122.46,82.94) v9(122.46,82.3) v9(123.1,93.81) v9(123.1,82.94) v9(123.1,82.3) v9(123.73,93.81) v9(123.73,82.94) v9(123.73,82.3) v9(124.37,82.94) v9(124.37,82.3) v9(131.28,91.39) v9(131.29,90.72) v9(131.29,90.08) v9(131.28,89.42) v9(131.28,88.79) v9(131.28,88.15) v9(131.74,86.97) v9(131.74,86.33) v9(131.74,85.7) v9(131.74,85) v9(131.74,84.36) v9(131.74,83.73) v9(131.74,83.09) v9(131.74,82.46) v9(131.74,81.82) v9(131.93,90.72) v9(131.93,90.08) v9(131.91,89.42) v9(131.91,88.79) v9(131.91,88.15) v9(132.44,85) v9(132.44,84.36) v9(132.44,83.73) v9(132.44,83.09) v9(132.44,82.46) v9(132.44,81.82) v9(132.55,88.79) v9(132.55,88.15) v9(133.07,85) v9(133.07,84.36) v9(133.07,83.73) v9(133.07,83.09) v9(133.07,82.46) v9(133.07,81.82) v9(133.18,88.79) v9(133.18,88.15) v9(133.71,85) v9(133.71,84.36) v9(133.82,88.79) v9(133.82,88.15) v9(134.34,85) v9(139.03,88.84) v9(139.03,88.2) v9(139.05,87.31) v9(139.05,86.68) v9(139.05,86.04) v9(161.27,105)
+VCC_PWR_SRC1: length 9.1
  TOP w0.508: v1(124.01,110.69) 124.4,110.3 v2(124.5,110.3) PR725.2
  IN3 w0.508: v1(124.01,110.69) 119.05,110.69 117.85,109.49 v9(117.01,109.49)
  vias: v9(114.34,109.49) v9(114.34,108.85) v9(115.1,109.49) v9(115.1,108.85) v9(116.12,109.49) v9(116.12,108.85) v9(117.01,108.85)
+VCC_PWR_SRC2:
  vias: v2(119.58,70.61) v9(114.08,72.15) v9(114.08,71.39) v9(115.23,72.15) v9(115.23,71.39) v9(116.37,72.15) v9(116.37,71.39) v9(117.64,72.15) v9(117.64,71.39)
+VCCAFDI_VRM: length 12.5
  IN3 w0.508: v1(255.9,30.56) 255.69,30.34 255.69,28.11 256.91,26.89 260.34,26.89 v1(261.04,26.19)
  BOTTOM w0.203: U7.BE22 v1(255.9,30.56)
  BOTTOM w0.254: U7.AK28 262.99,32.72 v1(262.72,32.45) 262.99,32.19 U7.AK26 ; v1(263.99,35.62) 264.27,35.62 U7.AF34 ; v1(261.04,26.19) 261.25,25.98 U7.AN11 ; U7.BB44 258.07,39.83 v1(258.67,39.83)
  vias: v1(255.03,38.34) v1(255.03,37.73) v2(257.12,31.28)
+VCCIO2PCH: length 170.8
  TOP w0.508: v1(250.51,47.51) 248.31,45.31 248.31,41.61 246.84,40.14 242.42,40.14 240.79,38.52 240.79,27.44 v2(245.13,23.1) 245.71,22.52 245.71,18.33 245.93,18.11 245.93,16.81 247.64,15.11 252.41,15.11 252.69,15.39 254.81,15.39 256.22,16.8 256.22,18.23 256.84,18.85 R53.2
  IN1 w0.508: v1(177.23,106.31) 179.42,106.31 183.95,101.78 183.95,91.37 190.92,84.4 192.03,84.4 199.26,77.17 199.26,73.82 203.15,69.94 204.9,69.94 209.43,65.41 211.72,65.41 216.56,60.57 230.8,60.57 230.85,60.52 238.15,60.52 242.51,56.16 243.92,56.16 248.51,51.57 248.51,49.5 v1(250.51,47.51)
  BOTTOM w0.508: v1(177.23,106.31) 176.93,106.31 176.01,107.23 172.42,107.23 171.41,108.24 R58.2
+VCCIO_OUT: length 211.4
  TOP w0.102: v1(131.81,107.71) v8(130.93,107.71)
  TOP w0.254: JXDP.44 132.02,108.55 131.81,108.34 131.81,108.14
  TOP w0.279: v1(138.3,108.4) 138.3,108.45 138.39,108.55 JXDP.43
  TOP w0.508: PR700.1 PR701.1 v1(119.43,120.67) 120.57,121.81 PR702.1 ; v1(172.91,91.07) 172.91,91.85 RU40.1 ; 131.81,108.14 v1(131.81,107.71)
  IN1 w0.508: v1(131.81,107.71) 131.81,104.14 126.52,98.84 126.52,71.15 124.17,68.79 124.17,66.48 117.67,59.99 114.27,59.99 106.58,52.29 104.91,52.29 102.27,49.65 102.27,49.26 v1(100.77,47.76)
  IN2 w0.508: v1(138.3,108.4) 138.62,108.4 139,108.02 139,107.39 136.92,105.3 v4(136.92,103.88) 136.92,100.71 137.29,100.34 137.98,100.34 v1(138.3,100.66) 140.6,98.36 v1(141.92,98.36) ; v1(146.25,102.87) 145.44,102.87 143.83,104.48 143.83,106.75 ; 143.83,106.75 171.26,106.75 172.59,105.42 172.59,101.48 174.69,99.39 174.69,94.24 172.91,92.46 v1(172.91,91.07) ; 143.83,106.75 143.27,107.31 143.27,108.06 142.15,109.18 v1(141.95,109.18)
  IN3 w0.508: v1(138.3,108.4) 138.3,108.78 132.22,114.87 132.22,120.18 129.81,122.59 125.79,122.59 124.23,124.15 121.21,124.15 119.43,122.37 v1(119.43,120.67)
  IN4 w0.508: v1(131.81,107.71) 132.41,108.3 135.01,108.3 135.94,109.23 137.79,109.23 138.3,108.72 v1(138.3,108.4)
  GND3 w0.508: v7(136.92,103) v4(136.92,103.88)
  BOTTOM w0.254: U6.D51 146.62,102.49 v1(146.25,102.87)
  BOTTOM w0.508: RU90.1 v1(141.92,98.36) ; RV470.1 100.19,47.57 100.38,47.76 v1(100.77,47.76) ; v1(138.3,100.66) 138.35,100.6 RU91.1 ; CU36.2 141.99,103.9 142.99,104.9 142.99,108.64 142.45,109.18 v1(141.95,109.18) 141.43,109.7 139.6,109.7 v1(138.3,108.4)
+VCCIOA_OUT: length 4.7
  TOP w0.508: RU2.2 RU1.2 174.59,85.24 175.11,84.72 v2(175.51,84.72) 176.17,84.72 v1(176.39,84.93)
  BOTTOM w0.254: v1(176.39,84.93) 176.39,85 176.73,85.33 U6.AK6
+VCCP: length 237.7
  TOP w0.102: v8(125.44,124.85) 125.23,124.85 125.03,124.65 v1(125.03,124.24)
  TOP w0.508: v1(268.56,36.26) 268.16,36.65 CH84.1 ; v1(260.92,36.11) 260.92,36.72 CH46.1 ; PR726.1 124.85,124.06 v1(125.03,124.24) ; v1(267.95,33.24) 267.95,33.91 CH82.1
  GND1 w0.508: v4(268.71,20.21) v3(268.09,20.21)
  IN1 w0.508: v1(210.82,62.24) 210.44,62.62 210.44,63.54 204.65,69.33 202.89,69.33 198.65,73.57 198.65,76.92 191.78,83.79 190.67,83.79 183.34,91.12 183.34,101.53 179.18,105.69 v1(177.26,105.69) 176.24,105.69 174.79,107.15 174.79,108.11 173.16,109.74 150.34,109.74 144.89,115.2 143.57,115.2 143.23,115.54 139.75,115.54 139.52,115.31 135.97,115.31 135.06,116.21 135.06,119.45 132.15,122.36 126.5,122.36 125.03,123.83 v1(125.03,124.24)
  IN2 w0.508: 265.37,19.52 264.85,19 263.23,19 262.58,18.35 262.28,18.35 261.62,17.68 258.87,17.68 258.25,18.3 254.77,18.3 v4(254.34,17.86) ; v1(125.03,124.24) 125.03,123.96 126.12,122.87 129.62,122.87 132.69,119.79 132.69,113.88 133.49,113.08 133.49,100.09 134.43,99.15 v1(134.43,97.48)
  IN3 w0.508: 269.6,44.96 269.89,45.25 272.01,45.25 278.47,38.78 278.47,29.86 279.07,29.26 279.07,22.06 278.13,21.12 278.13,20.58 v4(278.2,20.51)
  IN4 w0.508: v4(268.71,20.21) 268.99,19.93 271.79,19.93 272.21,19.5 273.54,19.5 274.54,20.51 v4(278.2,20.51)
  GND3 w0.381: v7(278.83,20.3) 278.79,20.34 278.37,20.34 v4(278.2,20.51)
  GND3 w0.508: v4(254.34,17.86) 254.25,17.78 v7(254.25,17.39) 254.25,16.91 v7(254.24,16.9)
  BOTTOM w0.203: U7.U35 268.24,35.96 268.38,36.09 268.39,36.09 v1(268.56,36.26) 268.26,36.56 U7.U36 ; U7.AK20 262.99,29.68 v1(262.66,30.02) ; v1(262.66,29.23) 262.99,28.9 U7.AK18
  BOTTOM w0.254: U7.AN34 261.35,35.31 260.92,35.74 v1(260.92,36.11) 261.44,36.11 U7.AN35
  BOTTOM w0.508: RU66.2 138.36,95.96 138.05,96.27 137.16,96.27 135.95,97.48 ; v1(177.26,105.69) 176.68,105.69 175.75,106.62 170.25,106.62 169.71,107.16 R58.1 169.05,108.34 RU94.1 ; RU13.2 136.47,98 135.95,97.48 ; 135.95,97.48 v1(134.43,97.48)
  vias: v1(253.26,58.68) v1(253.26,58.07) v1(253.26,57.46) v1(253.26,56.85) v1(253.87,58.68) v1(253.87,58.07) v1(253.87,57.46) v1(253.87,56.85) v1(267.21,42.98) v1(267.85,42.98) v1(268.48,42.98) v4(267.23,41.69)
+VCCRTCEXT: length 2.1
  TOP w0.254: v1(269.26,27.58) 269.26,28.16 CH79.1
  BOTTOM w0.203: U7.P16 269.59,27.91 v1(269.26,27.58) 269.59,27.25 U7.P14
+VCCSST: length 2
  TOP w0.102: v2(266.97,27.12) 266.62,27.47 v1(266.62,27.58)
  TOP w0.508: v1(266.62,27.58) 266.22,27.18 CH85.1
  BOTTOM w0.203: U7.AA14 266.29,27.25 v1(266.62,27.58)
+VDDA: length 11.3
  TOP w0.203: U15.39 23.55,38.26 23.2,37.9 v1(23.2,37.65)
  TOP w0.508: RA33.1 25.59,34.81 25.36,34.58 22.42,34.58 21.94,35.06 v8(21.94,35.9) 21.94,36.77 22.64,37.47 23.02,37.47 v1(23.2,37.65)
  BOTTOM w0.508: CA11.2 23.29,38.68 CA10.1 23.43,38.34 23.2,38.11 v1(23.2,37.65)
AGND: length 61.3
  TOP w0.102: v1(23.47,45.8) 23.44,45.8 22.67,46.57 v8(21.58,46.57) ; v8(11.44,30.84) 10.59,31.69 v3(10.54,31.69) ; v8(19.92,35.72) 19.92,36.33
  TOP w0.203: v1(23.47,45.8) 23.55,45.71 U15.22 ; U15.42 24.75,37.75 v1(24.92,37.59) ; v3(21.09,42.85) 21.15,42.79 U15.28
  TOP w0.508: v1(18.03,41.54) 18.01,41.51 RA7.1 ; CA38.2 CA34.2 16.8,45.45 v1(16.7,45.35) ; v1(15.02,51.26) CA5.2 CA12.2 ; v1(18.35,45.54) CA6.2 ; v1(16.75,36.57) 16.64,36.69 CA37.2 16.64,37.22 CA33.2
  GND1 w0.203: JHP2.7 9.47,46.64 ; JHP2.7 6.86,46.21 ; JHP2.7 6.86,46.64 ; v4(21.37,43.19) 21.09,42.91 v3(21.09,42.85)
  IN1 w0.508: JHP2.7 10.04,46.64 10.93,47.53 15.68,47.53 16.7,46.51 v1(16.7,45.35) ; v1(18.35,45.54) 18.35,45.75 15.72,48.38 15.72,50.56 v1(15.02,51.26) ; v1(16.75,36.57) 16.08,35.9 v1(15.05,35.9)
  GND2 w0.203: 6.86,46.21 JHP2.7 ; JHP2.7 9.47,46.64 ; JHP2.7 6.86,46.64
  GND3 w0.203: 6.86,46.64 JHP2.7 ; JHP2.7 9.47,46.64 ; JHP2.7 6.86,46.21
  BOTTOM w0.254: v1(5.33,31.31) 4.81,30.79 4.72,30.79 JP8.1 ; v7(11.68,35.85) UA2.A2
  BOTTOM w0.305: UA5.8 10.17,29.35 9.46,30.06 v7(9.46,31.12)
  BOTTOM w0.356: v1(15.14,40.98) 15.48,40.64 QA3.1 ; QA3.4 16.78,36.6 v1(16.75,36.57)
  BOTTOM w0.508: RA2.2 14.41,36.2 14.72,35.9 v1(15.05,35.9) ; v1(27.67,37.24) 27.87,37.45 27.87,38.36 27.24,39 CA18.2 ; v7(13.52,33.1) RA51.1 ; v1(23.47,45.8) 23.47,46.38 CA13.2 24.41,46.49 CA20.1
  vias: v1(5.29,37.42) v1(19.09,36.91) v1(22.07,44.58) v3(6.36,35.69) v3(7.54,32.67) v3(7.84,35.6) v3(9.56,34.3) v3(12.44,33.47) v3(12.74,34.7) v3(13.57,30.26) v3(14.17,30.99) v3(23.11,36.58) v7(6.98,33.1) v7(7.94,33.1) v7(8.98,35.64) v7(9.32,34.74) v7(9.32,33.73)
GND: length 2850.9
  TOP w0.102: v1(138.96,65.84) v8(138.96,66.44) ; v1(20.89,112.99) 20.17,112.99 v8(20.15,113.01) ; v8(33.53,57.13) 32.89,57.13 v1(32.78,57.24) ; v1(180.68,109.16) 180.71,109.13 v8(181.34,109.13) ; v1(231.52,73.22) v8(231.52,73.82) ; v8(20.89,88.63) 21.6,88.63 v1(21.64,88.67) ; CH67.2 251.07,32.57 v8(250.79,32.29)
  TOP w0.203: UI5.19 25.51,62.75 v1(25.46,62.8) ; UE1.N13 v3(167.78,21.12) ; v1(164.59,15.69) 164.77,15.52 164.77,15.17 UE1.G2 ; v1(165.3,18.22) 165.72,18.22 UE1.J8 UE1.J9 UE1.J10 ; v1(32.95,99.92) 32.86,99.92 32.64,99.7 U22.15 ; v3(30.55,96.5) 30.57,96.51 U22.8 ; v1(26.08,100.1) U22.35
  TOP w0.254: RPH9.1 268.87,12.17 v3(268.97,12.07) ; UN2.16 v3(226.96,65.29) ; QZ17.1 205.34,67.4 v3(205.17,67.57) ; RPH9.2 268.98,12.67 v3(269,12.66) ; v3(225.36,61.73) 225.63,62 UN2.5 ; v3(138.7,97.57) 138.7,97.89 138.85,98.05 JXDP.1 140.78,98.05 140.9,97.92 v3(140.9,97.61) ; UN2.12 v3(229.73,63.5) ; UN2.13 v3(229.73,64) ; RPH12.5 219,77.83 v3(219.22,77.61) 219.5,77.89 RPH12.6 ; 20.06,21.6 19.67,21.99 U12.44 ; RPH12.8 220.5,77.85 v3(220.21,77.56) 220,77.77 RPH12.7 ; QN2.4 228.74,58.89 229.04,59.19 v3(229.04,59.44) ; UN2.10 229.97,62.5 v1(230.06,62.59) ; JXDP.49 138.6,110.05 v1(138.25,109.7) ; JXDP.26 v3(135.47,104.05) ; v3(145.6,21.66) 145.43,21.49 UE36.12 ; UN2.15 v3(227.46,65.29)
  TOP w0.279: v3(135.13,97.48) 135.19,97.54 135.19,97.92 135.07,98.05 JXDP.2 ; JXDP.20 133.03,102.55 133.02,102.56 v1(132.27,102.56) ; JXDP.60 132.71,112.55 v1(132.6,112.65) ; v1(132.44,100.57) 132.92,101.05 JXDP.14 ; v1(138.36,104.27) 138.59,104.05 JXDP.25 ; JXDP.59 141.24,112.55 141.44,112.74 v1(141.44,113.16) ; v1(141.69,102.47) 141.62,102.55 JXDP.19 ; v1(138.17,107.7) 138.3,107.58 138.3,107.49 138.74,107.05 JXDP.37 ; v1(138.3,105.55) JXDP.31 ; v1(132.6,99.55) JXDP.8 ; JXDP.38 135.4,107.05 v1(135.7,106.75) ; v1(141.65,100.69) 141.65,100.69 141.29,101.05 JXDP.13 ; v1(141.61,99.43) 141.5,99.55 JXDP.7 ; v1(132.59,110.3) 132.84,110.05 JXDP.50 ; v1(135.63,105.68) 135.5,105.55 JXDP.32
  TOP w0.356: JMDP.19 13.61,94.41 v1(13.75,94.56)
  TOP w0.381: U1.9 200.65,14.93 v1(201.08,15.36) 200.86,15.58 U1.8 ; U1.3 201.08,18.83 v1(201.17,18.74) 200.61,18.18 U1.4 ; v3(215.85,60.42) 215.69,60.42 215.28,60.83 QZ2.1 ; v3(207.77,13.58) 206.86,13.58 206.82,13.63 U1.18 ; QZ5.1 213.26,59.46 213,59.72 v1(213,60.08) ; v3(264.78,11.56) 264.37,11.56 264.08,11.28 UH5.3 ; UH4.3 244.02,43.97 243.43,43.38 242.23,43.38 v1(241.85,43) ; v1(206.88,66.24) 207.02,66.1 QZ17.4 ; QZ2.4 v1(211.83,62.13) ; U1.1 200.98,20.13 v1(201.36,19.76) 201.08,19.48 U1.2 ; U1.11 200.55,13.63 v1(201.43,12.75) ; JMDP.13 10.41,92.61 v1(10.04,92.25) ; QN2.1 229.65,57.59 229.4,57.34 v1(229.4,56.35) ; QZ5.4 v1(214.56,58.16)
  TOP w0.406: v1(13.9,104.72) DV5.3 ; v1(13.97,108.08) DV4.3 ; PU202.2 112.01,17.03 v1(111.89,16.91)
  TOP w0.457: v1(170.75,81.59) 170.87,81.48 CU172.2 ; v1(270.51,23.87) 270.51,24.57 RH170.1 ; RH169.1 263.31,22.63 v1(264,23.33) ; CU195.2 157.78,82.32 158.17,81.93 v1(158.17,81.53) 158.18,81.54 CU196.2 CU197.2 ; v1(275.78,21.46) 275.85,21.39 CH4.2 ; v1(265.31,33.22) 265.71,33.63 CH105.2 ; CU171.2 169.31,81.48 v1(169.39,81.55) ; v1(192.78,125.46) 192.75,125.46 192.3,125.9 PR602.1 ; v1(166.47,81.43) 166.47,82.56 CU170.2
  TOP w0.508: C14.2 v1(218.31,24.46) ; v1(259.92,28.21) 259.92,27.98 CH76.2 ; CV588.2 211.5,100.48 v1(212.13,101.1) ; PR350.2 54.74,32.4 v1(54.85,32.29) ; CD31.2 219.71,27.04 v1(218.45,28.3) ; v1(18.1,18.74) 18.41,19.06 RA75.2 ; v1(162.48,90.57) 163.27,90.57 163.29,90.59 PC974.2 ; v1(140.31,79.76) 139.69,79.76 139.2,79.28 RU59.2 RU58.2 ; PC943.2 214.4,86.42 v1(214.4,86.87) ; CZ601.2 254.1,52.74 CH99.2 v1(253.44,52.76) ; PC506.2 231.84,67.19 v1(231.77,67.25) ; v1(214.82,24.46) 214.82,24.37 215.01,24.18 C16.2 ; v1(259.91,37.48) 259.76,37.33 259.76,36.97 CH46.2 ; v1(253.55,84.98) 254.2,84.98 CV712.2 ; CH72.2 259.5,30.52 v1(259.5,30.17) ; v1(252.58,106.05) 252.58,105.65 252.22,105.29 RV392.1 ; CV580.2 210.78,91.42 v1(211.32,91.96) 210.74,92.54 CV582.2 ; CV661.2 226.33,115.25 v1(226.3,115.27) ; CV701.2 v1(255.69,77.29) ; v1(152.78,99.13) 153.23,98.68 PC926.2 PC904.2 PC908.2 ; v3(257.67,11.09) CM22.2 ; PC990.2 220.23,92.87 v1(220.19,92.91) ; v1(162.48,92.6) 163.18,92.6 163.2,92.62 PC976.2 ; v1(256.09,37.35) 255.45,36.71 CH68.2 ; PR305.1 v1(43.78,35.72) ; CD8.2 132.86,35.06 v1(132.04,35.88) ; v1(216.7,126.47) 216.29,126.88 CV653.2 CV654.2 ; v1(169.04,36.64) 169.23,36.64 169.66,36.22 CD21.2 169.16,34.37 CD22.2 ; v9(190.82,124.66) 191.37,124.1 PC605.1 ; v1(220.25,88.91) 220.19,88.97 CV604.2 ; PC931.2 150,81.41 v1(148.59,81.41) ; v1(207.9,83.51) 207.96,83.57 RV479.2 ; v1(217.93,100.34) 218.11,100.16 CV592.2 218.11,98.71 PC938.2 ; QV23.3 212.47,127.64 v1(211.96,128.15) ; PC975.2 163.29,94.65 163.27,94.64 v1(162.48,94.64) ; v1(266.7,35) 266.62,34.92 CH110.2 ; CV570.2 210.69,87.13 v1(210.25,87.57) 209.8,87.13 CV569.2 ; RV355.2 CV650.2 v1(230.38,120.85) ; CV676.2 CV668.2 203.71,126.72 v1(203.48,126.5) ; v1(212.02,28.27) 212.05,28.24 CD32.2 ; CV745.2 23.81,97.73 v1(23.37,97.29) 23.87,96.78 CV772.2 ; PC913.2 213.46,93.86 v1(212.4,94.93) 212.07,95.26 PC914.2 211.43,95.77 v1(211.38,95.82) ; CV659.2 v1(226.25,128.21) ; v1(253.43,50.55) 253.03,50.16 RZ601.2 ; CD24.2 183.97,33.29 v1(184.9,32.37) ; CV612.2 v1(199.13,103.96) ; v1(169.45,92.73) 170.23,92.73 170.25,92.75 PC980.2 ; v1(224.66,90.24) 224.74,90.16 CV609.2 ; CV658.2 v1(225.25,128.21) ; CH98.2 262.03,32.08 v1(261.74,31.79) 261.9,31.63 CH78.2 ; v1(109.79,32.52) 109.87,32.44 CD2.2 ; CV732.2 244.77,101.1 v1(244.59,101.28) ; PC910.2 218.42,88.98 v1(218.31,88.88) ; v1(242.2,92.03) 242.05,92.18 CV706.2 ; v1(264.02,24.99) 263.49,24.99 CH89.2 ; v1(162.48,85.05) 163.27,85.05 163.29,85.07 PC972.2 ; CV606.2 218.96,103.44 219.55,102.85 v1(219.63,102.85) ; R2533.2 28.6,75.19 29.38,75.97 v1(29.57,75.97) 30.18,75.97 C2021.2 ; v1(20.89,105.44) 21.8,104.53 SW1.2 ; QV22.3 228.58,118.96 229.43,119.81 CV776.2 v1(230.31,119.96) ; v1(160.88,80.68) 160.88,81.36 CU198.2 CU199.2 ; CZ7.2 215.58,64.14 v1(215.9,64.46) ; v1(264.18,39.06) 264.2,39.09 CH106.2 ; v1(223.71,96.02) 222.73,95.04 PC958.2 ; CT22.1 96.14,42.62 v1(95.95,42.81) ; QV25.3 v1(255.41,96.07) ; v1(280.61,23.33) 280.36,23.33 280,23.69 CH92.2 CH90.2 ; RH138.1 271.65,39.4 v1(272.11,38.94) ; RV340.2 203.59,115.94 v1(203.47,116.07) ; PC905.2 149.95,98.01 v1(148.35,98.01) ; PC969.2 163.29,88.56 163.27,88.54 v1(162.48,88.54) ; CV3512.2 v1(232.25,111.28) 231.91,111.62 CV639.1 ; v1(219.64,67.09) RV314.1 RV315.1 ; PC944.2 216.3,86.58 v1(216.3,86.87) ; v1(256.86,21.11) 257.5,20.47 CH87.2 ; v1(255.38,83.45) 255.14,83.69 CV693.2 ; CV704.2 241.98,82 v1(242,82.02) 242.13,82.15 CV707.2 ; RA60.2 12.38,26.5 v1(12.24,26.36) ; CD19.2 CD20.2 v1(174.94,26.23) ; v1(219.07,126.51) 218.99,126.6 CV651.2 RV356.2 ; v1(14.31,33.57) 14.68,33.57 15.17,33.08 DA3.1 ; CV611.2 209.48,101.05 208.91,100.48 CV610.2 208.1,100.48 v1(207.9,100.27) ; v1(227.39,105.48) 227.28,105.6 CV594.2 ; v1(205.87,126.47) 205.87,126.8 RV369.2 ; v1(148.44,82.89) 148.71,83.16 PC933.2 ; CV738.2 242,101.68 v1(242.05,101.64) ; CH64.2 273.49,27.38 v3(273.09,27.78) ; CD17.2 CD18.2 v1(174.13,32.95) ; v1(151.59,24.78) 151.49,24.88 CD16.2 ; CV711.2 253.27,87.74 252.75,87.22 v1(252.58,87.22) ; CV683.2 208.47,117.04 v1(209.04,117.61) ; v1(27.99,19.41) YA2.4 ; v1(123.44,12.61) 123.61,12.44 PC410.2 ; v1(253.38,90.45) 253.42,90.41 CV713.2 ; v1(221.23,67) 221.42,67.19 RV310.1 ; CD26.2 208.28,27.99 v1(208.59,28.3) ; CA79.2 20.06,20.47 v1(20.06,21.09) 20.06,21.6 ; CH3.2 v3(278.54,21.45) ; QV24.3 v1(249.96,77.96) ; CD34.2 220.6,35.34 v1(220.18,35.75) ; v1(168.43,87.02) 169.11,87.02 169.13,87.03 PC977.2 ; v1(15.86,110.5) CV796.1 ; v1(242.04,109.68) 242.37,109.68 242.85,109.2 CV728.2 ; PC917.2 214.54,92.66 v1(214.27,92.93) ; CV718.2 255.71,102.76 RV395.2 CV726.2 v1(255.76,101.11) ; CU201.2 163.05,81.99 CU200.2 163.05,81.25 CU169.2 161.96,80.82 v1(161.82,80.68) ; v1(225.53,123.26) 225.53,122.79 CV656.2 ; PC935.2 155.76,98.58 v1(155.76,100.77) ; CD9.2 v1(142.56,35.95) ; v1(253.4,92.86) 254.36,92.86 CV702.2 ; v1(153.36,80.81) 153.41,80.86 CU174.2 154.38,82.63 PC930.2 ; CV599.2 207.5,106.15 v1(207.12,106.53) 206.5,106.53 206.3,106.33 CV598.2 ; QV30.3 79.9,33.58 79.56,33.92 v1(79.56,34.87) ; PC968.2 163.16,86.78 163.14,86.76 v1(162.48,86.76) ; CV591.2 222.71,98.16 v1(222.25,98.62) ; v1(218.29,86.87) 218.29,86.5 PC941.2 ; CV655.2 v1(223.47,128.22) ; PC919.2 214.48,95.02 v1(214.4,94.95) ; v1(229.93,108.15) 229.95,108.17 CV637.2 ; CV3508.2 84.67,40 v1(85.41,39.26) ; RH154.2 241.8,43.05 v1(241.85,43) ; CV733.2 252.03,112.91 v1(251.65,113.29) ; CV710.2 253.55,81.68 v1(253.49,81.74) ; v1(19.25,34.13) 18.96,34.42 CA91.2 ; CH103.2 267.29,37.09 266.9,37.47 CH30.2 266.59,37.22 v1(266.59,36.84) ; RZ485.2 v1(248.87,55.38) ; v1(155.24,80.73) 155.75,81.24 CU194.2 CU193.2 ; U4.2 91.9,43 CT44.2 v1(91.25,43.01) ; v1(169.54,84.08) 169.67,84.08 170.34,83.41 PC973.2 ; v1(70.4,26.3) 70.7,26 PC202.2 PC203.2 ; CD5.2 146.05,35.46 v1(146.47,35.88) ; CM11.2 281.29,41.3 v1(280.92,41.66) ; CH38.2 263.39,28.45 v1(263.33,28.39) 263.27,28.46 CH95.2 ; PC909.2 148.93,95.03 v1(148.44,94.54) ; CH73.2 264.1,26.26 v1(264.04,26.2) ; PC963.2 219.55,95.64 v1(220.2,94.99) ; RH143.2 274.33,30.69 273.81,30.17 v1(272.89,30.17) 272.57,30.48 CH100.2 ; RV459.2 25.37,99.44 26.03,100.1 v1(26.08,100.1) ; v1(148.37,87.07) 149.17,87.07 149.38,87.28 HU101.2 ; PR302.1 46.86,35.32 v1(46.54,35.63) ; RH322.2 260.61,39.35 v1(260.92,39.04) ; v1(138.37,35.88) 138.81,35.44 CD12.2 ; PC981.2 170.27,94.78 170.25,94.76 v1(169.45,94.76) ; v1(140.31,74.98) 139.36,74.98 139.2,75.13 RU61.2 ; CV643.2 v1(222.38,128.21) ; v1(217.18,27.92) 216.28,27.02 CD30.2 ; CD28.2 207.33,33.53 v1(206.66,32.87) ; CV662.2 215.87,114.89 v1(215.87,115.25) ; v1(23.7,103.2) CV756.2 ; PC934.2 v1(171.24,96.29) ; v1(211.81,35.75) 211.64,35.58 CD35.2 ; QZ18.3 v1(251.74,54.55) ; v1(216.3,88.87) 216,89.17 PC916.2 ; QH6.3 v1(255.59,57.11) ; v1(134.97,35.88) 135.32,35.53 CD6.2 ; RH35.2 265.49,22.44 266.06,23.01 v1(266.05,23.01) ; v1(243.79,98.88) 243.19,99.47 CV727.2 ; SW2.1 3.17,34.92 2.91,35.19 2.37,35.19 v1(2.32,35.14) ; CE20.1 v1(151.4,19.83) ; v1(244.59,82.44) 244.5,82.53 CV705.2 ; CD38.2 v1(225.31,24.63) ; CV663.2 224.55,115.12 v1(224.7,115.27) ; v1(168.43,85.11) 169.24,85.11 169.26,85.13 PC982.2 ; PC407.1 127.05,11.53 126.58,11.06 v1(125.9,11.06) ; RE12.2 159.26,24.32 v1(158.81,24.77) 159.25,25.21 CE12.2 ; PC936.2 217.88,95.31 v1(218.2,94.99) ; v1(249.43,106.87) 249.14,106.59 CV729.2 ; v1(251.84,87.27) 251.76,87.34 RV379.1 ; CV583.2 CV584.2 203.16,105.83 v1(202.94,106.05) ; CD25.2 v1(220.91,28.01) ; CA65.2 RA59.1 15.62,19.38 v1(15.43,19.18) ; v1(196.66,14.55) 197.09,14.12 C3.2 ; v1(222.14,100.38) 222.31,100.21 CV605.2 ; v1(198.67,115.27) 199.25,115.27 199.92,114.6 CV687.2 ; v1(251.79,84.04) 252.15,84.41 CV703.2 ; RV311.1 223.24,67.29 v1(223.01,67.06) ; CV734.2 v1(252.73,94.97) ; v1(244.98,27.57) 245.04,27.63 CD40.2 CD39.2 ; RH30.2 167.14,100.21 v1(166.83,100.52) ; RV394.2 CV789.2 CV725.2 v1(249.08,114.92) ; RE43.1 164.78,24.28 v1(165.29,24.79) 165.73,24.34 CE14.1 ; v1(273.66,24.65) 273.98,24.96 RH244.1 274.45,24.76 274.45,24.23 CH91.2 ; CA78.1 21.46,20.01 v1(21.02,20.45) ; PC942.2 v1(215.43,85.42) ; CA67.2 21.99,17.66 v1(21.99,16.72) ; v1(211.27,90.09) 210.84,90.53 CV581.2 ; v1(14.65,19.44) CA63.2 ; v1(10.77,87.13) 10.08,86.45 C18.2 10.07,86.13 C17.2 ; CA56.2 8.25,8.3 v1(7.91,7.96) ; CD33.2 216.15,36.85 v1(216.11,36.9) ; v1(263.06,36.26) 262.97,36.17 CH61.2 263.13,35.65 263.89,34.88 CH111.2 ; v1(216.61,56.41) QZ19.3 ; PC252.2 115.07,14.94 114.55,14.42 v1(114.35,14.42) PC109.2 ; RV382.2 v1(252.28,78.91) ; v1(15.9,111.75) 15.6,111.45 CV795.1 CV768.1 ; v1(225.51,101.12) 224.94,100.55 CV638.2 RV343.2 224,100.93 v1(223.77,101.16) ; CV657.2 219.09,114.75 v1(219.09,115.26) ; v1(64.58,24.65) 65.04,25.11 PQ202.3 ; RU44.1 173.16,94.73 v1(173.64,95.21) ; CV737.2 241.37,108.21 241.97,108.21 v1(242.07,108.11) ; v1(216.3,92.91) 215.88,93.34 PC918.2 ; PC978.2 169.13,88.94 169.11,88.92 v1(168.43,88.92) ; v1(35.28,35.06) 35.28,35.07 CA3.2 ; PR225.2 83.15,24.42 v1(82.95,24.23) ; v1(245.68,39.25) 245.43,39 CD44.2 ; v1(182.81,14.55) 183.37,13.99 QE1.3 185.18,13.99 185.49,14.31 RE44.2 ; CV596.2 CV595.2 210.64,96.71 v1(210.37,96.97) ; v1(113.85,17.89) 113.42,18.32 PR280.1 ; v1(245.11,30.61) CD41.2 CD42.2 ; v1(206.88,21.79) 206.88,20.75 207.17,20.45 C6.2 ; CH94.2 267.49,27.78 v1(267.28,27.58) ; PC912.2 212.13,91.21 v1(212.46,90.87) ; CV686.2 206.67,114.79 v1(206.67,115.27) ; v1(207.47,126.47) 207.53,126.53 CV679.2 ; v1(222.44,82.18) 222.05,81.78 CV621.2 CV619.2 ; PC940.2 212.4,86.68 v1(212.4,86.87) ; CV680.2 206.7,122.43 v1(206.67,122.47) ; v1(242.95,55.19) 242.76,55.38 RZ472.1 ; v1(242.99,90.48) 242.81,90.48 242.29,89.96 CV708.2 ; v1(218.3,91) 217.42,91.88 PC961.2 ; v1(142.21,108.17) 142.94,108.9 RU99.2 ; PC962.2 220.33,91.14 v1(220.14,90.95) ; CM12.2 281.1,13.71 CM13.2 281.75,13.7 v1(281.76,13.71) ; v1(22.16,21.48) 22.16,20.85 CA80.2 ; CV589.2 224.53,86.19 v1(224.67,86.06) ; v1(262.06,26.3) 262.3,26.53 CH88.2 ; v1(168.43,90.83) 169.21,90.83 169.23,90.84 PC979.2 ; CV736.2 251.79,97.41 v1(251.79,98.08) ; CD43.2 244.22,32.95 v1(244.27,32.9) 243.83,32.45 RD16.1 ; CV597.2 v1(210.25,97.99) ; CV731.2 250.84,100.63 v1(250.99,100.48) ; CD27.2 222.44,35.52 v1(222.2,35.75) ; PC970.2 v1(165.99,94.63) ; RV312.1 v3(223.58,71.94) ; v1(81.34,34.87) 81.34,36.15 CV752.2 ; R2535.2 27.28,76.33 v1(28.06,77.1) ; CV735.2 v1(254.33,113.76) ; YA2.2 v1(23.51,21.11) ; PC907.2 v1(163.24,96.29) ; CU192.2 151.64,81.48 v1(151.54,81.48) ; v1(26.4,23.45) 26.4,23.4 27.06,22.74 CA96.2 ; RV414.2 241.64,103.46 v1(242.04,103.86) 242.1,103.79 CV730.2 ; RI6.2 32.35,61.23 v1(32.78,60.79) ; DA5.1 6.18,7.02 5.78,7.42 v1(5.78,8.34) 6.28,8.85 CA57.2 ; CM31.2 v3(252.68,12.86) ; v1(266.6,24.92) 265.9,24.92 CH54.2 ; v1(148.46,91.58) 148.72,91.85 RU77.2 ; v1(3.17,31.42) SW2.2 ; PC928.2 v1(167.18,96.29) ; RD9.1 RD8.1 v3(174.13,37.41) ; CU173.2 168.53,82.21 CU171.2 ; v1(221.45,93.96) 221.83,93.96 CV608.2 222.18,92.73 CV607.2 ; v1(38.35,35.25) 38.27,35.16 CN7.2 ; CV778.2 v1(249.43,95.18) ; U5.1 v1(5.5,84.67) ; v1(226.3,118.47) 226.63,118.8 CV652.2 ; v1(205.07,115.27) 205.1,115.23 CV684.2 ; v1(223.96,122.37) 223.98,122.36 RV353.1 ; PC959.2 223.62,91.69 CV636.2 v1(223.77,92.59) ; PC903.2 PC929.2 v1(161.21,96.13) ; CE322.2 v1(172.43,12.71) ; v1(126.68,123.58) PC726.2 ; v1(222.87,119.44) 222.87,120.02 CV660.2 ; v3(197.29,18.45) v3(197.29,17.56) ; HT4.2 v1(189.01,80.91) ; CH12.2 v1(259.52,56.33) ; PQ103.3 v1(111.81,12.41)
  GND1 w0.102: 155.57,14.24 155.13,14.24
  GND1 w0.203: 13.21,62.25 JUSB1.11 ; JUSB1.11 14.72,63.97 ; JUSB1.11 14.72,63.11 ; JUSB1.11 14.72,62.25 ; JUSB1.11 13.21,63.97 ; H12.1 152.68,12.45 ; H12.1 149.76,11.21 ; H12.1 152.24,11.21 ; H12.1 152.24,13.69 ; H12.1 151,14.13 ; H12.1 151,10.77 ; H12.1 149.32,12.45 ; H12.1 149.76,13.69 ; 113.3,124.82 H13.1 ; H13.1 114.54,127.74 ; H13.1 114.98,126.5 ; H13.1 111.62,126.5 ; H13.1 112.06,127.74 ; H13.1 113.3,128.18 ; H13.1 112.06,125.26 ; H13.1 114.54,125.26 ; 12.96,72.35 JUSB3.4 ; JUSB3.4 12.96,71.07 ; JUSB3.4 13.6,72.55 ; JUSB3.4 14.24,72.35 ; JUSB3.4 13.6,70.87 ; JUSB3.4 12.76,71.71 ; 20.63,67.17 H11.1 ; H11.1 22.97,64.83 ; H11.1 20.63,64.83 ; H11.1 22.97,67.17 ; H11.1 21.8,64.41 ; H11.1 21.8,67.59 ; H11.1 23.39,66 ; H11.1 20.21,66 ; 8.85,90.25 JMDP.8 ; JMDP.8 8.73,90.71 ; JMDP.8 9.77,91.18 ; JMDP.8 8.85,91.18 ; JMDP.8 9.77,90.25 ; JMDP.8 9.89,90.71 ; JMDP.8 9.31,91.3 ; 9.99,108.2 JHDMI.8 ; JHDMI.8 11.03,108.66 ; JHDMI.8 10.11,108.66 ; JHDMI.8 11.03,107.74 ; JHDMI.8 10.11,107.74 ; JHDMI.8 11.15,108.2 ; 282.24,24.12 JSSD.18 ; JSSD.18 283.12,24.12 ; JSSD.18 282.24,24.6 ; 288.54,40.75 JSSD.53 ; JSSD.53 288.54,41.32 ; JSSD.53 289.77,41.32 ; H4.1 192.97,106.89 ; H4.1 192.97,103.55 ; H4.1 189.63,103.55 ; H4.1 191.3,102.93 ; H4.1 189.63,106.89 ; H4.1 193.59,105.22 ; H4.1 191.3,107.51 ; H4.1 189.01,105.22 ; JUSB1.14 14.72,49.45 ; JUSB1.14 13.21,51.17 ; JUSB1.14 13.21,49.45 ; JUSB1.14 14.72,50.31 ; 282.24,31.24 JSSD.34 ; JSSD.34 282.24,31 ; JSSD.34 282.24,30.76 ; JUSB3.12 4.13,83.97 ; JUSB3.12 2.62,83.97 ; JUSB3.12 4.13,83.11 ; JUSB3.12 1.11,83.11 ; JUSB3.12 1.11,83.97 ; 11.31,109.24 JHDMI.11 ; JHDMI.11 12.23,109.24 ; JHDMI.11 12.23,110.16 ; JHDMI.11 11.31,110.16 ; JHDMI.11 11.19,109.7 ; JHDMI.11 12.35,109.7 ; H6.1 152.52,67.39 ; H6.1 150.78,66.74 ; H6.1 154.26,63.26 ; H6.1 150.78,63.26 ; H6.1 154.26,66.74 ; H6.1 152.52,62.61 ; H6.1 150.13,65 ; H6.1 154.91,65 ; JMDP.23 4.03,85.44 ; JMDP.23 2.7,85.44 ; JMDP.23 1.37,86.21 ; JMDP.23 4.03,86.21 ; JMDP.23 1.37,85.44 ; 10.44,117.43 JHDMI.20 ; JHDMI.20 11.77,115.47 ; JHDMI.20 10.44,115.47 ; JHDMI.20 13.1,115.47 ; JHDMI.20 11.77,117.43 ; JHDMI.20 13.1,117.43 ; JHDMI.20 10.44,116.45 ; JHDMI.20 13.1,116.45 ; 252.13,127.67 H9.1 ; H9.1 254.89,126.5 ; H9.1 253.3,128.09 ; H9.1 254.47,127.67 ; H9.1 252.13,125.33 ; H9.1 251.71,126.5 ; H9.1 254.47,125.33 ; H9.1 253.3,124.91 ; JHDMI.21 5.53,119.18 ; JHDMI.21 2.87,119.18 ; JHDMI.21 4.2,119.18 ; JHDMI.21 2.87,118.2 ; JHDMI.21 5.53,118.2 ; H2.1 17.47,116.83 ; H2.1 16.3,119.59 ; H2.1 15.13,116.83 ; H2.1 17.47,119.17 ; H2.1 14.71,118 ; H2.1 16.3,116.41 ; H2.1 15.13,119.17 ; 1.11,66.45 JUSB3.13 ; JUSB3.13 2.62,66.45 ; JUSB3.13 4.13,66.45 ; JUSB3.13 1.11,67.31 ; JUSB3.13 4.13,67.31 ; H16.1 216.84,11.21 ; H16.1 214.36,11.21 ; H16.1 215.6,14.13 ; H16.1 217.28,12.45 ; H16.1 215.6,10.77 ; H16.1 213.92,12.45 ; H16.1 216.84,13.69 ; H16.1 214.36,13.69 ; 12.76,53.21 JUSB1.4 ; JUSB1.4 12.96,53.85 ; JUSB1.4 13.6,54.05 ; JUSB1.4 14.24,53.85 ; JUSB1.4 13.6,52.37 ; JUSB1.4 12.96,52.57 ; JHDMI.5 12.23,106.24 ; JHDMI.5 12.23,107.16 ; JHDMI.5 11.31,106.24 ; JHDMI.5 11.31,107.16 ; JHDMI.5 12.35,106.7 ; JHDMI.5 11.19,106.7 ; JMDP.14 9.77,93.18 ; JMDP.14 9.31,92.13 ; JMDP.14 8.73,92.71 ; JMDP.14 8.85,93.18 ; JMDP.14 9.89,92.71 ; JMDP.14 9.77,92.25 ; JMDP.14 8.85,92.25 ; 235.28,121.52 H8.1 ; H8.1 236.8,122.08 ; H8.1 236.8,117.92 ; H8.1 238.32,118.48 ; H8.1 238.32,121.52 ; H8.1 234.72,120 ; H8.1 235.28,118.48 ; H8.1 238.88,120 ; 237.07,70 H15.1 ; H15.1 237.63,71.52 ; H15.1 240.67,71.52 ; H15.1 241.23,70 ; H15.1 239.15,72.08 ; H15.1 239.15,67.92 ; H15.1 237.63,68.48 ; H15.1 240.67,68.48 ; 282.24,37.64 JSSD.50 ; JSSD.50 282.24,37.4 ; JSSD.50 282.24,37.16 ; JUSB3.11 14.72,81.61 ; JUSB3.11 13.21,82.47 ; JUSB3.11 14.72,82.47 ; JUSB3.11 13.21,80.75 ; 14.46,57.35 JUSB1.7 ; JUSB1.7 15.94,56.71 ; JUSB1.7 15.74,57.35 ; JUSB1.7 14.26,56.71 ; JUSB1.7 15.74,56.07 ; JUSB1.7 14.46,56.07 ; JUSB1.7 15.1,57.55 ; JUSB1.7 15.1,55.87 ; JMDP.24 9.88,87.76 ; JMDP.24 9.88,88.54 ; JMDP.24 8.51,86.99 ; 282.24,15.8 JSSD.4 ; JSSD.4 282.24,16.04 ; JSSD.4 282.24,15.56 ; JMDP.22 4.03,97.99 ; JMDP.22 4.03,97.21 ; JMDP.22 1.37,97.21 ; JMDP.22 2.7,97.99 ; JMDP.22 1.37,97.99 ; 10.57,104.62 JHDMI.2 ; JHDMI.2 11.03,104.74 ; JHDMI.2 10.11,104.74 ; JHDMI.2 11.15,105.2 ; JHDMI.2 11.03,105.66 ; JHDMI.2 10.11,105.66 ; JHDMI.2 9.99,105.2 ; 282.24,33.16 JSSD.40 ; JSSD.40 282.24,33.4 ; JSSD.40 282.24,33.64 ; JUSB1.13 4.13,47.95 ; JUSB1.13 1.11,47.95 ; JUSB1.13 1.11,48.81 ; JUSB1.13 2.62,47.95 ; JUSB1.13 4.13,48.81 ; 189.01,75.5 H5.1 ; H5.1 193.59,77.98 ; H5.1 189.01,73.02 ; H5.1 193.59,73.02 ; H5.1 189.01,77.98 ; H5.1 191.3,77.98 ; H5.1 193.59,75.5 ; H5.1 191.3,73.02 ; JHDMI.23 11.77,102.93 ; JHDMI.23 11.77,100.97 ; JHDMI.23 13.1,100.97 ; JHDMI.23 13.1,101.95 ; JHDMI.23 10.44,101.95 ; JHDMI.23 10.44,100.97 ; JHDMI.23 10.44,102.93 ; JHDMI.23 13.1,102.93 ; JUSB3.7 15.1,76.05 ; JUSB3.7 14.46,75.85 ; JUSB3.7 15.1,74.37 ; JUSB3.7 14.46,74.57 ; JUSB3.7 15.74,74.57 ; JUSB3.7 15.94,75.21 ; JUSB3.7 14.26,75.21 ; JUSB3.7 15.74,75.85 ; JUSB3.14 13.21,69.67 ; JUSB3.14 14.72,69.67 ; JUSB3.14 14.72,67.95 ; JUSB3.14 13.21,67.95 ; JUSB3.14 14.72,68.81 ; 1.11,65.47 JUSB1.12 ; JUSB1.12 4.13,64.61 ; JUSB1.12 4.13,65.47 ; JUSB1.12 1.11,64.61 ; JUSB1.12 2.62,65.47 ; JMDP.21 9.88,96.44 ; JMDP.21 9.88,95.66 ; JMDP.21 8.51,96.44 ; JMDP.21 9.88,94.89 ; 150.13,115.72 H3.1 ; H3.1 150.78,117.46 ; H3.1 150.78,113.98 ; H3.1 154.26,113.98 ; H3.1 152.52,118.11 ; H3.1 154.26,117.46 ; H3.1 154.91,115.72 ; H3.1 152.52,113.33 ; JHDMI.17 12.23,112.24 ; JHDMI.17 11.31,113.16 ; JHDMI.17 12.23,113.16 ; JHDMI.17 11.19,112.7 ; JHDMI.17 12.35,112.7 ; JHDMI.17 11.31,112.24 ; JHDMI.22 5.53,99.22 ; JHDMI.22 2.87,100.2 ; JHDMI.22 4.2,99.22 ; JHDMI.22 2.87,99.22 ; JHDMI.22 5.53,100.2 ; 282.24,27.56 JSSD.26 ; JSSD.26 282.24,28.04 ; JSSD.26 282.24,27.8 ; 288.54,12.05 JSSD.54 ; JSSD.54 289.77,11.48 ; JSSD.54 288.54,11.48
  IN1 w0.508: v1(14.31,33.57) 14.27,33.57 13.3,32.6 v1(11.49,32.6) 11.48,32.58 7.49,32.58 6.49,31.58 6.49,29.32 5.88,28.71 v1(5.01,28.71)
  IN2 w0.508: v1(14.31,33.57) 15.7,33.57 16.57,34.45 18.93,34.45 v1(19.25,34.13)
  GND2 w0.203: 1.11,83.97 JUSB3.12 ; JUSB3.12 2.62,83.97 ; JUSB3.12 4.13,83.11 ; JUSB3.12 4.13,83.97 ; JUSB3.12 1.11,83.11 ; 10.44,116.45 JHDMI.20 ; JHDMI.20 11.77,115.47 ; JHDMI.20 13.1,116.45 ; JHDMI.20 11.77,117.43 ; JHDMI.20 13.1,117.43 ; JHDMI.20 10.44,117.43 ; JHDMI.20 10.44,115.47 ; JHDMI.20 13.1,115.47 ; H3.1 154.26,117.46 ; H3.1 152.52,113.33 ; H3.1 150.78,113.98 ; H3.1 152.52,118.11 ; H3.1 154.26,113.98 ; H3.1 150.78,117.46 ; H3.1 154.91,115.72 ; H3.1 150.13,115.72 ; 9.31,92.13 JMDP.14 ; JMDP.14 8.85,92.25 ; JMDP.14 9.77,92.25 ; JMDP.14 8.73,92.71 ; JMDP.14 9.77,93.18 ; JMDP.14 9.89,92.71 ; JMDP.14 8.85,93.18 ; 20.63,64.83 H11.1 ; H11.1 20.21,66 ; H11.1 21.8,67.59 ; H11.1 21.8,64.41 ; H11.1 22.97,64.83 ; H11.1 23.39,66 ; H11.1 20.63,67.17 ; H11.1 22.97,67.17 ; JMDP.22 4.03,97.99 ; JMDP.22 4.03,97.21 ; JMDP.22 1.37,97.21 ; JMDP.22 1.37,97.99 ; JMDP.22 2.7,97.99 ; JUSB1.7 15.1,57.55 ; JUSB1.7 14.46,57.35 ; JUSB1.7 15.94,56.71 ; JUSB1.7 15.1,55.87 ; JUSB1.7 14.26,56.71 ; JUSB1.7 15.74,57.35 ; JUSB1.7 15.74,56.07 ; JUSB1.7 14.46,56.07 ; JHDMI.8 11.15,108.2 ; JHDMI.8 9.99,108.2 ; JHDMI.8 11.03,107.74 ; JHDMI.8 10.11,107.74 ; JHDMI.8 11.03,108.66 ; JHDMI.8 10.11,108.66 ; 2.7,85.44 JMDP.23 ; JMDP.23 4.03,85.44 ; JMDP.23 4.03,86.21 ; JMDP.23 1.37,86.21 ; JMDP.23 1.37,85.44 ; 191.3,73.02 H5.1 ; H5.1 193.59,73.02 ; H5.1 189.01,75.5 ; H5.1 189.01,73.02 ; H5.1 189.01,77.98 ; H5.1 193.59,77.98 ; H5.1 191.3,77.98 ; H5.1 193.59,75.5 ; JUSB1.11 13.21,63.97 ; JUSB1.11 14.72,63.11 ; JUSB1.11 13.21,62.25 ; JUSB1.11 14.72,63.97 ; JUSB1.11 14.72,62.25 ; JMDP.24 9.88,87.76 ; JMDP.24 9.88,88.54 ; JMDP.24 8.51,86.99 ; 235.28,118.48 H8.1 ; H8.1 238.32,121.52 ; H8.1 235.28,121.52 ; H8.1 236.8,122.08 ; H8.1 238.32,118.48 ; H8.1 234.72,120 ; H8.1 236.8,117.92 ; H8.1 238.88,120 ; 8.73,90.71 JMDP.8 ; JMDP.8 8.85,90.25 ; JMDP.8 8.85,91.18 ; JMDP.8 9.77,91.18 ; JMDP.8 9.31,91.3 ; JMDP.8 9.89,90.71 ; JMDP.8 9.77,90.25 ; 15.1,74.37 JUSB3.7 ; JUSB3.7 15.1,76.05 ; JUSB3.7 15.94,75.21 ; JUSB3.7 15.74,75.85 ; JUSB3.7 14.26,75.21 ; JUSB3.7 15.74,74.57 ; JUSB3.7 14.46,74.57 ; JUSB3.7 14.46,75.85 ; H9.1 253.3,128.09 ; H9.1 251.71,126.5 ; H9.1 252.13,127.67 ; H9.1 252.13,125.33 ; H9.1 253.3,124.91 ; H9.1 254.89,126.5 ; H9.1 254.47,125.33 ; H9.1 254.47,127.67 ; 11.31,109.24 JHDMI.11 ; JHDMI.11 11.31,110.16 ; JHDMI.11 11.19,109.7 ; JHDMI.11 12.23,109.24 ; JHDMI.11 12.23,110.16 ; JHDMI.11 12.35,109.7 ; 215.6,10.77 H16.1 ; H16.1 213.92,12.45 ; H16.1 214.36,11.21 ; H16.1 214.36,13.69 ; H16.1 216.84,13.69 ; H16.1 217.28,12.45 ; H16.1 215.6,14.13 ; H16.1 216.84,11.21 ; H6.1 152.52,67.39 ; H6.1 154.26,63.26 ; H6.1 152.52,62.61 ; H6.1 150.78,63.26 ; H6.1 154.91,65 ; H6.1 154.26,66.74 ; H6.1 150.13,65 ; H6.1 150.78,66.74 ; JHDMI.23 13.1,102.93 ; JHDMI.23 11.77,102.93 ; JHDMI.23 11.77,100.97 ; JHDMI.23 13.1,101.95 ; JHDMI.23 13.1,100.97 ; JHDMI.23 10.44,102.93 ; JHDMI.23 10.44,100.97 ; JHDMI.23 10.44,101.95 ; JUSB1.4 13.6,54.05 ; JUSB1.4 12.76,53.21 ; JUSB1.4 12.96,52.57 ; JUSB1.4 12.96,53.85 ; JUSB1.4 13.6,52.37 ; JUSB1.4 14.24,53.85 ; JMDP.21 9.88,94.89 ; JMDP.21 8.51,96.44 ; JMDP.21 9.88,96.44 ; JMDP.21 9.88,95.66 ; 282.24,27.8 JSSD.26 ; JSSD.26 282.24,28.04 ; JSSD.26 282.24,27.56 ; 282.24,30.76 JSSD.34 ; JSSD.34 282.24,31.24 ; JSSD.34 282.24,31 ; H4.1 192.97,106.89 ; H4.1 193.59,105.22 ; H4.1 189.63,106.89 ; H4.1 189.63,103.55 ; H4.1 192.97,103.55 ; H4.1 191.3,102.93 ; H4.1 189.01,105.22 ; H4.1 191.3,107.51 ; JUSB3.11 13.21,82.47 ; JUSB3.11 13.21,80.75 ; JUSB3.11 14.72,81.61 ; JUSB3.11 14.72,82.47 ; 14.71,118 H2.1 ; H2.1 16.3,119.59 ; H2.1 17.47,119.17 ; H2.1 17.47,116.83 ; H2.1 15.13,116.83 ; H2.1 15.13,119.17 ; H2.1 16.3,116.41 ; 282.24,24.6 JSSD.18 ; JSSD.18 282.24,24.12 ; JSSD.18 283.12,24.12 ; JSSD.53 289.77,41.32 ; JSSD.53 288.54,41.32 ; JSSD.53 288.54,40.75 ; 239.15,67.92 H15.1 ; H15.1 237.63,68.48 ; H15.1 240.67,71.52 ; H15.1 237.63,71.52 ; H15.1 240.67,68.48 ; H15.1 239.15,72.08 ; H15.1 241.23,70 ; H15.1 237.07,70 ; JHDMI.2 11.03,104.74 ; JHDMI.2 10.11,105.66 ; JHDMI.2 10.11,104.74 ; JHDMI.2 11.15,105.2 ; JHDMI.2 10.57,104.62 ; JHDMI.2 11.03,105.66 ; JHDMI.2 9.99,105.2 ; JHDMI.17 12.23,113.16 ; JHDMI.17 11.31,113.16 ; JHDMI.17 11.31,112.24 ; JHDMI.17 12.35,112.7 ; JHDMI.17 11.19,112.7 ; JHDMI.17 12.23,112.24 ; 282.24,15.56 JSSD.4 ; JSSD.4 282.24,16.04 ; JSSD.4 282.24,15.8 ; 112.06,127.74 H13.1 ; H13.1 112.06,125.26 ; H13.1 111.62,126.5 ; H13.1 114.54,125.26 ; H13.1 113.3,128.18 ; H13.1 114.98,126.5 ; H13.1 113.3,124.82 ; H13.1 114.54,127.74 ; 2.87,99.22 JHDMI.22 ; JHDMI.22 2.87,100.2 ; JHDMI.22 5.53,100.2 ; JHDMI.22 5.53,99.22 ; JHDMI.22 4.2,99.22 ; 288.54,12.05 JSSD.54 ; JSSD.54 289.77,11.48 ; JSSD.54 288.54,11.48 ; 282.24,37.16 JSSD.50 ; JSSD.50 282.24,37.4 ; JSSD.50 282.24,37.64 ; 11.19,106.7 JHDMI.5 ; JHDMI.5 11.31,107.16 ; JHDMI.5 11.31,106.24 ; JHDMI.5 12.23,106.24 ; JHDMI.5 12.35,106.7 ; JHDMI.5 12.23,107.16 ; JUSB1.13 4.13,48.81 ; JUSB1.13 1.11,48.81 ; JUSB1.13 4.13,47.95 ; JUSB1.13 2.62,47.95 ; JUSB1.13 1.11,47.95 ; 2.62,66.45 JUSB3.13 ; JUSB3.13 1.11,67.31 ; JUSB3.13 4.13,67.31 ; JUSB3.13 4.13,66.45 ; JUSB3.13 1.11,66.45 ; 12.76,71.71 JUSB3.4 ; JUSB3.4 12.96,71.07 ; JUSB3.4 13.6,70.87 ; JUSB3.4 14.24,72.35 ; JUSB3.4 13.6,72.55 ; JUSB3.4 12.96,72.35 ; JUSB1.14 13.21,51.17 ; JUSB1.14 14.72,50.31 ; JUSB1.14 13.21,49.45 ; JUSB1.14 14.72,49.45 ; 149.76,13.69 H12.1 ; H12.1 149.76,11.21 ; H12.1 149.32,12.45 ; H12.1 152.24,13.69 ; H12.1 152.24,11.21 ; H12.1 151,14.13 ; H12.1 152.68,12.45 ; H12.1 151,10.77 ; JUSB3.14 14.72,68.81 ; JUSB3.14 14.72,67.95 ; JUSB3.14 13.21,69.67 ; JUSB3.14 14.72,69.67 ; JUSB3.14 13.21,67.95 ; JHDMI.21 5.53,118.2 ; JHDMI.21 4.2,119.18 ; JHDMI.21 2.87,118.2 ; JHDMI.21 5.53,119.18 ; JHDMI.21 2.87,119.18 ; 1.11,65.47 JUSB1.12 ; JUSB1.12 4.13,64.61 ; JUSB1.12 2.62,65.47 ; JUSB1.12 1.11,64.61 ; JUSB1.12 4.13,65.47 ; 282.24,33.16 JSSD.40 ; JSSD.40 282.24,33.4 ; JSSD.40 282.24,33.64
  IN4 w0.508: v4(18.98,47.48) 19.14,47.33 19.14,45.38 18.44,44.69 17.41,44.69 v6(17.21,44.89)
  GND3 w0.203: JUSB1.7 15.74,56.07 ; JUSB1.7 15.94,56.71 ; JUSB1.7 15.1,55.87 ; JUSB1.7 14.46,56.07 ; JUSB1.7 15.1,57.55 ; JUSB1.7 14.46,57.35 ; JUSB1.7 14.26,56.71 ; JUSB1.7 15.74,57.35 ; 288.54,41.32 JSSD.53 ; JSSD.53 288.54,40.75 ; JSSD.53 289.77,41.32 ; JUSB1.4 13.6,54.05 ; JUSB1.4 12.96,52.57 ; JUSB1.4 12.76,53.21 ; JUSB1.4 13.6,52.37 ; JUSB1.4 14.24,53.85 ; JUSB1.4 12.96,53.85 ; 14.46,75.85 JUSB3.7 ; JUSB3.7 15.94,75.21 ; JUSB3.7 15.1,74.37 ; JUSB3.7 14.46,74.57 ; JUSB3.7 15.1,76.05 ; JUSB3.7 14.26,75.21 ; JUSB3.7 15.74,75.85 ; JUSB3.7 15.74,74.57 ; 13.21,67.95 JUSB3.14 ; JUSB3.14 13.21,69.67 ; JUSB3.14 14.72,67.95 ; JUSB3.14 14.72,68.81 ; JUSB3.14 14.72,69.67 ; JHDMI.5 12.23,107.16 ; JHDMI.5 11.31,107.16 ; JHDMI.5 11.31,106.24 ; JHDMI.5 12.35,106.7 ; JHDMI.5 11.19,106.7 ; JHDMI.5 12.23,106.24 ; JUSB3.12 4.13,83.97 ; JUSB3.12 1.11,83.11 ; JUSB3.12 4.13,83.11 ; JUSB3.12 1.11,83.97 ; JUSB3.12 2.62,83.97 ; H6.1 154.26,66.74 ; H6.1 152.52,67.39 ; H6.1 150.13,65 ; H6.1 152.52,62.61 ; H6.1 154.91,65 ; H6.1 154.26,63.26 ; H6.1 150.78,66.74 ; H6.1 150.78,63.26 ; 237.63,68.48 H15.1 ; H15.1 239.15,72.08 ; H15.1 239.15,67.92 ; H15.1 240.67,68.48 ; H15.1 237.07,70 ; H15.1 240.67,71.52 ; H15.1 237.63,71.52 ; H15.1 241.23,70 ; 2.62,47.95 JUSB1.13 ; JUSB1.13 1.11,47.95 ; JUSB1.13 4.13,47.95 ; JUSB1.13 4.13,48.81 ; JUSB1.13 1.11,48.81 ; H5.1 193.59,77.98 ; H5.1 189.01,73.02 ; H5.1 193.59,73.02 ; H5.1 189.01,75.5 ; H5.1 191.3,77.98 ; H5.1 189.01,77.98 ; H5.1 193.59,75.5 ; H5.1 191.3,73.02 ; 12.96,71.07 JUSB3.4 ; JUSB3.4 13.6,70.87 ; JUSB3.4 12.76,71.71 ; JUSB3.4 14.24,72.35 ; JUSB3.4 12.96,72.35 ; JUSB3.4 13.6,72.55 ; H16.1 216.84,13.69 ; H16.1 215.6,14.13 ; H16.1 217.28,12.45 ; H16.1 214.36,13.69 ; H16.1 213.92,12.45 ; H16.1 215.6,10.77 ; H16.1 216.84,11.21 ; H16.1 214.36,11.21 ; 20.63,67.17 H11.1 ; H11.1 22.97,67.17 ; H11.1 21.8,64.41 ; H11.1 20.21,66 ; H11.1 21.8,67.59 ; H11.1 23.39,66 ; H11.1 20.63,64.83 ; H11.1 22.97,64.83 ; H4.1 193.59,105.22 ; H4.1 189.01,105.22 ; H4.1 191.3,107.51 ; H4.1 189.63,103.55 ; H4.1 192.97,106.89 ; H4.1 191.3,102.93 ; H4.1 189.63,106.89 ; H4.1 192.97,103.55 ; 253.3,124.91 H9.1 ; H9.1 254.47,127.67 ; H9.1 254.47,125.33 ; H9.1 254.89,126.5 ; H9.1 252.13,127.67 ; H9.1 252.13,125.33 ; H9.1 253.3,128.09 ; H9.1 251.71,126.5 ; JHDMI.20 13.1,115.47 ; JHDMI.20 13.1,117.43 ; JHDMI.20 13.1,116.45 ; JHDMI.20 10.44,115.47 ; JHDMI.20 11.77,115.47 ; JHDMI.20 10.44,117.43 ; JHDMI.20 11.77,117.43 ; JHDMI.20 10.44,116.45 ; H8.1 238.32,121.52 ; H8.1 235.28,118.48 ; H8.1 236.8,117.92 ; H8.1 238.32,118.48 ; H8.1 234.72,120 ; H8.1 235.28,121.52 ; H8.1 236.8,122.08 ; H8.1 238.88,120 ; 1.11,67.31 JUSB3.13 ; JUSB3.13 1.11,66.45 ; JUSB3.13 2.62,66.45 ; JUSB3.13 4.13,67.31 ; JUSB3.13 4.13,66.45 ; 10.11,104.74 JHDMI.2 ; JHDMI.2 9.99,105.2 ; JHDMI.2 11.03,104.74 ; JHDMI.2 11.15,105.2 ; JHDMI.2 10.11,105.66 ; JHDMI.2 11.03,105.66 ; JHDMI.2 10.57,104.62 ; 2.7,85.44 JMDP.23 ; JMDP.23 4.03,86.21 ; JMDP.23 1.37,85.44 ; JMDP.23 1.37,86.21 ; JMDP.23 4.03,85.44 ; H13.1 114.98,126.5 ; H13.1 113.3,124.82 ; H13.1 112.06,127.74 ; H13.1 111.62,126.5 ; H13.1 113.3,128.18 ; H13.1 114.54,127.74 ; H13.1 114.54,125.26 ; H13.1 112.06,125.26 ; 13.21,49.45 JUSB1.14 ; JUSB1.14 14.72,50.31 ; JUSB1.14 14.72,49.45 ; JUSB1.14 13.21,51.17 ; 282.24,33.4 JSSD.40 ; JSSD.40 282.24,33.16 ; JSSD.40 282.24,33.64 ; 10.44,102.93 JHDMI.23 ; JHDMI.23 13.1,102.93 ; JHDMI.23 10.44,101.95 ; JHDMI.23 13.1,101.95 ; JHDMI.23 11.77,100.97 ; JHDMI.23 13.1,100.97 ; JHDMI.23 10.44,100.97 ; JHDMI.23 11.77,102.93 ; H12.1 152.24,11.21 ; H12.1 151,14.13 ; H12.1 152.68,12.45 ; H12.1 149.32,12.45 ; H12.1 149.76,13.69 ; H12.1 149.76,11.21 ; H12.1 152.24,13.69 ; H12.1 151,10.77 ; JHDMI.17 12.35,112.7 ; JHDMI.17 12.23,113.16 ; JHDMI.17 11.31,112.24 ; JHDMI.17 11.19,112.7 ; JHDMI.17 12.23,112.24 ; JHDMI.17 11.31,113.16 ; JHDMI.22 5.53,100.2 ; JHDMI.22 4.2,99.22 ; JHDMI.22 2.87,99.22 ; JHDMI.22 2.87,100.2 ; JHDMI.22 5.53,99.22 ; 9.31,92.13 JMDP.14 ; JMDP.14 9.77,93.18 ; JMDP.14 8.85,93.18 ; JMDP.14 9.89,92.71 ; JMDP.14 8.85,92.25 ; JMDP.14 9.77,92.25 ; JMDP.14 8.73,92.71 ; 282.24,37.4 JSSD.50 ; JSSD.50 282.24,37.64 ; JSSD.50 282.24,37.16 ; JHDMI.8 11.03,108.66 ; JHDMI.8 11.15,108.2 ; JHDMI.8 11.03,107.74 ; JHDMI.8 10.11,107.74 ; JHDMI.8 9.99,108.2 ; JHDMI.8 10.11,108.66 ; H3.1 154.26,117.46 ; H3.1 150.78,117.46 ; H3.1 150.13,115.72 ; H3.1 152.52,118.11 ; H3.1 152.52,113.33 ; H3.1 150.78,113.98 ; H3.1 154.26,113.98 ; H3.1 154.91,115.72 ; JMDP.24 9.88,87.76 ; JMDP.24 9.88,88.54 ; JMDP.24 8.51,86.99 ; 11.31,109.24 JHDMI.11 ; JHDMI.11 12.35,109.7 ; JHDMI.11 11.19,109.7 ; JHDMI.11 12.23,109.24 ; JHDMI.11 12.23,110.16 ; JHDMI.11 11.31,110.16 ; 1.37,97.21 JMDP.22 ; JMDP.22 1.37,97.99 ; JMDP.22 2.7,97.99 ; JMDP.22 4.03,97.99 ; JMDP.22 4.03,97.21 ; 13.21,62.25 JUSB1.11 ; JUSB1.11 14.72,63.97 ; JUSB1.11 14.72,63.11 ; JUSB1.11 13.21,63.97 ; JUSB1.11 14.72,62.25 ; 288.54,11.48 JSSD.54 ; JSSD.54 289.77,11.48 ; JSSD.54 288.54,12.05 ; 14.71,118 H2.1 ; H2.1 15.13,119.17 ; H2.1 17.47,119.17 ; H2.1 15.13,116.83 ; H2.1 17.47,116.83 ; H2.1 16.3,116.41 ; H2.1 16.3,119.59 ; JHDMI.21 4.2,119.18 ; JHDMI.21 2.87,118.2 ; JHDMI.21 5.53,119.18 ; JHDMI.21 5.53,118.2 ; JHDMI.21 2.87,119.18 ; JMDP.8 9.89,90.71 ; JMDP.8 8.85,90.25 ; JMDP.8 9.77,91.18 ; JMDP.8 8.73,90.71 ; JMDP.8 8.85,91.18 ; JMDP.8 9.31,91.3 ; JMDP.8 9.77,90.25 ; 282.24,15.8 JSSD.4 ; JSSD.4 282.24,15.56 ; JSSD.4 282.24,16.04 ; JUSB1.12 4.13,64.61 ; JUSB1.12 1.11,65.47 ; JUSB1.12 1.11,64.61 ; JUSB1.12 4.13,65.47 ; JUSB1.12 2.62,65.47 ; JUSB3.11 14.72,81.61 ; JUSB3.11 13.21,80.75 ; JUSB3.11 13.21,82.47 ; JUSB3.11 14.72,82.47 ; JMDP.21 9.88,94.89 ; JMDP.21 9.88,95.66 ; JMDP.21 9.88,96.44 ; JMDP.21 8.51,96.44 ; 282.24,24.6 JSSD.18 ; JSSD.18 283.12,24.12 ; JSSD.18 282.24,24.12
  GND3 w0.254: v7(222.43,90.5) 222.42,90.5 v4(222.11,90.81) ; v4(221.04,89.67) v7(221.36,89.99)
  GND3 w0.508: v7(17.44,44.28) 17.44,44.66 v6(17.21,44.89)
  BOTTOM w0.102: v8(229.98,63.36) 230.06,63.28 v1(230.06,62.59) ; v1(189.01,80.91) v8(189.01,81.59) ; v8(42.18,31.38) 41.33,30.53 v1(41.33,30.51) ; v1(184.9,107.35) 185.96,107.35 v8(186.29,107.02) ; v8(46.15,28.41) v1(46.15,27.62) ; v8(19.62,23.22) 18.92,23.92 v1(18.92,24.07) ; v1(221.23,67) 221.23,67.25 v8(221.91,67.93) ; v8(233.16,111.29) 233.15,111.28 v1(232.25,111.28) ; v8(129.3,100.62) 129.07,100.39 v9(129.07,99.39) ; v8(238.52,75.62) 239.36,75.62 240.09,76.36 CV709.2 ; v8(28.18,59.09) 27.94,59.33 v1(27.94,60.28) ; v7(19.66,93.34) v8(19.66,92.13) ; v7(33.45,52.33) v8(33.45,52.81)
  BOTTOM w0.152: U6.BE10 U6.BF10 ; v1(162.16,76.51) 162.17,76.5 163.04,76.5 U6.BC26 ; U6.P2 U6.P3 U6.P4
  BOTTOM w0.203: v7(262.9,13.24) JTB1.41 ; v7(272.23,28.2) 272.23,28.47 U7.H17 ; U7.AG2 264.18,22.64 264,22.82 v1(264,23.33) 263.74,23.59 U7.AJ6 ; v1(259.91,37.48) 260.23,37.15 U7.AT38 U7.AT36 ; U7.AA4 267.31,22.99 v1(267.43,22.87) ; v1(268.58,37.54) 268.37,37.75 U7.U39 ; v1(268.58,37.54) 268.19,37.15 U7.U38 ; v1(268.58,37.54) 268.97,37.15 U7.R38 ; U7.N39 270.19,37.75 v7(270.53,37.41) ; U7.AA20 266.29,29.68 v1(266.62,30.02) ; v7(181.32,90.97) 181.27,91.03 180.23,91.03 U6.AA1 ; U7.AL12 262.57,26.75 U7.AK14 262.99,27.3 v7(262.69,27.6) ; v1(36.26,45.73) UZ4.11 ; JTB1.77 255.7,12.19 255.99,11.9 v7(255.99,11.87) ; v1(259.92,28.21) 259.92,28.03 U7.AT15 ; 265.51,38.87 265.5,38.86 U7.AD40 ; v1(260.92,39.04) 260.59,39.38 U7.AT43 ; U7.D25 273.71,31.85 v1(273.71,32.28) ; U7.AY7 258,24.2 v7(257.73,24.47) ; U7.AE16 264.97,28.11 v1(265.25,28.39) ; U7.BD19 257.94,29.34 v1(258.09,29.19) ; v7(266.5,11.84) JTB1.23 ; UV1.C25 228.43,98.12 229.17,98.12 UV1.B25 ; v7(254.72,13.24) 254.5,13.02 JTB1.83 ; v1(257.7,26.11) 258.04,25.77 U7.AY10 ; U7.K15 271.55,27.57 271.55,27.34 v7(271.55,27.34) ; UV1.AH24 207.1,96.9 205.56,96.9 205.16,96.5 UV1.AL23 ; v1(266.6,26.71) 266.47,26.57 U7.AB12 ; v1(267.28,27.58) 267.61,27.25 U7.V14 ; v1(267.28,27.58) 267.61,27.91 U7.V16 ; v1(267.28,27.58) 266.95,27.25 U7.Y14 ; v7(256.9,11.92) JTB1.71 ; U7.N12 269.84,26.62 v1(269.53,26.32) ; v7(260.5,13.24) JTB1.53 ; v1(262.03,36.18) 262.03,35.9 U7.AL34 ; v7(265.3,11.87) JTB1.29 ; U7.N6 270.31,23.87 v1(270.51,23.87) ; v1(274.16,39.3) 273.8,38.94 U7.D42 ; U7.G44 272.31,39.71 U7.F43 272.72,39.28 272.37,38.94 v1(272.11,38.94) ; v7(262.59,22.93) 262.59,22.86 262.56,22.82 U7.AL2 ; U7.G38 272.27,37.14 v1(272.13,37.28) ; v7(270.51,25.55) 270.83,25.55 U7.K10 ; U7.Y16 266.95,28.03 v1(266.62,28.36) 266.29,28.03 U7.AA16 ; v3(272.23,23.02) 272.37,22.88 U7.G2 ; U6.AA4 U6.AA5 177.43,91.04 v1(177.07,91.4) ; U7.W44 267.43,39.78 U7.V43 267.84,39.09 v1(267.56,38.81) 267.1,38.35 U7.Y40 ; v1(267.94,32.45) 267.94,32.52 268.27,32.85 U7.U28 ; U7.AL8 262.57,24.78 262.26,24.47 v1(262.12,24.47) 261.93,24.47 261.63,24.78 261.63,24.78 U7.AN8 ; U7.H7 272.1,24.06 272.8,24.06 v7(272.86,24.13) 272.86,24.49 272.59,24.76 U7.G8 ; v1(263.06,36.26) 263.1,36.22 263.1,35.63 263.37,35.36 U7.AJ34 ; v7(264.1,13.27) JTB1.35 ; U7.AF38 264.21,37.15 v1(264.04,37.32) 263.86,37.15 U7.AJ38 ; PU600.24 192.74,125.5 v1(192.78,125.46) ; U7.P32 269.59,34.55 v1(269.26,34.88) 269.05,35.1 U7.R34 ; v7(270.1,13.32) JTB1.5 ; v7(258.1,11.92) JTB1.65 ; v1(207.9,100.27) 207.93,100.31 209.66,100.31 UV1.AE28 ; U7.R12 269.05,27.06 U7.R14 268.93,27.23 v1(268.62,27.55) 268.27,27.89 U7.U16 ; U7.AR2 260.93,22.72 v7(260.6,23.05) ; U7.L2 v7(270.68,22.77) ; v7(259.3,13.29) JTB1.59 ; v7(267.7,13.27) JTB1.17 ; U7.AE28 264.97,32.89 v1(265.31,33.22) 265.63,33.55 U7.AD30 ; v7(268.9,13.29) JTB1.11 ; v7(261.7,13.24) JTB1.47 ; U6.AE5 177.43,88.64 177.72,88.94 v7(177.72,89.05)
  BOTTOM w0.254: v1(145.48,101.44) 145.83,101.79 U6.E52 ; v1(145.48,101.44) 145.14,101.78 U6.E53 ; v1(145.48,101.44) 145.83,101.09 U6.F52 145.92,101.09 v1(146.27,101.44) ; v1(155.76,101.5) 156.12,101.14 U6.F37 ; UV6.H2 v1(203.47,116.07) UV6.H1 ; UV6.B10 v1(208.27,122.47) ; UU2.3 v7(134.12,103.77) ; v1(153.4,105.01) 153.77,104.64 U6.A40 U6.B40 153.74,103.94 v1(153.4,103.6) 153.76,103.24 U6.C40 ; v1(250.18,82.43) 250.56,82.04 UV9.C11 ; U7.P24 269.6,31.23 270,31.63 v7(270,31.69) 270.2,31.49 U7.M24 ; U6.BF6 176.44,74.01 176.44,73.53 v1(176.23,73.32) ; U7.AG28 264.31,32.8 v7(264.65,32.46) 264.31,32.12 U7.AG26 ; U7.R44 269.46,39.4 U7.P43 269.46,39.2 v1(269.22,38.95) 268.79,39.38 U7.T43 ; U6.AA7 175.88,91.32 v7(176.12,91.32) 176.12,91.66 U6.Y7 175.63,92.15 U6.W7 ; v7(229.58,96.05) 229.2,95.67 UV1.B22 ; UV10.C14 253.04,100.08 253.42,99.7 v1(253.4,99.7) ; v1(170.18,103.59) 170.54,103.24 U6.C15 ; U6.BF33 158.45,74.06 v1(158.1,73.71) ; U6.D8 175.55,102.54 v7(175.87,102.22) 175.87,102.2 175.86,102.2 175.5,101.84 U6.E8 ; JDIMM1.11 111.9,35.95 112.6,36.64 v1(112.61,36.64) ; v1(253.38,90.45) 252.99,90.06 UV9.N14 ; U6.AG48 148.67,87.37 v1(148.37,87.07) ; v1(144.02,88.54) 144.02,88.6 U6.AD54 ; v7(178.42,85.8) 178.13,86.1 U6.AH4 ; U6.M54 143.99,97.07 v1(143.87,97.2) ; v1(162.16,76.51) 161.81,76.86 U6.BB28 161.06,76.16 U6.BC30 ; v1(8.47,23.96) 8.22,23.71 UA5.24 ; UV1.G28 224.71,100.31 v7(224.7,100.31) ; UV9.E1 242.53,83.59 242.06,83.59 v1(242.05,83.61) ; v1(174.35,76.51) 174,76.16 U6.BC10 174.02,76.08 174.02,75.53 U6.BD10 174.02,75.38 174.02,74.83 U6.BE10 ; v1(174.35,76.51) 174,76.86 U6.BB10 ; v1(174.35,76.51) 174.7,76.86 U6.BB9 ; UV10.B10 249.27,99.28 v1(249.25,99.29) ; U6.U7 175.97,94.25 v1(176.23,94.25) 176.23,94.4 U6.R7 ; v7(176.12,88.29) 176,88.17 U6.AE7 ; U6.BA37 155.7,77.58 155.7,78.23 U6.AY37 155.62,78.26 v1(155.24,78.63) ; UV6.H14 203.07,126.08 v1(203.48,126.5) ; U6.B19 168.18,103.94 168.55,104.3 168.56,104.3 v1(168.56,104.29) ; UV1.N33 220.15,104.7 220.15,104.1 UV1.N32 220.45,103.6 v1(220.5,103.6) ; v1(249.39,91.25) UV9.P10 ; v1(144.02,83.66) 144.02,83.72 U6.AM54 144.45,84.07 144.52,84.15 144.92,84.15 145,84.07 U6.AM53 ; v1(209.04,117.61) 208.7,117.27 UV6.A3 ; v7(205.37,82.72) 205.8,83.15 UV1.AK7 ; v1(259.92,31.69) 259.92,31.57 259.62,31.27 U7.AV24 ; UV1.G13 225.1,88.09 v1(225.49,87.7) ; v1(177.79,84.11) 177.43,84.47 U6.AL5 ; v1(177.79,84.11) 177.43,83.75 U6.AM5 ; v1(177.79,84.11) 177.99,84.32 177.99,84.32 178.13,84.45 U6.AL4 ; U7.BD11 257.68,26.09 v1(257.7,26.11) ; U6.AU18 168.97,80.36 v1(169.34,79.98) ; U6.AT33 158.44,81.06 v1(158.06,80.68) 158.39,80.36 U6.AU33 ; v1(172.73,76.51) 172.38,76.16 U6.BC12 ; v1(172.73,76.51) 172.38,76.86 U6.BB12 U6.BB14 ; v1(172.73,76.51) 173.08,76.86 U6.BB11 ; v1(245.39,106.08) UV10.L5 ; v1(177.73,102.75) 178.08,103.09 U6.C4 178.12,103.28 U6.B4 ; v1(173.95,91.83) 173.96,91.82 U6.Y9 ; v1(221.46,115.04) 221.1,115.4 UV5.H1 221.14,115.71 221.14,116.43 UV5.H2 ; v1(177.13,96.3) U6.P6 ; UV9.A1 242.05,80.44 v1(242.01,80.41) ; v1(228.84,103.52) 229.2,103.16 UV1.B31 ; v7(228.79,88.45) 228.67,88.45 228.4,88.17 UV1.C13 ; v1(146.27,101.44) 146.62,101.79 U6.E51 ; v1(146.27,101.44) 146.61,101.09 U6.F51 ; U6.F40 153.76,101.14 v1(153.4,101.5) ; v7(227.95,93.55) 228.36,93.15 228.4,93.15 UV1.C19 ; UV9.F5 246.25,84.44 v1(246.34,84.36) ; UV9.R3 244.19,91.64 v1(244.58,91.25) ; UV5.E3 v1(223.9,117.67) ; v1(150.55,79.41) 151,78.96 U6.AW45 ; U7.Y8 266.73,24.78 v1(266.6,24.92) 266.47,24.78 U7.AB8 ; U7.BD45 257.02,39.76 U7.BD44 257.17,39.68 U7.BB42 257.89,38.6 v1(257.76,38.48) ; v7(205.4,81.05) 205,81.45 UV1.AL5 ; U7.B11 274.03,26.09 273.99,26.05 v7(273.99,26.05) ; RPH32.7 222.41,66.46 v1(223.01,67.06) 223.23,66.85 223.23,65.87 222.91,65.56 RPH32.8 ; UN1.13 v7(32.33,35.06) ; U7.Y28 266.95,32.9 v1(266.62,33.23) 266.29,32.9 U7.AA28 ; UV10.M5 245.88,107.19 246.25,107.19 v1(246.38,107.06) ; v1(197.07,115.27) UV6.R1 ; v1(180.73,88.68) 180.66,88.6 180.24,88.6 U6.AE1 ; UV1.AC13 210.42,87.4 v1(210.25,87.57) ; U6.AG50 147.17,87.38 v1(146.82,87.73) ; UV1.G30 225.11,102.4 225.48,102.04 v7(225.49,102.04) ; v1(174.98,78.58) 174.66,78.26 U6.AY9 174.52,78.08 174.52,78.08 174.52,77.68 174.52,77.68 U6.BA9 174.52,77.1 U6.BB9 ; U6.BB38 155.31,76.86 v1(155.66,76.51) ; U6.AG9 173.63,86.77 v7(173.62,86.78) ; v1(223.9,125.67) UV5.E14 ; UV6.C4 v1(206.67,117.67) UV6.C3 ; U6.BB7 U6.BC7 175.52,76.16 v1(175.17,75.81) ; U6.BB7 U6.BB6 U6.BB5 U6.BC5 177.21,76.16 v1(176.86,75.81) 177.21,75.46 U6.BD5 ; U6.BB7 U6.BB9 ; U6.U5 177.44,93.48 177.42,93.48 v1(177.04,93.86) ; U6.AH5 177.43,86.1 v7(177.73,85.8) 177.43,85.49 U6.AK5 ; v7(202.2,105.24) 202.2,105.2 UV1.AP33 ; UV1.AE32 210.23,104 v7(210.53,103.7) ; v1(272.89,29.19) 272.89,29.4 273.17,29.68 U7.F20 273.66,29.68 274,29.34 U7.B19 ; U7.AC44 265.81,39.36 265.78,39.33 265.78,39.22 265.51,38.95 v7(265.51,38.83) ; v1(147.88,101.5) 148.24,101.14 U6.F49 ; U6.K6 176.52,98.55 v1(176.26,98.55) ; U7.K29 271.39,33.41 v7(271.65,33.66) ; v1(206.95,92.8) 207.3,93.15 UV1.AH19 ; U7.K39 271.6,38.35 U7.H40 272.07,38.35 v1(272.5,37.92) ; UV1.AB28 212.53,100.7 v1(212.13,101.1) ; UV6.E3 205.48,117.27 205.48,117.27 205.48,117.29 205.09,116.9 v1(205.09,116.87) ; U6.BF30 160.89,74.06 v1(160.54,73.71) ; UV6.R3 197.47,117.26 v1(197.07,116.87) ; U7.AV33 259.62,35.31 259.45,35.48 v1(259.45,35.68) ; U7.BD15 v7(257.75,27.72) 257.75,27.75 257.4,28.1 U7.BC16 ; U7.L44 v7(270.27,39.81) ; U6.AB5 177.43,90.21 177.43,90.17 v1(177.07,89.81) ; UV1.AB2 212.55,78.86 v1(212.91,78.49) ; UV1.AL26 205,99 v1(204.58,99.42) ; v1(146.85,92.58) 147.17,92.25 U6.W50 ; v1(177.04,100.4) 177.16,100.53 U6.F5 177.77,101.14 U6.F4 ; v1(263.19,41.1) 262.96,40.87 U7.AK45 U7.AK43 ; v1(146.82,84.48) 147.17,84.13 U6.AM50 ; v1(146.81,95.83) 147.17,95.46 U6.P50 ; U6.G25 164.2,100.3 v1(164.2,100.62) ; v1(265.26,27.58) 265.63,27.21 U7.AD14 ; v1(208.85,86.18) 208.53,86.5 UV1.AG11 ; v1(173.54,73.71) 173.6,73.71 U6.BF10 ; U6.F54 143.68,101.08 v1(143.58,101.18) ; UV1.K2 222.55,78.97 v7(222.15,78.57) ; U6.P48 148.9,95.81 v1(148.4,95.81) ; U6.V48 148.96,93.1 148.51,93.1 v1(148.32,93.28) 148.71,93.67 U6.U48 ; v7(27.57,53.32) 27.35,53.1 US1.14 ; U6.BE46 150.38,74.83 150.45,74.91 150.45,75.31 150.38,75.38 U6.BD46 150.38,75.53 150.45,75.61 150.45,76.01 150.38,76.08 U6.BC46 150.43,76.16 v1(150.78,76.51) ; v1(253.39,109.3) 253.01,109.68 UV10.R14 ; U6.BC33 158.56,76.16 v1(158.91,76.51) ; U6.AJ50 147.17,85.75 v1(146.82,86.1) ; v7(26.45,26.86) JHDD.13 ; v7(179.88,98.75) 179.53,98.4 U6.K2 ; U6.AF7 175.98,87.45 176.32,87.45 v7(176.43,87.33) 176.73,87.63 U6.AF6 ; v1(202.78,80.42) 203,80.65 UV1.AN4 ; v1(167.85,73.64) 168.26,74.05 U6.BF18 ; U7.U34 U7.R34 ; U6.AR26 163.09,81.21 U6.AT26 U6.AT25 ; U6.AT16 169.67,81.06 v1(169.34,80.73) 169.02,81.06 U6.AT18 ; U6.F44 151.43,101.14 151.4,101.14 151.04,101.5 v1(151.04,101.5) ; v1(143.96,92.51) 144.28,92.2 U6.W54 ; v7(180.79,100.07) U6.G1 ; U6.U6 176.52,93.67 v1(176.25,93.67) 175.96,93.38 U6.V7 ; v1(159,78.58) 158.68,78.26 U6.AY33 158.54,78.08 158.55,78.08 158.55,77.68 158.54,77.68 U6.BA33 158.54,76.9 U6.BB33 158.56,76.86 v1(158.91,76.51) ; v7(209.61,83.28) 209.79,83.1 UV1.AE7 ; v1(153.22,73.71) 153.28,73.71 U6.BF41 153.63,74.13 153.7,74.21 153.7,74.61 153.63,74.68 U6.BE41 153.63,74.83 153.7,74.91 153.7,75.31 153.63,75.38 U6.BD41 153.63,75.53 153.7,75.61 153.7,76.01 153.63,76.08 U6.BC41 153.68,76.16 v1(154.03,76.51) ; U6.A15 170.54,104.64 v1(170.18,104.99) ; v1(250.99,92.85) UV9.U12 ; v1(244.59,92.05) UV9.R4 ; U7.U10 268.37,25.08 v1(268.56,25.08) 268.75,25.08 U7.R8 ; v1(242.23,85.69) 242.58,86.05 UV9.H1 ; v1(258.09,32.75) 258.09,32.89 U7.AY29 ; v1(258.09,32.75) 257.65,32.75 U7.BC28 ; v1(258.09,32.75) 258.09,32.59 U7.AY26 ; v7(217.91,83.44) 217.89,83.44 UV1.T7 ; UV5.N12 v1(216.7,124.87) ; v7(225.53,79.39) 225.46,79.39 UV1.G3 ; U6.W48 148.69,92.27 v1(148.33,92.63) ; UV1.C7 228.4,83.12 v7(228.79,82.73) 229.2,83.14 UV1.B7 ; v1(251.79,98.08) UV10.A12 ; v7(205.47,78.6) 205.07,79 UV1.AL2 ; U6.BA50 147.17,77.68 v1(146.82,78.03) 147.17,78.38 U6.AY50 147.17,78.46 v1(146.83,78.8) 147.17,79.15 U6.AW50 147.17,79.25 v1(146.82,79.6) 147.17,79.95 U6.AV50 147.17,80.06 v1(146.82,80.41) 146.47,80.76 U6.AT51 ; U6.AW43 151.94,78.96 v1(151.49,79.41) ; v1(166.05,105.06) 166.05,104.96 U6.A22 165.57,104.48 165.57,104.11 U6.B22 ; U6.BD53 145.11,75.49 v1(145.62,75.49) ; v1(202.82,77.86) 203.06,77.86 UV1.AN1 ; v1(180.58,84.93) 180.23,84.58 U6.AL1 ; U6.AT10 173.63,81.06 v1(173.99,81.41) 174.2,81.41 U6.AR9 ; UV10.U14 252.99,111.26 v1(253.47,110.79) ; U6.E25 164.12,101.84 164.48,102.2 164.49,102.2 v1(164.49,102.19) 164.85,101.84 U6.E24 ; v1(162.98,73.71) 163.33,74.06 U6.BF26 ; UV1.G19 225.1,93.17 v1(224.66,93.61) ; U7.AD32 265.63,34.88 U7.AB34 266.14,35.36 266.51,35 v1(266.7,35) 267.06,35.36 U7.Y34 ; v1(149.16,76.54) 148.84,76.86 U6.BB48 ; v1(149.16,76.54) 148.77,76.16 U6.BC48 ; v1(149.16,76.54) 149.47,76.86 U6.BB47 ; U6.P52 146.14,95.08 v1(146.14,95.01) ; v7(179.18,93.87) 179.53,93.53 U6.U2 179.62,93.56 180.14,93.56 U6.U1 ; v1(242,82.02) 242.56,82.02 UV9.C1 ; U6.B49 148.28,104.63 U6.A49 148.27,104.65 v1(147.87,105.05) 147.47,104.64 U6.A50 ; v1(197.07,124.87) UV6.R12 v1(197.87,124.07) ; U7.AT17 259.92,28.41 v1(259.92,28.21) ; UV1.N7 220.05,83.05 v7(220.45,82.65) ; UV1.M18 UV1.M17 221.8,91.13 v7(222.43,90.5) ; v1(242.99,90.48) 242.59,90.08 UV9.N1 ; v1(215.14,124.09) 215.5,123.72 UV5.R11 ; UV1.T32 217.55,103.82 v7(217.18,103.45) ; U7.AF8 264.52,24.79 264.32,24.99 264.02,24.99 v1(264.02,24.99) 263.76,24.99 U7.AJ8 ; v1(252.59,92.05) UV9.R14 ; UV6.C11 207.05,123.67 v1(206.65,124.07) 207.06,124.47 UV6.C12 ; U6.K7 176.02,98.31 v1(176.26,98.55) ; v1(202.82,78.49) 202.6,78.71 UV1.AP2 ; v1(214.27,116.85) 214.27,116.9 UV5.U3 ; UV6.N14 v1(198.67,126.47) ; UV1.AE2 v7(210.49,78.56) ; 26.12,30.95 26.54,31.36 JHDD.4 ; 26.12,30.95 v1(26.12,30.97) ; 26.12,30.95 26.12,30.61 26.1,30.59 26.1,30.16 26.39,29.86 JHDD.7 ; U6.BB1 180.76,77.06 v1(180.83,77.13) ; v7(84.26,39.31) 84.26,39.89 84.05,40.11 JEDP1.17 ; UV10.C4 v1(244.59,100.48) UV10.C3 ; UV9.R11 v1(250.19,92.05) UV9.T10 ; v1(242.2,92.03) 242.2,92.03 UV9.R1 ; U6.BB44 151.13,76.86 v1(150.78,76.51) ; U7.AY36 258.43,36.17 258.83,36.57 v1(258.83,36.61) ; v7(225.5,78.59) 225.46,78.59 UV1.G2 ; U7.B39 v7(273.85,37.47) ; v1(243.8,93.67) 244.19,93.28 UV9.U3 ; U6.AU30 160.56,80.36 v1(160.88,80.68) ; JEDP1.8 88.55,40.83 v1(88.55,41.94) 89.64,41.94 90.05,41.53 JEDP1.5 ; U6.AR50 147.17,81.7 147.04,81.84 v1(146.83,82.05) ; v1(177.78,79.24) 178.13,79.59 U6.AV4 178.12,79.65 v1(177.73,80.05) 177.43,80.34 U6.AU5 177.43,80.56 v1(177.73,80.86) ; v1(177.78,79.24) 177.43,79.59 U6.AV5 ; v1(177.78,79.24) 177.43,78.89 U6.AW5 177.43,78.78 v1(177.78,78.43) 178.13,78.08 U6.BA4 178.13,77.97 v1(177.78,77.62) 177.43,77.97 U6.BA5 ; v1(170.29,76.44) 170.7,76.85 U6.BB15 U6.BB14 ; v1(170.29,76.44) 170.58,76.16 U6.BC15 170.7,76.08 170.77,76.01 170.77,75.61 170.7,75.53 U6.BD15 170.7,75.38 170.77,75.31 170.77,74.91 170.7,74.83 U6.BE15 170.7,74.68 170.77,74.61 170.77,74.21 170.7,74.13 U6.BF15 170.7,74.05 v1(170.29,73.64) ; v1(170.29,76.44) 169.88,76.85 U6.BB16 U6.BB17 ; U6.G30 160.87,100.41 v1(160.52,100.76) ; U6.D37 156.12,102.54 v1(155.76,102.9) ; U6.AR24 164.44,81.31 U6.AT25 ; U7.W2 v1(267.43,22.87) ; JEDP1.1 92.05,41.48 v7(91.8,41.73) 91.55,41.48 JEDP1.2 ; v1(179.13,102.05) 179.53,102.45 U6.D2 ; v1(245.39,88.05) UV9.L5 ; v1(144.02,90.17) 144.02,90.22 U6.AB54 ; UV5.K13 219.48,125.27 v1(219.07,125.67) 219.47,126.07 UV5.K14 ; v1(145.62,75.49) 145.88,75.49 146.05,75.32 146.51,75.32 U6.BD51 146.87,75.23 146.87,74.94 147.14,74.67 v1(147.14,74.61) U6.BF50 ; v1(145.62,75.49) 145.62,76.18 U6.BC52 ; U7.AT10 259.74,26.26 v1(259.45,26.26) 259.45,26.45 259.62,26.62 U7.AV13 ; U6.AN48 148.72,83.17 v1(148.44,82.89) ; UV1.AL33 205,104.8 v7(204.6,104.4) 205,104 UV1.AL32 ; U7.H22 271.96,30.66 271.69,30.39 v1(271.69,30.19) 271.69,29.98 U7.K20 ; v7(204.6,102.8) 205,102.4 UV1.AL30 ; v7(227.25,79.37) 227.26,79.37 227.55,79.08 UV1.D2 ; UV5.U12 213.86,124.47 v1(213.48,124.1) ; U6.AT25 164.39,81.06 v1(164.71,80.74) 164.32,80.36 164.27,80.36 ; U6.AG5 177.43,86.91 v7(177.72,86.61) ; v7(270.31,30.18) 270.2,30.29 U7.M22 270.19,30.66 269.82,30.66 269.59,30.43 U7.P22 ; UV5.H14 v1(221.5,125.67) UV5.H13 ; v1(221.98,122.33) 221.98,122.79 UV5.G10 ; U7.BC22 257.41,30.55 257.75,30.55 v7(257.89,30.69) 257.89,31.72 U7.BB25 ; v1(264.18,39.06) U7.AG44 ; UV6.L10 200.67,122.84 v1(200.27,122.44) ; v1(168.56,102.89) 168.56,102.9 168.55,102.9 168.18,102.54 U6.D19 ; U7.P45 269.46,40.3 v1(269.87,40.71) ; UV1.G5 225,81.4 v7(224.59,81.82) ; v7(173.03,100.57) 173.03,100.57 173.19,100.41 U6.G11 ; UV6.E12 v1(205.07,124.87) ; 166.52,77.81 v1(166.52,78.56) ; 166.52,77.81 166.07,78.26 U6.AY22 ; 166.52,77.81 166.27,77.56 U6.BA22 ; U7.BD1 256.86,21.49 v1(256.86,21.11) 257.32,21.11 257.61,21.4 U7.BC1 U7.BA1 ; v7(273.46,28.24) 273.19,27.97 U7.F15 ; v1(270.65,35.8) 270.49,35.96 U7.N35 ; v1(146.82,88.54) 147.17,88.19 U6.AE50 ; UV10.C12 v1(250.99,100.48) UV10.C11 ; JEDP1.24 v7(80.55,39.76) ; UV1.AH13 207.5,88.1 v7(207.9,87.7) ; v7(269.3,32.46) 269.59,32.16 U7.P26 ; U6.N48 v1(148.33,96.64) 148.56,96.87 U6.M48 ; U6.BA1 180.28,77.92 180.7,78.35 v1(180.7,78.43) ; v1(259.5,30.17) 259.5,30.55 259.62,30.66 U7.AV22 ; U6.AU22 166.44,79.98 v1(166.52,79.98) 166.2,79.66 U6.AV22 ; U6.E54 144.12,101.78 143.83,102.08 v1(143.64,102.08) ; v1(260.92,39.04) 261.26,39.38 U7.AP43 ; v7(271.65,34.74) 271.39,35 U7.K33 ; U7.H36 271.93,36.16 271.59,35.82 v7(271.59,35.69) ; U6.AU13 171.79,80.36 v1(172.16,79.98) ; v1(243.79,87.25) UV9.K2 ; U7.BE41 256.34,38.57 v1(256,38.22) ; v7(228.78,96.05) 228.4,95.67 UV1.C22 ; v1(260.09,24.58) 259.7,24.19 U7.AV7 U7.AV6 ; U7.Y24 266.95,31.11 v1(266.65,30.81) ; v1(165.59,81.26) 165.79,81.46 U6.AR22 166.12,81.77 v1(166.47,81.43) 166.81,81.77 U6.AR20 ; U6.BF38 155.64,73.67 v1(155.64,73.67) ; U6.G37 156.14,100.39 v1(155.76,100.77) ; UV6.N12 v1(198.67,124.87) ; v1(251.79,84.04) UV9.E12 ; UV10.M10 249.79,107.23 v1(249.43,106.87) 249.79,106.52 UV10.L10 ; U6.AA2 179.53,91.09 v7(179.18,91.44) 178.83,91.08 U6.AA3 ; v7(221.28,87.9) 221.78,87.4 UV1.M13 ; v1(146.12,81.22) 145.77,80.87 U6.AT52 ; 147.89,102.9 148.23,103.24 U6.C49 ; 147.89,102.9 148.26,102.54 U6.D49 ; 147.89,102.9 v1(147.88,102.9) ; v7(263.33,30.03) 263.65,30.35 U7.AJ22 ; U6.AW49 148.21,79.01 v1(147.66,79.55) ; U7.A44 275.34,39.53 275.57,39.53 v1(275.58,39.54) ; UV6.B5 v1(208.27,119.27) ; v1(167.85,76.54) 168.17,76.86 U6.BB18 U6.BB17 ; v1(167.85,76.54) 168.24,76.16 U6.BC18 168.26,76.08 168.33,76.01 168.33,75.61 168.26,75.53 U6.BD18 ; v1(167.85,76.54) 167.54,76.86 U6.BB20 167.33,76.86 U6.BC21 U6.BC22 ; UV1.G22 225.07,95.65 v1(224.65,96.07) ; U6.AU29 161.5,80.36 v1(161.82,80.68) 161.45,81.06 U6.AT29 ; v1(177.73,82.48) 177.73,82.6 U6.AN5 ; UV9.C4 v1(244.59,82.44) UV9.C3 ; v1(198.67,115.27) UV6.N1 ; UV10.C1 242.55,100.12 v1(242.04,100.12) ; v1(257.72,34.17) 257.68,34.22 U7.BD31 ; 164.27,80.36 v1(164.64,79.98) 164.32,79.66 U6.AV25 ; 164.27,80.36 U6.AU25 ; v1(251.75,81.65) 251.39,82.02 UV9.C12 ; v7(206.04,85.23) 205.8,85.48 UV1.AK10 ; U6.G13 171.44,100.33 v1(171.44,100.64) ; UV10.R3 244.58,110.07 v1(244.58,110.07) 244.97,109.68 UV10.R4 ; v1(263.33,28.39) 263.65,28.07 U7.AJ16 U7.AG16 ; U6.H53 144.75,99.84 v1(144.75,99.94) ; v1(146.12,82.85) 146.47,82.5 U6.AP51 ; UV6.K2 v1(201.07,116.07) UV6.K1 ; v1(245.39,98.88) UV10.B5 ; UV5.R1 215.87,115.3 v1(215.87,115.25) ; v7(229.6,101.12) 229.2,100.72 UV1.B28 ; U6.AE48 148.37,88.41 v1(148.37,88.47) 148.49,88.59 148.9,88.59 U6.AD48 ; UV5.L5 v1(218.29,119.28) 217.9,118.9 UV5.M5 ; v1(151.04,100.8) 151.41,100.43 151.43,100.43 151.43,100.43 U6.G44 ; v7(208.01,101.17) 207.88,101.17 207.52,101.52 UV1.AH29 ; v7(174.04,93.22) U6.V9 ; U6.AU42 153.36,80.81 v1(153.36,80.81) 153.12,81.06 U6.AT42 ; v1(242.04,109.68) UV10.R1 ; U7.BE3 256.13,22.77 255.96,22.61 v1(255.96,22.31) 256.36,22.31 U7.BE2 ; U6.AR18 168.83,81.55 v1(169.39,81.55) 169.8,81.55 U6.AR16 ; U6.AR12 172.84,81.59 v1(173.13,81.3) 172.88,81.3 U6.AT12 ; v7(210.44,81) 210.05,81.39 UV1.AE5 210.02,81.42 210.02,81.53 v7(209.71,81.84) ; U6.AU9 174.66,80.36 v1(174.98,80.68) ; U7.AD6 265.5,23.56 v1(266.05,23.01) 265.81,22.77 U7.AC2 ; UV1.AB5 v7(212.95,81) ; U6.AN49 147.54,82.92 v1(147.54,82.85) ; v1(177.73,80.86) 177.43,81.16 U6.AT5 ; v1(177.73,80.86) 178.13,81.26 U6.AT4 ; U7.M31 270.2,34.48 v7(270.46,34.74) ; U6.BF22 165.76,74.06 v1(165.41,73.71) ; UV9.H14 252.99,86.02 v1(253.36,85.64) ; U6.AT53 145,80.82 144.92,80.89 144.52,80.89 144.45,80.82 U6.AT54 143.95,80.4 v1(143.88,80.4) ; U6.B11 173.02,103.97 173.02,104.61 U6.A11 173.01,104.68 173.01,105.23 173.4,105.62 v1(173.48,105.62) ; U6.AM7 176.05,83.87 v1(176.23,83.69) 176.23,83.45 U6.AN7 ; UV1.AL23 UV1.AL24 205,97.35 UV1.AM25 UV1.AN25 ; UV10.F5 246.24,102.48 v1(246.33,102.57) ; v1(174.98,80.68) 175.08,80.68 U6.AT8 ; v1(174.98,80.68) 174.9,80.68 U6.AT9 ; U11.24 31.55,82.33 v7(31.98,82.75) ; U6.AB9 173.96,90.37 v1(173.95,90.38) ; v7(255.99,23.25) 256.1,23.37 U7.BE5 ; v1(152.41,76.51) 152.06,76.16 U6.BC43 ; v1(152.41,76.51) 152.76,76.86 U6.BB42 ; v1(152.41,76.51) 152.06,76.86 U6.BB43 ; v7(228.02,100.22) 228.4,100.6 UV1.C28 ; UV1.A33 230,105.51 v1(229.94,105.56) ; UV9.M10 v1(249.39,88.85) UV9.L10 ; UV9.B10 v1(249.24,81.24) ; U6.AT40 154.03,81.06 v1(154.37,80.72) 154.71,81.06 U6.AT39 ; U6.AL48 148.47,84.57 v1(148.36,84.68) 148.35,84.69 148.35,84.91 U6.AK48 ; U7.P28 269.59,33.05 v7(269.78,33.24) ; v1(144.72,87.73) 144.37,87.38 U6.AG54 ; U6.D15 170.54,102.54 v1(170.18,102.89) ; U6.BC50 147.27,76.39 v1(147.36,76.48) 147.74,76.86 U6.BB49 ; UV5.R12 v1(215.9,124.07) ; UV9.H13 251.79,86.45 251.79,87.21 v1(251.84,87.27) ; U6.D30 160.85,102.54 v1(160.48,102.9) ; U6.AF5 177.43,87.72 v7(177.72,87.43) ; v7(220.46,80.86) 220.46,80.94 220.05,81.35 UV1.N5 ; v1(275.73,22.72) 275.27,22.72 U7.A4 U7.A5 ; U6.BB14 171.7,77.05 U6.BA13 171.7,77.68 171.7,77.68 171.7,78.08 171.7,78.08 U6.AY13 171.84,78.26 v1(172.16,78.58) ; v1(161.82,78.58) 161.5,78.26 U6.AY29 161.36,78.08 161.37,78.08 161.37,77.68 161.36,77.68 U6.BA29 ; UV5.N3 217.05,117.27 v1(216.65,117.67) ; UV1.AL12 v7(205.4,86.9) ; U6.H44 151.43,99.73 151.43,99.73 151.41,99.73 v1(151.04,100.1) ; v1(249.26,103.22) 249.72,103.22 UV10.G10 ; v1(145.39,92.58) U6.W52 ; UV6.K13 201.47,125.31 201.08,125.7 v1(201.07,125.7) 201.44,126.07 UV6.K14 ; UV5.R3 215.4,117.37 215.4,117.98 UV5.R4 215.5,118.07 v1(215.07,118.49) ; U6.AV13 171.79,79.66 v1(172.16,79.28) 171.84,78.96 U6.AW13 ; v7(174.11,97.72) 174.26,97.57 U6.L9 ; v1(273.18,40.88) 273.18,40.48 273.38,40.28 U7.E45 U7.C45 U7.B45 274.6,40.63 v1(274.36,40.87) ; v7(273.52,22.68) 273.52,22.77 273.73,22.97 U7.D4 ; U6.AP54 144.02,82.09 v1(144.02,82.04) ; v1(156.47,73.71) 156.82,74.06 U6.BF36 156.88,74.13 156.96,74.21 156.96,74.61 156.88,74.68 U6.BE36 156.88,74.83 156.96,74.91 156.96,75.31 156.88,75.38 U6.BD36 156.88,75.53 156.96,75.61 156.96,76.01 156.88,76.08 U6.BC36 ; v1(223.1,115.27) UV5.E1 ; v1(160.48,102.2) 160.85,101.84 U6.E30 ; v1(175.17,74.41) 175.52,74.06 U6.BF7 ; v1(243.03,85.69) 243.38,86.05 UV9.H2 ; U6.P5 177.43,95.85 v1(177.78,95.5) 178.13,95.85 U6.P4 ; UV1.G33 225.15,104.8 v7(225.55,104.4) ; U6.D22 165.77,102.54 v1(166.12,102.89) 165.77,103.24 U6.C22 ; v1(158.12,102.2) 158.48,101.84 U6.E33 ; U6.BB37 156.01,76.86 v1(155.66,76.51) ; U7.AP13 261.61,26.75 v1(262.06,26.3) 262.34,26.57 U7.AL12 ; v1(260.05,29.19) 260.05,29.39 260.22,29.56 U7.AT20 ; v7(273.75,27.81) 273.84,27.72 U7.B15 ; v7(207.05,86.92) 207.08,86.92 UV1.AH11 ; v1(273.66,24.65) 273.83,24.47 274.49,24.47 U7.B7 ; v1(155.24,79.33) 155.62,78.96 U6.AW37 ; U6.E44 151.4,101.84 v1(151.04,102.2) ; v1(205.04,119.26) 204.67,118.89 UV6.F5 ; v1(197.07,125.67) UV6.R14 ; v1(87.25,39.26) 87.05,39.46 JEDP1.11 ; v1(243.79,80.84) UV9.A3 ; v1(31.09,78.4) 31.4,78.4 31.74,78.06 U11.31 ; U6.C11 172.98,103.24 v7(172.65,102.91) 173.01,102.54 U6.D11 ; UV1.T2 v1(217.15,78.6) ; U6.C53 145.07,103.28 v7(144.78,103.58) ; UV5.L10 v1(218.7,122.31) ; UV5.T10 v1(215.1,122.47) ; U6.AE2 179.53,88.69 v7(179.17,89.05) 178.83,88.71 U6.AE3 ; UV1.B34 229.2,106.06 v1(229.93,106.79) ; U6.A19 168.18,104.64 168.55,105 168.56,105 v1(168.56,104.99) ; v1(215.32,119.39) 215.22,119.39 214.74,118.91 214.74,118.91 UV5.T5 ; UV10.U3 244.16,111.28 v1(243.76,111.68) ; U6.BB17 169.07,77.37 U6.BA18 ; UV1.AE30 210,102.4 v7(209.6,102.8) ; JEDP1.30 v7(77.55,39.8) ; v1(252.59,98.08) UV10.A14 ; v1(177.42,73.42) 177.35,73.48 U6.BF5 ; v1(195.47,115.27) UV6.U1 ; v1(158.06,79.98) 158.39,79.66 U6.AV33 ; UV1.D33 227.55,105.32 v1(227.39,105.48) ; v7(178.48,101.18) 178.83,100.83 U6.F3 178.9,100.86 179.45,100.86 U6.F2 ; U6.AD7 176.33,88.87 v7(176.44,88.99) ; UV5.U14 213.9,126.1 v1(214.28,126.48) ; U7.B2 274.51,22.26 U7.D1 273.51,21.26 v1(273.51,21.19) 273.31,21.38 U7.E1 ; U7.B2 274.5,22.24 U7.B1 ; U7.B2 274.54,22.28 U7.A2 275.12,21.74 275.4,21.46 v1(275.78,21.46) ; U6.BC38 155.31,76.16 v1(155.66,76.51) ; U6.BF12 171.97,73.71 v1(171.92,73.71) ; U6.G9 174.58,100.42 v7(174.97,100.8) 175.28,100.49 U6.G8 ; U6.A33 U6.B33 158.47,103.94 v1(158.12,103.6) 158.48,103.24 U6.C33 ; v1(146.83,81.24) 147.17,80.89 U6.AT50 ; v1(164.64,78.58) 164.32,78.26 U6.AY25 164.18,78.08 164.19,78.08 164.19,77.68 164.18,77.68 U6.BA25 164.18,76.87 U6.BB25 U6.BB23 ; v7(269.23,33.28) 269.59,33.65 U7.P30 ; U7.AP31 261.41,34.26 261.11,34.56 v1(261.11,34.68) 261.14,34.7 262.11,34.7 U7.AM32 ; v1(208.85,115.18) 208.67,115.37 UV6.A1 ; v7(227.24,82.72) 227.23,82.72 UV1.E7 226.6,83.15 226.6,83.15 226.21,83.15 226.21,83.15 UV1.F7 ; v1(147.52,84.48) 147.51,84.48 147.87,84.84 U6.AK49 ; UV10.K13 252.22,105.68 252.58,106.03 v1(252.58,106.05) ; v1(273.77,34.16) 273.82,34.22 U7.B31 ; UV6.A12 v1(208.27,124.07) ; U6.C30 160.85,103.24 v1(160.48,103.6) 160.82,103.94 U6.B30 U6.A30 160.85,104.64 v1(160.48,105) ; v1(155.76,102.2) 156.12,101.84 U6.E37 ; v7(207.1,104.4) 207.5,104 UV1.AH32 ; U6.E16 169.81,101.84 170.17,102.2 170.18,102.2 v1(170.18,102.19) 170.54,101.84 U6.E15 ; v1(253.55,101.68) UV10.E14 ; v1(222.87,119.44) 222.7,119.27 UV5.F5 ; v1(148.37,89.87) 148.49,89.99 148.9,89.99 U6.AB48 ; U6.L48 148.35,97.93 v1(148.35,98.01) ; U6.AR5 177.43,82.09 177.73,81.79 v1(177.73,81.68) ; v1(224.7,115.27) UV5.C1 ; UV6.F10 v1(205.07,122.47) ; v1(153.36,79.41) 153.36,79.41 U6.AW42 ; v1(151.04,105.01) 151.41,104.64 U6.A44 U6.B44 151.38,103.94 v1(151.04,103.6) 151.4,103.24 U6.C44 ; U7.AY20 258.24,29.68 258.09,29.54 v1(258.09,29.19) ; v1(26.4,23.45) 26.4,23.5 26.76,23.86 JHDD.19 ; UV5.F10 222.7,122.48 v1(222.82,122.36) ; v1(207.12,83.57) 206.7,83.15 UV1.AJ7 ; v7(207.55,78.4) UV1.AH2 ; UV6.C14 v1(207.47,126.47) ; v1(146.76,89.35) 147.17,88.95 U6.AD50 ; v1(207.9,100.27) 207.5,100.67 UV1.AH28 ; v1(204.28,119.64) 203.87,119.23 UV6.G5 ; U6.BB46 150.43,76.86 v1(150.78,76.51) ; UV1.K33 UV1.K32 222.55,103.91 v7(222.16,103.53) ; v7(270.51,25.55) 270.19,25.55 U7.N10 ; UV10.K14 253.08,105.68 v1(253.44,106.04) ; UV6.A14 v1(209.07,126.47) ; U6.U3 178.83,93.53 v7(178.48,93.87) 178.13,93.52 U6.U4 ; U6.P2 179.53,95.96 v7(179.88,96.31) 180.23,95.96 U6.P1 ; v1(146.12,79.6) 146.47,79.25 U6.AW51 ; U6.K5 177.43,98.4 v7(177.78,98.75) ; v7(219.76,79.39) 220.05,79.1 UV1.N2 ; v1(216.7,126.47) UV5.N14 ; v1(245.4,92.83) 245.4,92.83 UV9.T5 ; U6.Y48 149.08,91.58 v1(148.46,91.58) ; U6.H7 175.63,100.02 U6.G7 v7(175.98,100.86) ; v1(225.5,125.67) UV5.C14 ; v1(259.92,33.72) 259.92,33.53 U7.AT29 ; v1(253.49,81.74) 253.46,81.74 253.16,82.04 UV9.C14 ; v1(249.39,109.28) UV10.P10 ; UV1.B25 229.3,98.25 v7(229.67,98.25) ; U7.AJ24 U7.AK24 262.99,31.31 v7(262.66,31.64) ; v1(144.02,85.29) 144.02,85.34 U6.AJ54 ; UV1.B4 229.25,80.7 v7(229.78,80.7) ; U6.D44 151.4,102.54 v1(151.04,102.9) ; U7.H13 271.99,26.49 272.1,26.38 v1(272.1,26.25) 272.1,26.25 271.99,26.14 U7.H10 ; UV9.F10 249.79,84.52 v1(249.46,84.84) 249.79,85.17 UV9.G10 ; v7(179.12,85.8) 178.83,86.1 U6.AH3 ; v1(242.04,105.68) UV10.K1 UV10.K2 ; U6.P9 173.81,95.37 v1(173.64,95.21) ; U6.G54 144.37,100.31 v1(144,99.93) 144,99.89 U6.H54 ; UV1.AH22 207.48,95.65 v7(207.06,95.22) ; v1(195.88,119.98) 195.99,119.98 196.44,119.52 196.44,119.09 UV6.T5 ; U6.G18 168.65,100.06 168.65,100.55 v1(168.52,100.68) 168.22,100.38 U6.G19 167.76,100.47 167.76,101.34 167.36,101.75 U6.E20 ; v1(153.39,100.79) 153.81,100.38 U6.G40 ; UV5.A3 v1(226.3,116.87) ; v1(272.89,30.17) 273.25,30.17 274.04,30.96 274.64,30.96 U7.B23 ; v1(224.66,90.24) 225.07,90.65 UV1.G16 ; v7(272.22,34.7) 271.99,34.47 U7.H31 ; UV5.U1 214.27,115.3 v1(214.27,115.25) ; v1(180.58,83.31) 180.23,82.96 U6.AN1 180.15,82.9 180.08,82.82 179.68,82.82 179.6,82.9 U6.AN2 179.45,82.9 179.38,82.82 178.98,82.82 178.9,82.9 U6.AN3 178.83,82.83 v1(178.48,82.48) 178.13,82.83 U6.AN4 ; v7(178.42,89.05) 178.13,88.76 U6.AE4 ; 175.93,81.27 176.18,81.27 U6.AT6 ; 175.93,81.27 175.93,81.75 U6.AR7 ; 175.93,81.27 v1(175.93,81.27) ; v1(174.98,79.98) 174.66,79.66 U6.AV9 ; v1(242.97,92.85) 242.59,93.24 UV9.U1 ; JEDP1.27 v7(79.05,39.76) ; v1(202.82,82.81) 203.16,83.15 UV1.AN7 ; UV5.K1 v1(219.09,115.26) ; U7.R16 268.93,27.91 268.62,27.59 v1(268.62,27.55) ; v1(206.67,115.27) UV6.C1 ; UV1.C10 UV1.B10 v7(229.66,85.65) ; UV5.C12 225.1,124.43 v1(224.73,124.06) 225.1,123.68 UV5.C11 ; U6.B51 146.62,103.94 v1(146.25,103.57) 145.89,103.22 U6.C52 ; U6.AA48 148.71,90.83 148.35,90.47 v1(148.36,90.47) ; U6.AB50 147.17,90.63 v7(146.82,90.98) ; v1(253.4,92.86) 253.02,93.25 UV9.U14 ; v7(26.42,27.86) JHDD.11 ; v1(203.96,122.18) 203.87,122.28 UV6.G10 ; v1(12.24,26.36) 13.08,26.36 14.07,27.35 UA5.14 ; U6.F33 158.48,101.14 v1(158.12,101.5) ; UV1.AH5 v7(207.97,81.82) ; v1(223.96,122.37) 224.3,122.71 UV5.D10 ; U7.BA40 258.24,37.62 v1(257.85,37.23) 257.62,37.47 U7.BD39 ; U6.AH50 147.17,86.56 v1(146.82,86.91) 146.47,87.26 U6.AG51 146.47,87.38 v1(146.12,87.73) ; v1(224.67,86.06) 225.07,85.65 UV1.G10 ; U7.U40 268.34,38.35 v1(268.66,38.66) 268.38,38.94 U7.U42 ; UV5.C4 225.09,118.07 v1(224.69,117.67) 225.09,117.27 UV5.C3 ; U6.AP50 147.17,82.5 v1(146.82,82.85) ; U7.AB38 266.42,36.84 v1(266.59,36.84) 266.81,36.84 U7.Y36 ; UV5.B5 v1(226.3,118.47) ; v1(195.45,124.1) 195.82,124.47 UV6.U12 ; v1(229.58,79.38) 229.62,79.38 UV1.A2 ; U6.E17 168.91,101.84 v1(168.56,102.19) 168.56,102.2 168.55,102.2 168.18,101.84 U6.E19 ; UV1.AB32 212.52,104 v7(212.14,103.61) ; UV1.AH30 207.5,102.4 v7(207.1,102.8) ; UV6.N3 v1(198.67,116.87) ; v7(209.6,105.2) 210,104.8 UV1.AE33 ; U6.AH48 148.36,86.33 v1(148.36,86.27) 148.66,85.97 U6.AJ48 ; U7.U6 268.27,23.59 v1(268.54,23.86) ; v7(165.17,99.69) 165.49,100.01 165.49,100.02 U6.G23 ; U7.AD8 265.2,24.48 v1(265.01,24.48) ; v1(219.1,116.87) UV5.K2 ; U6.AH1 180.23,86.11 v7(180.53,85.8) ; UV6.P10 v1(197.87,122.47) ; U6.AV3 178.9,79.65 178.98,79.57 179.38,79.57 179.45,79.65 U6.AV2 179.6,79.65 179.68,79.57 180.08,79.57 180.15,79.65 U6.AV1 180.31,79.57 181.22,79.57 181.46,79.8 v1(181.46,80.05) ; UV6.H13 203.07,125.28 v1(203.48,125.7) ; U7.AW2 259.3,22.76 v1(259.56,23.02) ; UV1.E22 226.8,95.73 v1(227.2,96.13) ; v7(207.1,105.2) 207.5,104.8 UV1.AH33 ; v1(176.26,98.55) 175.98,98.83 U6.J7 ; v1(199.47,122.47) UV6.M10 ; v7(224.65,83.52) 225.07,83.1 UV1.G7 ; v7(272.92,34.74) 273.19,35.01 U7.F33 273.27,35.18 v1(273.93,35.84) U7.B35 ; v1(148.36,89.07) 148.35,89.07 148.71,89.43 U6.AC48 ; JEDP1.25 v7(80.05,39.76) ; U7.H26 v7(271.99,32.71) ; U6.AW54 144,78.82 v1(144,78.79) ; U6.AC7 175.91,89.57 v7(176.13,89.79) 176.13,90.2 U6.AB7 ; UV1.C16 228.28,90.77 228.28,91 228.2,91.08 v7(228.2,91.08) ; UV9.A12 251.39,80.44 v1(251.88,79.95) 252.49,79.95 UV9.A14 ; UV1.D31 227.55,103.2 v1(227.15,103.6) ; U6.AT1 180.57,81.28 v1(180.97,81.68) ; UV1.K30 v7(222.12,101.97) ; v1(158.1,100.81) 158.53,100.38 U6.G33 ; v1(149.61,79.41) 150.06,78.96 U6.AW46 ; U6.E22 165.75,101.84 166.11,102.2 166.12,102.2 v1(166.12,102.19) 166.19,102.19 U6.E21 ; UV10.N14 253.39,107.68 v1(253.39,107.68) ; v1(153.36,80.11) 153.36,80.11 U6.AV42 ; v1(215.9,123.27) UV5.P10 ; JHDD.17 26.57,24.86 26.27,24.57 v1(26.27,24.09) ; U6.BA51 146.47,77.68 v1(146.12,78.03) 145.77,77.68 U6.BA52 145.7,77.49 145.15,77.49 U6.BA53 ; UV10.U12 251.39,111.32 v1(251.01,111.7) ; U6.AT47 149.43,81.34 149.8,81.34 U6.AT46 150.32,81.29 150.75,81.29 150.98,81.06 U6.AT45 151.45,81.48 v1(151.54,81.48) 151.97,81.06 U6.AT43 ; U7.AV40 259.37,38.35 v1(259.1,38.07) ; v1(201.09,118.47) 201.09,118.49 200.7,118.87 UV6.L5 ; U6.F30 160.85,101.14 v1(160.48,101.5) ; v1(227.1,125.67) UV5.A14 ; v1(275.62,38.35) 275.34,38.35 275.12,38.57 U7.A41 U7.A43 ; v1(158.12,102.9) 158.48,102.54 U6.D33 ; v1(147.54,82.04) 147.54,82.11 U6.AP49 ; v1(266.62,30.02) 266.29,30.35 U7.AA22 ; v1(249.36,102.06) 249.78,102.48 UV10.F10 ; v1(257.7,35.82) 257.68,35.84 U7.BD35 ; U6.G20 167.09,100.26 v1(166.83,100.52) ; U6.AK9 173.63,85.37 v7(173.62,85.38) ; UV1.N19 220.8,93.46 220.38,93.88 v1(220.2,93.88) ; UV1.AB7 v7(212.95,82.7) ; U6.H49 148.24,99.74 v1(147.88,100.1) ; U6.T48 148.6,94.37 v1(148.44,94.54) 148.44,94.72 U6.R48 ; v7(258.72,27.38) 258.43,27.67 U7.AY15 ; UV6.T10 v1(197.07,123.27) UV6.R11 ; v1(250.2,110.89) 249.79,110.48 UV10.T10 ; v7(176.12,87.02) 175.88,87.02 U6.AG7 175.63,86.4 U6.AH7 ; v1(222.14,100.38) 222.24,100.38 UV1.K28 ; U6.AT15 170.76,81.58 v1(170.75,81.59) 171.26,81.59 U6.AR14 ; UV6.U14 v1(195.47,125.67) ; v1(261.07,38.02) 261.27,38.02 U7.AN40 261.74,38.5 U7.AN42 ; UV1.AH7 207.5,83.11 v1(207.9,83.51) ; v7(262.69,27.6) 262.99,27.91 U7.AK16 ; U6.N7 176.09,96.07 v1(176.37,96.35) 175.94,96.78 U6.M7 ; U11.3 v1(24.32,76.56) ; v1(221.93,119.42) 221.93,118.9 UV5.G5 ; v7(207.01,86.1) 207.46,85.65 UV1.AH10 ; v7(176.11,84.29) 175.96,84.44 U6.AL7 175.73,84.9 175.73,85.28 U6.AK7 ; v1(147.57,99.13) 147.87,98.83 U6.J49 ; UV10.R12 v1(250.99,109.28) UV10.R11 ; U6.BF49 147.84,73.77 148,73.61 v1(148.3,73.61) 148.7,74 U6.BF48 ; U6.BC3 178.82,76.26 v1(178.44,75.89) 179.06,75.89 U6.BD2 ; v1(274.16,39.3) 274.52,39.66 U7.B44 ; v7(176.11,95.08) 175.82,95.37 U6.P7 ; v1(273.65,32.92) 273.65,32.92 273.34,33.23 U7.F29 ; UV6.D10 v1(206.67,122.47) ; U6.B15 170.54,103.94 v1(170.18,104.29) ; UV1.E25 226.38,98.56 v1(226.38,98.56) ; U6.A8 175.48,104.54 U6.B8 175.45,103.94 v7(175.1,103.59) 175.45,103.24 U6.C8 ; U7.AM26 262.33,32.16 v7(262,32.48) 262.33,32.81 U7.AM28 U7.AM30 ; U6.AH2 179.53,86.1 v7(179.82,85.8) ; U6.AB51 146.76,90.29 v1(146.76,90.17) 147.17,89.76 U6.AC50 ; U6.AW47 149.12,78.96 v1(148.67,79.41) ; v1(242.04,103.86) 242.26,104.08 UV10.H1 242.67,104 243.3,104 UV10.H2 ; v7(222.9,81.85) 222.55,81.5 UV1.K5 ; v1(221.04,71.95) 220.84,72.16 RPH33.5 ; U6.AV18 168.97,79.66 v1(169.34,79.28) 169.02,78.96 U6.AW18 ; UV10.E1 242.53,101.63 242.06,101.63 v1(242.05,101.64) ; v1(246.32,103.43) 246.16,103.28 UV10.G5 ; UV5.N1 v1(217.51,115.26) ; v1(204.59,101.08) 205,100.67 UV1.AL28 ; v7(271.78,31.76) 271.99,31.54 U7.H24 ; U6.K4 178.13,98.4 v7(178.48,98.75) ; v1(251.79,108.48) UV10.N12 ; v1(220.25,88.91) 220.76,88.4 UV1.N14 ; U7.AJ20 263.65,29.39 v7(263.84,29.2) 263.65,29.01 U7.AJ18 ; U6.AJ49 147.87,85.65 147.51,85.29 v1(147.52,85.29) ; UV9.E14 252.6,83.26 v1(252.6,83.25) ; v1(245.38,110.88) 245.77,110.48 UV10.T5 ; v1(242.07,108.11) 242.08,108.12 242.55,108.12 UV10.N1 ; v7(172.62,102.19) 172.97,101.84 U6.E11 ; U7.B27 274.03,32.59 v1(273.71,32.28) ; U6.B26 163.26,103.94 v1(162.91,104.29) 163.27,104.64 U6.A26 ; U7.BD7 v7(257.73,24.47) ; v1(246.19,89.64) 245.79,89.25 UV9.M5 ; U6.D40 153.76,102.54 v1(153.4,102.9) ; U6.J44 151.4,99.04 v1(151.04,99.4) ; JEDP1.34 v7(75.55,39.8) ; UV6.U3 195.87,117.26 v1(195.47,116.86) ; v1(242.19,88.05) UV9.K1 ; v1(251.79,92.05) UV9.R12 ; U6.AT22 166.08,81.06 v1(166.52,80.62) 166.96,81.06 U6.AT20 ; U6.C19 168.18,103.24 168.55,103.6 168.56,103.6 v1(168.56,103.59) ; v1(147.88,102.2) 148.24,101.84 U6.E49 ; U7.AP24 261.41,31.46 v1(261.74,31.79) 262.29,31.23 U7.AM24 ; v1(244.59,89.65) UV9.N3 ; UV9.B5 245.37,80.83 v1(245.38,80.83) ; v7(26.68,33.15) 26.98,32.86 JHDD.1 ; v1(243.79,98.88) UV10.A3 ; U6.BB39 154.38,76.86 v1(154.03,76.51) ; U6.AV29 161.5,79.66 v1(161.82,79.98) ; v1(28.56,80.76) 28.55,80.77 U11.18 ; v1(180.92,98.19) 180.77,98.34 U6.K1 ; v1(85.41,39.26) 85.55,39.41 JEDP1.14 ; U7.M17 270.2,28.54 v7(270.54,28.2) ; v1(158.17,81.53) 157.7,81.06 U6.AT35 ; U6.V50 147.17,93.06 v1(146.85,93.39) 147.17,93.72 U6.U50 ; UV1.E5 226.79,81.4 v7(226.36,80.98) ; U6.AB52 145.77,90.63 v7(146.12,90.98) ; v7(175.63,97.28) 175.93,97.57 U6.L7 ; UV1.AN34 203.4,105.6 v1(202.94,106.05) ; U6.AR48 148.95,81.77 v1(148.59,81.41) 148.23,81.06 U6.AT49 ; U6.K3 178.83,98.4 v7(179.18,98.75) ; UV6.M5 v1(199.47,118.47) ; UV1.E10 226.65,85.65 v1(226.3,85.3) ; v1(226.3,115.27) UV5.A1 ; v1(244.59,101.28) UV10.E3 ; v1(253.35,103.66) 253.33,103.69 253.33,103.69 252.99,104.03 UV10.H14 UV10.H13 ; U7.AM16 262.33,27.9 v7(262.06,27.63) 262.33,27.36 U7.AM14 ; U6.J54 144.15,98.92 143.93,98.92 v1(143.76,99.09) ; UV10.A1 242.05,98.48 v1(242.01,98.44) ; UV10.D10 249.75,100.88 v1(249.39,101.24) ; v1(146.12,89.35) 146.12,89.3 U6.AD51 ; U6.AC5 177.72,89.11 v7(177.72,89.05) ; UV5.R14 v1(215.1,125.67) ; v1(147.88,100.8) 148.24,100.44 U6.G49 ; U6.U54 143.83,94.37 v1(143.76,94.37) ; U6.AR8 175.63,82.15 U6.AP7 176.21,82.47 v1(176.24,82.44) ; U6.C37 156.12,103.24 v1(155.76,103.6) 156.1,103.94 U6.B37 U6.A37 156.12,104.64 v1(155.76,105) ; UV6.E14 v1(205.87,126.47) ; v1(244.59,107.68) UV10.N3 ; U6.BB54 143.71,76.77 v1(143.25,77.22) 143.5,77.47 U6.BA54 ; v7(145.42,90.98) 145.07,90.63 U6.AB53 ; v1(222.44,82.18) 222.55,82.29 UV1.K7 ; U7.AT26 259.84,32.63 v1(259.84,32.76) ; v1(146.82,85.29) 147.17,84.94 U6.AK50 ; U6.AU37 155.62,80.36 v1(155.24,80.73) 155.57,81.06 U6.AT37 ; v1(224.72,97.73) 225.1,98.11 UV1.G25 ; v1(244.59,83.24) UV9.E3 ; v1(249.39,83.22) 249.76,82.84 UV9.D10 ; v1(158.91,76.51) 159.26,76.86 U6.BB32 ; UN1.3 38.17,35.06 v1(38.35,35.25) ; v7(170.11,100.53) 170.19,100.45 U6.G16 ; U6.BA42 152.88,77.58 152.88,78.23 U6.AY42 153.36,78.71 v1(153.36,78.71) ; v1(227.08,124.08) 226.7,124.46 UV5.A12 ; v1(146.09,99.08) U6.J51 ; v1(205.07,115.27) UV6.E1 ; v1(174.98,79.28) 174.66,78.96 U6.AW9 ; U7.AD18 265.63,28.77 v1(265.25,28.39) 265.63,28.01 U7.AD16 ; U6.BF43 151.65,73.71 v1(151.6,73.71) ; UV1.T5 217.55,81.66 v7(217.79,81.91) ; U6.G26 163.13,100.98 U6.F26 163.23,101.14 v1(162.88,101.49) 162.95,101.49 U6.E26 163.23,101.84 v1(162.88,102.19) 162.95,102.19 U6.D26 163.23,102.54 v1(162.88,102.89) 162.95,102.89 U6.C26 ; JEDP1.35 v7(75.05,39.8) ; v1(145.39,94.2) U6.U52 ; UV9.K13 252.32,87.65 252.58,87.39 v1(252.58,87.22) 252.99,87.63 UV9.K14 ; U6.BF46 150.03,73.71 v1(149.97,73.71) ; v1(145.39,97.45) U6.M52 ; U7.AV31 259.18,34.65 258.61,34.65 258.61,34.65 v1(258.61,34.65) ; UV5.M10 v1(217.5,122.47) ; v1(246.31,85.24) UV9.G5 ; U6.G52 145.87,100.18 v1(146.12,99.93) 146.47,99.58 U6.H51 ; UV5.B10 225.9,122.88 v1(225.53,123.26) ; v1(146.12,86.1) 146.47,85.75 U6.AJ51 ; UV5.E12 v1(223.1,124.87) ; U6.BB41 153.68,76.86 v1(154.03,76.51) ; U6.AG53 145.07,87.38 v1(145.42,87.73) 145.77,87.38 U6.AG52 ; v1(251.79,90.45) UV9.N12 ; JEDP1.33 v7(76.05,39.8) ; v1(242.99,110.87) 242.59,111.27 UV10.U1 ; UV1.AH16 v7(207.08,90.22) ; U7.AL38 262.52,37.15 262.15,36.79 v1(262.03,36.79) 261.82,36.79 261.59,36.56 U7.AN36 ; v7(11.47,21.7) UA5.19 ; U6.P54 144.3,95.38 v1(143.75,95.38) ; v7(215.33,104.39) 215.05,104.11 UV1.W32 ; v1(267.94,32.45) 267.61,32.12 U7.V26 ; UV1.T28 217.55,100.77 v1(217.16,101.17) ; v1(197.08,118.48) 197.47,118.09 UV6.R4 ; U6.AM52 145.77,84.13 v1(146.12,84.48) 146.47,84.13 U6.AM51 146.47,84.01 v1(146.82,83.66) 147.17,83.31 U6.AN50 ; v1(145.4,99.93) 145.77,99.55 U6.H52 ; U6.AD9 173.96,88.87 v1(173.95,88.88) ; v1(146.79,97.45) U6.M50 ; v1(153.4,102.2) 153.76,101.84 U6.E40 ; UV1.AN10 v7(202.92,85.65) ; U7.R2 v7(269.06,22.53) ; v1(251.79,102.08) UV10.E12
  BOTTOM w0.279: v7(172.14,20.95) 171.77,20.58 JKB.30 ; v1(173.09,21.03) 172.77,20.71 JKB.29
  BOTTOM w0.3: v1(207.08,97.72) UV1.AH24
  BOTTOM w0.305: UV1.AB23 212.28,96.92 ; 212.28,96.92 UV1.AA22 ; 212.28,96.92 v1(212.37,96.92) ; UV1.U12 216.77,86.4 v1(216.3,86.87) 215.83,86.4 UV1.V12 ; JKB.29 172.77,19.58 173.06,19.29 173.65,19.29 173.77,19.41 JKB.28 ; UV1.T18 217.8,92.43 v1(218.29,92.91) 218.77,93.4 UV1.R19 ; v1(229.61,78.56) 229.28,78.22 229.22,78.22 UV1.B1 ; UV1.G32 225.44,103.61 v7(225.44,103.59) ; UV1.Y23 213.86,97.4 v1(214.34,96.93) 214.8,96.46 UV1.W22 ; v1(220.19,92.91) 219.8,92.53 UV1.P18 ; UV1.AB12 211.93,86.4 v1(212.4,86.87) 212.8,87.27 UV1.AA13 ; UV1.M22 221.75,96.4 v7(221.36,96.01) 220.8,95.45 UV1.N21 ; UV1.AA15 212.8,89.27 v1(212.4,88.87) 211.93,88.4 UV1.AB14 ; v1(212.15,102.02) 212.53,102.4 UV1.AB30 ; UV1.T17 217.9,91.4 v1(218.3,91) 218.8,90.5 UV1.R16 ; JNFC1.1 v7(122.8,18.4) ; UV1.W18 v1(214.27,92.93) UV1.Y19 ; v1(219.63,102.85) 220.05,102.43 UV1.N30 ; UV1.U21 216.71,95.4 v1(216.3,94.99) 215.89,95.4 UV1.V21 ; UV1.V19 215.82,93.4 v1(216.3,92.91) 216.78,93.4 UV1.U19 ; UV1.AA18 v1(212.27,92.93) ; UV1.AB16 211.58,90.4 v1(211.27,90.09) 210.8,89.62 UV1.AC15 ; UV1.Y12 213.93,86.4 v1(214.4,86.87) 214.8,87.27 UV1.W13 ; UV1.Y21 213.95,95.4 v1(214.4,94.95) 214.8,94.55 UV1.W20 ; UA5.6 8.87,27.53 v1(8.52,27.19) 8.22,27.49 UA5.5 ; UV1.V14 215.83,88.4 v1(216.3,88.87) 216.77,88.4 UV1.U14 ; UV1.T22 217.8,96.59 v1(218.14,96.93) 218.33,96.93 UV1.R23 ; JTP.7 206.75,22.11 206.88,21.97 v1(206.88,21.79) ; UV1.AC17 210.8,91.53 v1(211.32,91.96) UV1.AC18 ; v1(220.14,90.95) 219.8,91.29 UV1.P17 ; UV1.W15 214.8,89.27 v1(214.4,88.87) 213.93,88.4 UV1.Y14 ; v1(225.51,101.12) 225.95,100.68 UV1.F28 ; 211.38,93.82 v1(211.38,93.82) ; 211.38,93.82 UV1.AC20 ; 211.38,93.82 UV1.AB19 ; U7.BE3 256.59,22.77 257.1,22.27 U7.BD2 ; UV1.P22 219.8,96.54 v1(220.18,96.92) 220.66,97.4 UV1.N23 ; UV1.P13 219.8,87.27 v1(220.2,86.87) 220.67,86.4 UV1.N12 ; v1(220.25,88.91) 219.8,89.36 UV1.P15 ; v1(214.63,101.1) 215.03,100.7 UV1.W28 ; UV1.V16 215.8,90.51 v1(216.3,91.01) 216.8,90.51 UV1.U16 ; UV1.AA17 212.8,91.21 v1(212.46,90.87) ; UV1.R14 218.79,88.4 v1(218.31,88.88) 217.8,89.39 UV1.T15 ; UV1.T13 217.8,87.36 v1(218.29,86.87) 218.76,86.4 UV1.R12 ; UV1.N28 v1(219.66,100.31) ; UV1.T20 217.8,94.59 v1(218.2,94.99) 218.61,95.4 UV1.R21 ; v1(220.2,94.99) 219.8,94.59 UV1.P20 ; UV1.Y16 214.27,90.87 v1(214.46,90.87) 214.8,91.21 UV1.W17 ; UV1.U23 216.71,97.4 v1(216.24,96.93) 215.8,97.36 UV1.V23 ; UV1.M20 221.8,94.31 v1(221.45,93.96) 220.89,93.4 UV1.N19 ; UV1.AC22 v1(211.38,95.82) UV1.AB21 ; UV1.N16 220.94,90.4 v7(221.36,89.99) 221.8,89.54 UV1.M15 ; UV1.AA20 212.4,94.8 v1(212.4,94.93)
  BOTTOM w0.356: JDIMM1.128 149.4,27.37 149.21,27.56 v1(148.88,27.56) ; JDIMM2.13 187,32.53 v1(187.26,32.27) ; v1(237.73,36.13) 237.4,35.81 JDIMM2.173 ; v1(202.54,30.97) 202,31.52 JDIMM2.63 ; v1(121.3,32.84) 121.5,33.04 JDIMM1.43 ; JDIMM2.156 232.3,27.65 v1(232.9,28.25) ; JDIMM1.65 128.1,35.79 127.25,36.64 v1(127.14,36.64) ; JDIMM2.49 197.8,35.71 v1(197.4,36.11) ; JDIMM2.9 185.8,36.45 v1(187.37,38.02) ; JDIMM1.37 119.7,33.26 v1(119.27,32.83) ; JDIMM1.145 154.5,33.24 154.2,32.94 v1(154.09,32.94) ; v1(150.54,28.25) 151.2,27.59 JDIMM1.134 ; JDIMM2.71 204.4,34.99 204.9,35.49 204.9,35.96 v1(204.37,36.5) ; JDIMM1.9 111.3,33.09 v1(111.65,32.73) ; JDIMM1.28 117,25.13 v1(116.65,24.77) 116.4,25.02 JDIMM1.26 ; v1(224.5,28.25) 223.9,27.65 JDIMM2.128 ; v1(123.11,32.84) 123.3,33.03 JDIMM1.49 ; JDIMM1.25 116.1,33.15 v1(116.46,32.79) ; JDIMM2.61 201.4,30.72 v1(201.27,30.59) ; v1(191.9,36.11) 191.9,35.93 192.4,35.44 JDIMM2.31 ; JDIMM2.196 244.3,27.2 244.66,27.57 v1(244.98,27.57) ; JDIMM2.189 242.2,33.33 v1(241.9,33.03) 241.6,33.33 JDIMM2.187 ; JDIMM1.187 167.1,33.03 166.93,32.86 v1(166.44,32.86) 166.44,33.19 166.5,33.25 JDIMM1.185 ; v1(184.62,24.58) 184.2,24.58 183.7,25.09 JDIMM2.2 ; JDIMM2.32 v1(192.7,24.52) ; JDIMM1.161 159.3,33.16 158.89,32.75 v1(158.38,32.75) 157.82,32.75 157.5,33.07 JDIMM1.155 ; v1(164.46,32.91) 164.7,33.15 JDIMM1.179 ; v1(199.29,36.5) 199.87,35.91 199.87,35.54 199.6,35.27 JDIMM2.55 ; JDIMM2.179 239.2,32.36 v1(239.69,31.87) 241,33.19 JDIMM2.185 ; v1(109.15,28.59) 108.55,28 108.55,27.64 109.2,27 JDIMM1.2 ; JDIMM2.155 232,35.53 v1(231.02,36.51) ; JDIMM2.145 229,33.19 228.65,32.84 v1(228.26,32.84) ; JDIMM2.26 190.9,24.75 v1(191.15,24.5) 191.5,24.85 JDIMM2.28 ; JDIMM1.133 150.9,33.39 v1(151.41,32.88) ; v9(129.89,24.77) 130.2,25.08 JDIMM1.72 ; JDIMM2.11 186.4,35.53 v1(187.37,36.5) ; v1(240.94,24.8) 240.7,25.03 JDIMM2.184 ; JDIMM1.136 151.8,25 v1(151.59,24.78) ; JDIMM1.190 168,27.54 v1(167.68,27.87) ; JDIMM1.14 112.8,27.5 v1(112.22,28.08) ; JDIMM1.138 152.4,24.74 v1(152.4,24.74) ; v1(230.85,27.87) 230.5,27.52 JDIMM2.150 ; JDIMM1.173 v1(162.9,32.94) ; JDIMM2.138 226.9,24.97 226.53,24.6 225.35,24.6 v1(225.31,24.63) ; JDIMM2.54 199.3,28.5 v1(198.73,29.07) ; v1(234.23,27.64) 234.1,27.52 JDIMM2.162 ; JDIMM1.195 169.5,35.39 169.64,35.54 169.64,36.04 v1(169.04,36.64) ; JDIMM1.19 114.3,35.81 115.14,36.64 v1(115.15,36.64) ; JDIMM1.32 118.2,25.18 118.59,24.78 v1(119.06,24.78) 119.83,24.78 120,24.95 JDIMM1.38 ; v1(124.7,24.71) 124.7,24.9 124.8,25 JDIMM1.54 ; JDIMM2.127 223.6,32.77 v1(223.73,32.64) ; JDIMM2.151 230.8,33.38 231.16,33.03 v1(231.16,32.93) 231.4,33.17 JDIMM2.153 ; JDIMM2.136 226.3,27.2 v1(225.97,27.53) ; JDIMM2.19 188.8,35.39 v1(189.91,36.5) ; v1(202.57,24.58) 202.57,24.57 202.9,24.91 JDIMM2.66 ; v1(193.17,36.5) 194.2,35.47 JDIMM2.37 ; v1(235.44,28.25) 235.99,27.69 235.99,27.26 235.9,27.16 JDIMM2.168 ; JDIMM2.190 242.5,27.33 v1(243.41,28.25) ; v1(235.09,32.83) 235.09,32.84 235.6,33.35 JDIMM2.167 ; JDIMM1.178 164.4,25.09 164.7,24.79 v1(165.29,24.79) 166,24.79 166.2,24.99 JDIMM1.184 ; JDIMM2.3 184,33.27 v1(184.9,32.37) ; JDIMM1.20 114.6,27.86 v1(114,28.46) ; JDIMM2.178 238.9,24.97 v1(239.09,24.78) ; JDIMM2.72 204.7,28.08 v1(204.63,28.15) ; v1(109.79,32.52) 109.5,32.81 JDIMM1.3 ; JDIMM2.139 227.2,35.9 v1(227.44,36.13) ; v1(112.05,24.58) 111.61,24.58 111,25.19 JDIMM1.8 ; v1(117.9,32.84) JDIMM1.31 ; v1(195.71,36.5) 196.25,35.96 196.25,35.51 196,35.27 JDIMM2.43 ; JDIMM2.46 196.9,27.36 197,27.46 197,28.53 v1(196.46,29.07) ; JDIMM2.8 185.5,24.6 v1(185.44,24.54) ; JDIMM2.144 v1(228.7,27.48) ; v1(125.14,32.82) 125.1,32.86 JDIMM1.55 ; JDIMM1.60 126.6,25.1 126.21,24.71 v1(125.87,24.71) ; JDIMM2.20 189.1,24.96 188.66,24.52 v1(188.4,24.52) 187.7,24.52 187.3,24.92 JDIMM2.14 ; JDIMM1.71 129.9,35.17 130.22,35.5 130.22,36.08 129.66,36.64 v1(129.66,36.64) ; JDIMM2.38 194.5,25.03 194.94,24.58 v1(195.79,24.58) 196.04,24.58 196.3,24.84 JDIMM2.44 ; JDIMM1.167 161.1,32.88 v1(161.15,32.83) ; JDIMM1.168 161.4,27.22 161.51,27.33 161.51,27.64 v1(160.9,28.25) ; v1(152.7,32.94) JDIMM1.139 ; v1(168.95,28.25) 169.8,27.39 JDIMM1.196 ; v1(244.27,32.9) 244,33.17 JDIMM2.195 ; JDIMM1.151 156.3,33.14 v1(156.6,32.84) 156.9,33.14 JDIMM1.153 ; v1(198.73,30.59) 197.5,29.36 JDIMM2.48 ; v1(158.87,28.25) 159.6,27.52 JDIMM1.162 ; v1(167.12,36.64) 167.7,36.06 JDIMM1.189 ; JDIMM1.44 121.8,24.99 122.12,24.67 122.35,24.67 v1(122.4,24.72) JDIMM1.46 ; JDIMM1.48 123,27.82 122.36,28.46 v1(121.45,28.46) ; v1(128.33,28.08) 128.4,28.01 JDIMM1.66 ; JDIMM2.25 v1(190.6,32.33) ; JDIMM1.170 162,27.24 v1(162.34,27.58) 162.6,27.32 JDIMM1.172 ; JDIMM2.65 202.6,35.75 v1(201.85,36.5) ; v1(233.14,36.51) 233.48,36.51 233.8,36.2 JDIMM2.161 ; v1(224.85,32.83) 225.4,33.37 JDIMM2.133 ; v1(201.93,24.6) 201.47,24.6 201.1,24.97 JDIMM2.60 ; JDIMM1.63 127.5,32.97 127.31,32.77 v1(126.92,32.77) 126.9,32.79 JDIMM1.61 ; JDIMM2.172 237.1,25.18 v1(236.69,24.78) 236.5,24.97 JDIMM2.170 ; JDIMM1.127 v1(149.1,32.77)
  BOTTOM w0.381: v1(225.97,27.53) 225.7,27.26 JDIMM2.134 ; JDIMM1.13 112.5,32.93 112.31,32.73 v1(111.65,32.73) ; RE42.2 151.32,19.01 UE2.3 ; v1(202.98,102.7) 203.38,102.3 UV1.AN30 ; v1(156,27.46) JDIMM1.150 ; JDIMM1.156 157.8,27.16 v1(157.09,27.87) ; JDIMM1.144 v1(154.2,27.46)
  BOTTOM w0.406: v1(133.91,69.25) 133.54,69.25 132.72,68.43 UU3.3
  BOTTOM w0.432: PQ231.4 43.39,36.11 v1(43.78,35.72)
  BOTTOM w0.457: RV430.2 33.17,100.13 v1(32.95,99.92)
  BOTTOM w0.508: v1(79.56,34.87) 79.78,34.87 80.18,34.47 PC209.1 ; v1(13.75,94.56) 13.44,94.88 CV769.2 ; CI26.2 22.34,76.89 v1(21.82,77.42) ; CV709.2 v1(240.09,77.8) ; CE34.2 179.84,22.56 CE30.2 180.82,23.2 v1(181.04,23.41) ; CH27.2 261.41,43.14 v1(262,42.55) ; RV365.1 v1(193.64,128.03) HT2.2 ; CA42.2 CA41.2 3.02,21.59 v1(2.73,21.88) ; RV389.1 239.86,104.35 v1(240.07,104.55) ; v1(235.28,17.48) 235.45,17.31 JKBL.6 ; R59.2 v1(133.91,70.65) ; v1(138.36,104.27) 138.74,103.9 CU36.1 ; v1(189.04,23.38) 188.76,23.1 CE33.2 CE52.2 CE39.2 ; CE4.2 164.59,15.16 v1(164.59,15.69) 164.59,15.83 CE7.2 ; PQ203.4 68.2,29.46 68.39,29.65 v7(68.39,30.23) ; PC996.2 PC995.2 v1(140.94,91.59) ; v1(189.78,23.38) CE31.2 CE37.2 CE35.2 ; v1(225.36,75.32) 225.05,75.32 224.59,74.85 CV576.2 ; v1(198.67,115.27) 199.76,114.18 CV685.2 ; v7(249.64,9.79) CM33.2 ; v1(23.23,107.69) JTS.8 ; PC811.2 138.67,117.28 v1(138.95,117.01) ; v1(22.45,60.72) 22.45,60.27 22.07,59.89 DI2.1 ; v1(263.69,52.14) 263.69,51.85 263.91,51.63 CH6.1 ; v1(251.39,22.4) 251.62,22.18 RH69.2 RH68.2 ; RN21.2 40.08,31.87 RN30.2 40.85,31 v1(41.33,30.51) ; JDIMM2.205 v1(182.25,39.13) ; v1(202.61,111.46) RV363.1 ; RV352.1 223.35,111.44 223.79,111.87 RV341.2 223.79,112.71 v1(223.14,113.36) ; RV501.1 v1(231.52,73.22) ; CE48.2 v7(178.81,22.56) ; PR709.1 119.26,118 v1(118.81,117.55) 119.25,117.11 PR707.1 ; v7(27.7,34.73) 27.17,35.26 JHDD.21 ; PC218.2 84.35,29.85 v1(84.95,29.26) ; CLRP2.1 v1(263.65,47.82) 263.65,46.57 YH2.2 ; RH27.2 141.23,93.86 v1(141.67,94.31) 141.16,94.81 RU67.2 ; v1(136.5,118.73) PC820.2 ; v1(196.99,23.38) 196.78,23.17 CE46.2 CE41.2 CE51.2 ; CZ8.2 211.67,69.43 CZ6.2 v1(212.28,69.41) ; v1(96.95,45.33) RV469.2 ; PR223.2 81.23,34.76 v1(81.34,34.87) ; v1(17.02,24.14) 16.64,23.76 CA64.1 ; RV418.2 239.2,89.23 v1(238.82,89.61) ; RU62.1 139.39,65.41 v1(138.96,65.84) 139.42,66.3 CU39.2 ; v1(280.61,23.33) 279.93,23.33 279.66,23.06 RH172.2 ; RU68.2 138.08,107.61 v1(138.17,107.7) 138.27,107.61 RU87.2 ; v7(47.92,45.52) 47.75,45.69 PQ101.3 47.31,47.35 PR106.2 ; v1(255.79,54.31) 256.22,54.74 256.22,56.06 ; YH2.4 260.73,44.82 260.01,45.55 v1(260.01,46.62) ; v1(175.7,41.54) 175.04,42.2 JDIMM1.206 ; v1(107.49,47.95) 107.49,47.14 107.75,46.88 JDIMM1.205 ; RV391.1 252.03,114.43 251.65,114.05 v1(251.65,113.29) ; v1(151.4,19.83) 151.13,19.57 RE42.2 ; CE15.2 147.75,17.61 v1(147.28,18.08) ; RU86.2 135.86,106.59 v1(135.7,106.75) ; JDIMM2.206 246.44,42.2 v1(245.68,42.96) ; JFAN1.4 54.1,33.04 v1(54.85,32.29) ; v1(20.89,112.99) JTS.6 ; YV1.2 225.02,70.7 v1(225.55,70.18) ; v1(194.52,23.43) 194.75,23.2 CE44.2 CE49.2 ; RV354.1 211.65,127.84 v1(211.96,128.15) ; RU74.2 145.16,70.25 v1(145.6,70.7) ; PR508.2 225.94,69.62 v1(225.93,69.6) ; JEDP1.41 v1(68.93,38.7) ; RV323.2 v1(198.11,80.92) ; CA7.2 27.04,41.16 26.86,41.35 ; v1(272.6,43.44) 272.59,43.45 RH62.2 ; PQ207.3 v1(82.95,24.23) ; v1(31.44,27.68) CN1.2 CN2.2 ; PC317.2 46.15,25.74 v1(46.15,27.62) ; v1(21.95,112.94) JTS.7 ; RE58.2 CE16.2 156.73,16.9 156.31,16.48 v1(156.13,16.48) 155.6,16.48 CE19.2 ; v1(16.51,21.53) CA89.2 ; v1(137.79,101.29) 137.38,100.88 RU11.1 136.47,100.88 RU33.1 ; v1(138.29,127.53) PR827.1 ; v1(181.71,23.4) CE28.2 CE36.2 ; v1(264.48,42.81) 264.1,43.18 CH28.2 ; RU85.2 138.33,105.57 v1(138.3,105.55) 138.27,105.58 RU115.2 ; v1(167.89,105.99) 167.51,105.99 165.91,107.59 RH31.2 ; DI3.1 v1(23.94,118.73) ; PR502.1 v1(226.88,66.81) ; CH5.2 v1(260.1,51.96) ; PR837.1 147.93,122.2 PC823.2 v1(147.26,122.95) ; PR704.1 118.81,116.22 v1(118.81,116.21) ; CA76.2 CA75.2 v1(11.49,32.6) ; UZ600.5 254.95,54.62 254.63,54.3 v1(254.19,54.3) ; CLRP1.2 260.36,48.07 v1(260.6,47.82) ; RV451.2 RV449.2 RV430.2 ; PC1000.2 178.27,108.75 v1(177.86,108.34) 177.38,108.82 PC999.2 ; v7(119.81,22.53) RN9.2 ; CI27.2 27.99,62.88 v1(27.94,62.82) ; PC316.2 v1(37.85,25.73) ; v1(31.36,26.68) CN6.2 CN4.2 CN5.2 ; QV38.3 v1(99.93,46) ; v1(21.64,88.67) PC100.2 PC101.2 PC120.2 ; PC710.2 124.86,123.53 PR727.1 v1(125.73,124.21) ; v1(231.07,68.59) 230.76,68.91 PR505.2 ; PC106.2 110.91,22.36 PC107.2 111.24,23.32 v1(111.87,22.69) ; v1(10.04,92.25) 10.32,91.97 RV453.2 CV32.1 ; v1(237.62,84.78) 238.38,85.54 RV378.1 ; RV300.2 216.15,71.51 v1(216.6,71.06) ; JNFC1.16 124.9,17.71 v9(124.78,17.83) ; JTP.9 211.85,21.49 v7(211.85,21.5) ; RV299.2 v1(215.29,75.47) ; CA83.2 17.22,30.18 v1(17.46,30.42) ; v1(113.85,17.89) 113.7,17.74 JNFC1.17 ; JHDD.22 23.66,20.96 v1(23.51,21.11) ; RV380.1 v1(254.81,76.39) ; RV324.2 v1(197.98,83.05) ; v1(18.27,103.96) 17.54,103.23 DE2.1 ; v1(183.39,23.41) 183.74,23.06 CE47.2 CE43.2 CE45.2 ; 258.76,56.06 v1(258.76,54.08) ; CV767.2 14.84,114.13 CV766.2 v1(13.4,114.13) ; CH14.1 v1(270,41.79) ; PC212.2 v1(75.86,24.5) ; v1(248.68,76.41) 248.36,76.41 RV381.2 CV700.2 ; JHDD.24 23.64,24.21 23.86,23.99 25.67,23.99 25.77,24.09 v1(26.27,24.09) ; v1(77.61,34.84) 77.46,34.69 77.46,34.33 PC211.2 ; CE57.2 v7(29.78,65.71) ; YV1.4 v1(228.28,73.06) ; D8.1 4.25,33.18 v1(3.26,32.19) ; CE50.2 193.8,22.56 CE38.2 v1(192.76,23.4) ; RV290.2 v1(197.5,103.23) ; CV787.2 v1(13.88,96.41) ; v1(280.1,34.74) 280.86,34.74 281,34.6 JSSD.43 ; RV408.2 v7(85.65,34.87) ; JKB.31 v1(202.92,12.71) ; RV330.2 v1(229.61,73.22) ; v1(257.49,54.08) UZ600.7
  vias: v1(1.18,120.02) v1(1.18,117.53) v1(1.23,100.82) v1(1.2,98.92) v1(1.23,96.7) v1(1.23,86.73) v1(1.23,84.69) v1(1.18,5.77) v1(1.26,3.36) v1(1.7,0.53) v1(3.59,0.52) v1(3.79,120.02) v1(4.25,3.34) v1(4.61,96.68) v1(4.86,64.3) v1(4.86,49.13) v1(5.35,86.75) v1(5.52,98.66) v1(5.57,82.76) v1(6.16,117.56) v1(6.41,120.02) v1(6.41,96.7) v1(6.95,100.82) v1(7.23,67.63) v1(7.23,64.29) v1(7.22,49.16) v1(7.38,84.36) v1(7.43,0.53) v1(8.44,26.42) v1(8.44,24.9) v1(8.62,118.91) v1(8.67,117.58) v1(9.02,120.02) v1(9,3.36) v1(9.36,24.02) v1(9.59,82.79) v1(9.56,0.49) v1(9.84,25.6) v1(10.01,24.02) v1(10.09,114.94) v1(10.07,103.59) v1(10.24,67.63) v1(10.24,64.29) v1(10.77,9) v1(10.77,6.34) v1(10.77,3.67) v1(11.44,118.75) v1(11.63,120.02) v1(12.15,79.44) v1(12.15,76.62) v1(12.15,73.8) v1(12.15,70.98) v1(12.15,60.94) v1(12.15,58.12) v1(12.15,55.3) v1(12.15,52.48) v1(12.44,24.84) v1(13.02,66.45) v1(13.04,65.24) v1(12.97,11.51) v1(15.76,87.72) v1(15.94,94.35) v1(15.9,92.65) v1(16.52,94.35) v1(16.47,90.77) v1(17.02,27.82) v1(17.08,25.92) v1(17.36,82.38) v1(18.58,96) v1(18.92,27.82) v1(18.92,25.98) v1(20.54,95.97) v1(20.47,82.93) v1(20.83,27.82) v1(20.83,25.98) v1(20.83,24.14) v1(20.96,82.55) v1(23.53,11.53) v1(23.56,42.55) v1(23.56,41.79) v1(23.56,40.39) v1(24.55,43.52) v1(24.69,120.02) v1(24.74,53.29) v1(24.74,52.46) v1(24.95,41.79) v1(24.95,40.39) v1(25.25,52.91) v1(25.49,43.49) v1(26.3,11.53) v1(26.35,41.79) v1(26.35,40.39) v1(26.77,13.5) v1(26.94,111.67) v1(26.94,109.86) v1(27.8,119.95) v1(27.94,61.55) v1(28.03,79.34) v1(28.19,101.23) v1(28.32,98.56) v1(28.8,78.31) v1(28.8,15.53) v1(28.89,35.69) v1(29.57,99.9) v1(29.73,115.32) v1(29.73,113.5) v1(29.69,79.32) v1(29.69,77.04) v1(30.85,118.27) v1(30.92,101.29) v1(30.86,98.5) v1(31.45,15.53) v1(31.81,115.32) v1(31.79,112.33) v1(31.79,109.17) v1(31.79,106) v1(32.29,103.56) v1(32.78,65.24) v1(32.75,63.46) v1(32.8,59.02) v1(33.3,104.52) v1(34.09,15.53) v1(35.18,95.72) v1(35.18,95.08) v1(35.18,94.48) v1(35.18,93.84) v1(35.18,93.26) v1(35.18,92.62) v1(35.18,92.04) v1(35.32,82.18) v1(35.29,78.67) v1(35.78,95.72) v1(35.78,95.08) v1(35.78,94.48) v1(35.78,93.84) v1(35.78,93.26) v1(35.78,92.62) v1(35.78,92.04) v1(36.23,59.77) v1(36.38,55.91) v1(36.56,75.7) v1(36.62,72.85) v1(36.62,70.19) v1(36.6,67.54) v1(36.62,64.89) v1(36.62,62.23) v1(36.74,15.53) v1(36.79,101.44) v1(36.79,98.87) v1(36.79,96.31) v1(36.79,93.75) v1(36.79,91.19) v1(36.79,88.63) v1(36.82,85.02) v1(38.26,54.29) v1(39.39,15.53) v1(40.63,54.01) v1(42.04,15.53) v1(43.88,53.5) v1(44.68,15.53) v1(45.48,51.7) v1(47.31,49.92) v1(47.33,15.53) v1(49.54,48.09) v1(49.98,15.53) v1(52.18,46.34) v1(52.62,15.53) v1(55.33,44.69) v1(55.27,15.53) v1(57.92,15.53) v1(58.02,43.62) v1(60.56,42.86) v1(60.57,15.53) v1(63.08,42.32) v1(63.21,15.53) v1(65.59,42.03) v1(65.86,15.53) v1(67.73,38.81) v1(68.3,41.9) v1(68.51,15.53) v1(71.15,15.53) v1(71.63,41.92) v1(73.8,15.53) v1(74.97,41.92) v1(76.83,12.5) v1(77.3,10.03) v1(78.3,41.9) v1(78.65,25.67) v1(79.04,26.15) v1(79.87,10.03) v1(80.9,42.02) v1(82.44,10.03) v1(85.01,10.03) v1(86.45,42.97) v1(87.58,10.03) v1(88.54,43.58) v1(90.15,10.03) v1(91.63,44.81) v1(92.72,10.03) v1(94.93,46.62) v1(95.3,10.03) v1(97.87,10.03) v1(98.93,49.54) v1(100.44,10.03) v1(101.1,51.67) v1(103.01,10.03) v1(103.06,53.92) v1(104.96,56.62) v1(105.65,36.3) v1(105.58,10.03) v1(106.42,59.13) v1(107.43,61.37) v1(108.14,63.25) v1(108.15,10.03) v1(108.98,66.23) v1(109.02,38.04) v1(109.02,36.51) v1(109.15,30.11) v1(109.54,69.1) v1(109.59,50.71) v1(109.82,124.34) v1(109.8,104.4) v1(109.78,101.82) v1(109.78,99.23) v1(109.8,96.65) v1(109.78,94.07) v1(109.78,91.48) v1(109.8,88.9) v1(109.78,86.32) v1(109.78,83.73) v1(109.8,81.15) v1(109.78,78.57) v1(109.78,75.98) v1(109.79,75.13) v1(109.79,72.25) v1(109.84,54.32) v1(110.05,52.51) v1(110.07,127.19) v1(110.23,121.93) v1(110.53,67.41) v1(110.53,66.8) v1(110.53,66.19) v1(110.53,65.58) v1(110.72,10.03) v1(111.19,51.83) v1(111.3,115.4) v1(111.28,112.78) v1(111.28,110.16) v1(111.28,107.54) v1(111.3,104.9) v1(111.67,53.48) v1(112,121.9) v1(112.08,55.26) v1(112.22,30.36) v1(112.61,38.17) v1(112.66,52.34) v1(113.25,54.04) v1(113.29,10.03) v1(114,29.98) v1(114.28,121.88) v1(114.28,115.92) v1(114.62,129.24) v1(114.57,54.62) v1(115.15,38.04) v1(115.86,10.03) v1(116.08,121.36) v1(116.54,29.98) v1(116.54,28.46) v1(116.65,117.04) v1(117.15,38.55) v1(117.15,36.26) v1(117.28,119.07) v1(117.79,128.51) v1(118.2,29.98) v1(118.2,28.46) v1(118.42,38.17) v1(118.42,36.64) v1(118.43,10.03) v1(118.58,126.47) v1(120.8,125.52) v1(120.96,38.17) v1(120.96,36.64) v1(121,10.03) v1(121.45,29.98) v1(122.78,38.55) v1(122.78,36.26) v1(123.12,125.46) v1(123.57,10.03) v1(124.28,76.85) v1(124.3,76.19) v1(124.31,75.5) v1(124.32,74.84) v1(124.35,74.16) v1(124.28,29.98) v1(124.28,28.46) v1(124.6,38.17) v1(124.6,36.64) v1(124.88,67.55) v1(125,68.23) v1(125.28,24.72) v1(125.31,14.69) v1(125.31,14.11) v1(125.41,125.97) v1(125.46,68.69) v1(125.94,69.07) v1(126,68.44) v1(126.15,10.03) v1(126.62,29.98) v1(126.62,28.46) v1(126.94,114.26) v1(127.14,38.17) v1(127.3,129.27) v1(127.98,127.64) v1(127.98,126.47) v1(128.33,30.36) v1(128.72,10.03) v1(129.5,124.9) v1(129.6,29.98) v1(129.6,28.46) v1(129.66,38.17) v1(129.88,129.27) v1(130.52,127.64) v1(130.8,125.84) v1(131.29,10.03) v1(132.04,38.93) v1(132.04,37.4) v1(132.19,124.67) v1(132.46,129.27) v1(133.06,127.57) v1(133.72,30.53) v1(133.72,29.01) v1(133.72,27.48) v1(133.86,10.03) v1(133.97,125.79) v1(135.04,129.27) v1(134.97,38.93) v1(134.97,37.4) v1(135.65,127.69) v1(135.68,30.53) v1(135.68,29.01) v1(135.68,27.48) v1(136.23,114.69) v1(136.43,10.03) v1(136.54,114.19) v1(136.84,114.69) v1(137.46,29.77) v1(137.46,28.25) v1(137.62,129.27) v1(138.37,38.93) v1(138.37,37.4) v1(139,10.03) v1(140.12,114.88) v1(140.12,114.27) v1(140.12,113.68) v1(140.2,129.27) v1(140.17,38.93) v1(140.17,37.4) v1(140.17,35.88) v1(140.76,30.53) v1(140.76,29.01) v1(140.76,27.48) v1(141.57,10.03) v1(141.71,29.77) v1(141.97,39.31) v1(141.97,37.02) v1(142.78,129.27) v1(142.82,38.17) v1(142.8,30.91) v1(142.8,28.63) v1(144.14,10.03) v1(144.52,38.93) v1(144.52,37.4) v1(144.52,35.88) v1(144.5,30.53) v1(144.5,29.01) v1(144.5,27.48) v1(145.36,129.27) v1(145.88,19.11) v1(145.88,18.08) v1(146.47,38.93) v1(146.47,37.4) v1(146.54,18.63) v1(146.71,10.03) v1(146.96,30.53) v1(146.96,29.01) v1(147.48,19.14) v1(147.94,129.27) v1(148.88,28.96) v1(150.2,38.17) v1(150.2,36.64) v1(150.52,129.27) v1(150.54,29.77) v1(151.98,38.55) v1(151.98,36.26) v1(152.43,29.77) v1(152.43,28.25) v1(153.1,129.27) v1(154.01,38.17) v1(154.01,36.64) v1(154.42,10.03) v1(155.04,94) v1(155.04,91.97) v1(155.04,89.94) v1(155.04,87.9) v1(155.04,85.87) v1(154.97,29.77) v1(154.97,28.25) v1(155.68,129.27) v1(156.32,38.17) v1(156.32,36.64) v1(157,10.03) v1(157.1,72.38) v1(157.09,30.15) v1(157.27,95.17) v1(157.67,67.45) v1(157.67,66.87) v1(157.67,66.28) v1(157.86,97.54) v1(158.25,129.27) v1(158.34,38.17) v1(158.34,36.64) v1(158.87,29.77) v1(159.57,10.03) v1(160.54,71.61) v1(160.54,70.21) v1(160.54,68.81) v1(160.83,129.27) v1(160.88,38.17) v1(160.88,36.64) v1(160.9,29.77) v1(162.14,10.03) v1(162.55,38.55) v1(162.55,36.26) v1(162.98,72.31) v1(162.98,70.91) v1(162.98,69.51) v1(162.98,68.11) v1(162.98,66.71) v1(163.35,29.77) v1(163.35,28.25) v1(163.41,129.27) v1(164.58,38.17) v1(164.58,36.64) v1(164.71,10.03) v1(165.42,71.83) v1(165.42,69.98) v1(165.99,129.27) v1(165.98,29.77) v1(165.98,28.25) v1(167.12,38.17) v1(167.28,10.03) v1(167.68,30.15) v1(167.85,73.01) v1(167.85,71.61) v1(167.85,70.21) v1(167.85,68.81) v1(167.85,67.41) v1(168.57,129.27) v1(168.95,29.77) v1(169.04,38.17) v1(169.85,10.03) v1(171.15,129.27) v1(172.42,10.03) v1(172.72,71.05) v1(173.73,129.27) v1(174.99,10.03) v1(176.31,129.27) v1(177.56,10.03) v1(178.89,129.27) v1(179.51,66.62) v1(180.02,66.24) v1(180.13,10.03) v1(180.78,65.48) v1(181.13,89.8) v1(181.29,65.03) v1(181.47,129.27) v1(181.78,123.2) v1(182.7,10.03) v1(183.9,38.02) v1(183.9,36.5) v1(184.05,129.27) v1(184.6,30.59) v1(184.6,29.07) v1(185,119.13) v1(185.29,118.63) v1(185.27,10.03) v1(185.61,119.13) v1(185.93,30.97) v1(185.93,28.69) v1(186.12,108.85) v1(186.24,119.13) v1(186.63,129.27) v1(186.75,108.85) v1(187.81,30.59) v1(187.81,29.07) v1(187.85,10.03) v1(189.21,129.27) v1(189.91,38.02) v1(190.42,10.03) v1(191.11,30.59) v1(191.11,29.07) v1(191.79,129.27) v1(192.99,10.03) v1(193.17,38.02) v1(193.91,30.59) v1(193.91,29.07) v1(194.37,129.27) v1(194.48,124.98) v1(195.56,10.03) v1(195.71,38.02) v1(196.46,30.59) v1(196.95,129.27) v1(198.13,10.03) v1(198.88,108.78) v1(199.3,108.37) v1(199.29,38.02) v1(199.53,129.27) v1(200.7,10.03) v1(200.8,23.17) v1(201.27,29.07) v1(201.85,38.02) v1(202.11,129.27) v1(202.54,28.69) v1(203.27,10.03) v1(203.85,93.58) v1(204.05,30.59) v1(204.05,29.07) v1(204.37,38.02) v1(204.69,129.27) v1(205.84,10.03) v1(206.66,31.35) v1(206.66,29.82) v1(206.66,28.3) v1(207.27,129.27) v1(208.41,10.03) v1(208.59,31.35) v1(208.59,29.82) v1(209.85,129.27) v1(210.41,32.87) v1(210.41,31.35) v1(210.41,29.82) v1(210.41,28.3) v1(210.61,121.86) v1(210.61,121.28) v1(210.98,10.03) v1(211.81,38.8) v1(211.81,37.28) v1(212.43,129.27) v1(213.11,31.35) v1(213.11,29.82) v1(213.11,28.3) v1(214.25,38.8) v1(214.25,37.28) v1(214.25,35.75) v1(215,129.27) v1(215.34,31.35) v1(215.34,29.82) v1(215.34,28.3) v1(216.11,39.18) v1(216.2,29.06) v1(217.16,64.55) v1(217.18,30.21) v1(217.25,38.04) v1(217.58,129.27) v1(218.45,31.35) v1(218.45,29.82) v1(218.62,38.8) v1(218.62,37.28) v1(218.62,35.75) v1(218.81,10.02) v1(220.16,129.27) v1(220.18,38.8) v1(220.18,37.28) v1(220.26,30.59) v1(220.26,29.06) v1(221.27,10.03) v1(222.01,30.59) v1(222.01,29.06) v1(222.2,38.8) v1(222.2,37.28) v1(222.74,129.27) v1(223.84,10.03) v1(224.5,29.77) v1(224.7,38.04) v1(224.7,36.51) v1(225.32,129.27) v1(226.41,10.03) v1(227.04,29.77) v1(227.04,28.25) v1(227.44,38.42) v1(227.9,129.27) v1(228.77,38.04) v1(228.77,36.51) v1(228.98,10.03) v1(229.58,29.77) v1(229.58,28.25) v1(229.93,107.45) v1(230.48,129.27) v1(230.85,30.15) v1(231.02,38.04) v1(231.07,67.25) v1(231.38,67.89) v1(231.55,10.03) v1(231.71,68.59) v1(232.7,127.08) v1(232.7,125.81) v1(232.7,124.54) v1(232.7,123.27) v1(232.75,122.03) v1(232.9,117.91) v1(232.9,116.64) v1(232.9,29.77) v1(233.06,129.27) v1(233.14,38.04) v1(234.07,127.08) v1(234.07,125.81) v1(234.07,124.54) v1(234.07,123.27) v1(234.12,10.03) v1(235.34,127.08) v1(235.34,125.81) v1(235.34,124.54) v1(235.44,29.77) v1(235.64,129.27) v1(235.58,38.04) v1(235.58,36.51) v1(236.61,127.08) v1(236.61,125.81) v1(236.61,124.54) v1(236.74,20.38) v1(236.69,10.03) v1(237.22,29.77) v1(237.22,28.25) v1(237.6,13.11) v1(237.73,38.42) v1(237.88,127.08) v1(237.88,125.81) v1(237.88,124.54) v1(238.22,129.27) v1(239.26,38.04) v1(239.26,36.51) v1(239.26,10.03) v1(239.41,124.29) v1(239.71,125.51) v1(239.76,29.77) v1(239.76,28.25) v1(240.96,124.01) v1(241.01,122.59) v1(240.98,117.53) v1(240.98,116.26) v1(241.16,129.07) v1(241.76,38.04) v1(241.76,36.51) v1(241.83,10.03) v1(242.07,126.5) v1(242.14,30.15) v1(242.33,122.74) v1(242.25,121.34) v1(242.25,120.07) v1(242.25,118.8) v1(242.25,117.53) v1(242.25,116.26) v1(243.41,29.77) v1(243.52,121.34) v1(243.52,120.07) v1(243.52,118.8) v1(243.52,117.53) v1(243.52,116.26) v1(243.87,38.68) v1(243.93,38.04) v1(243.93,36.51) v1(244.77,125.48) v1(244.79,121.34) v1(244.79,120.07) v1(244.79,118.8) v1(244.79,117.53) v1(244.79,116.26) v1(244.98,8.48) v1(246.52,118.78) v1(246.52,117.51) v1(246.52,116.24) v1(246.63,36.33) v1(246.63,35.63) v1(247.66,8.48) v1(247.79,117.51) v1(247.79,116.24) v1(248.04,126.5) v1(249.3,129.27) v1(249.75,120.39) v1(249.75,117.41) v1(250.34,8.48) v1(252.61,115.91) v1(253.02,8.48) v1(253.07,121.9) v1(255.27,115.51) v1(255.32,112.11) v1(255.32,108.81) v1(255.32,105.52) v1(255.7,8.48) v1(255.97,45.96) v1(256.3,121.88) v1(256.81,124.52) v1(256.82,102.37) v1(256.82,99.73) v1(256.82,97.1) v1(256.82,94.47) v1(256.82,91.83) v1(256.82,89.2) v1(256.82,86.57) v1(256.82,83.93) v1(256.82,81.3) v1(256.82,78.67) v1(256.82,76.03) v1(256.82,73.4) v1(256.92,70.8) v1(257.25,68.22) v1(257.77,65.62) v1(258.44,63.25) v1(258.38,8.48) v1(259.84,59.82) v1(261.07,8.48) v1(261.81,56.21) v1(263.75,8.48) v1(265.14,52.08) v1(266.43,8.48) v1(267.93,49.36) v1(269.11,8.48) v1(271.08,47.04) v1(271.79,8.48) v1(273.32,45.71) v1(274.47,8.48) v1(275.65,44.57) v1(276.46,18.32) v1(276.59,29.07) v1(279.18,43.24) v1(280.46,38.91) v1(282.33,42.48) v1(284,9.98) v1(285.7,42.02) v1(287.05,9.98) v1(287.18,40.58) v1(287.18,12.17) v1(288.3,41.92) v3(10.6,90.81) v3(10.6,89.01) v3(12.23,90.81) v3(12.23,89.01) v3(12.84,18.96) v3(13.78,18.6) v3(14.16,28.61) v3(14.73,92.53) v3(14.73,89.03) v3(16.08,16.76) v3(17.11,63.72) v3(17.59,71.56) v3(17.67,57.09) v3(17.97,59.88) v3(17.98,15.46) v3(18.73,71.56) v3(18.78,57.09) v3(19.21,59.27) v3(21.75,73.6) v3(22.65,32.5) v3(22.71,73.6) v3(22.87,32.04) v3(23.65,16.13) v3(24.37,22.42) v3(24.73,78.69) v3(25.18,77.05) v3(25.18,74.36) v3(25.55,14.83) v3(27.13,24.82) v3(27.24,29.22) v3(27.18,18.01) v3(28.08,27.59) v3(28.08,27.11) v3(28.26,52.24) v3(28.28,24.82) v3(28.93,55.63) v3(29.08,16.71) v3(31.43,40.95) v3(32.56,45.16) v3(32.56,43.89) v3(33.87,28.63) v3(34.68,102.81) v3(34.68,101.86) v3(34.68,100.91) v3(34.68,98.81) v3(34.68,97.92) v3(34.68,97.04) v3(34.83,28.23) v3(35.04,43.47) v3(35.29,38.41) v3(35.57,43.19) v3(36.31,43.44) v3(36.82,43.19) v3(39.77,44.7) v3(39.76,43.52) v3(47.79,28.38) v3(49.31,37.29) v3(50.23,28.96) v3(50.43,28.48) v3(52.44,35.32) v3(53.84,34.18) v3(59.25,27.32) v3(65.16,23.15) v3(80.88,39.89) v3(94.85,40.84) v3(97.47,19.46) v3(97.47,18.37) v3(99.33,15.96) v3(101.38,18.91) v3(115.2,19.69) v3(115.26,12.77) v3(121.27,18.93) v3(155.26,96.05) v3(156.6,20.9) v3(162.09,10.93) v3(163.01,10.93) v3(163.9,11.19) v3(166.72,12.97) v3(166.72,12.08) v3(167.91,11.35) v3(168.51,11.35) v3(171.52,15.95) v3(173.3,16.84) v3(173.57,110.07) v3(176.08,12.15) v3(183.7,119.46) v3(184.21,119.18) v3(185.74,81.61) v3(187.74,126.5) v3(188,126.02) v3(191.2,126.22) v3(193.76,121.97) v3(194.29,127.98) v3(199.05,113.35) v3(199.05,81.52) v3(199.05,79.74) v3(199.43,80.55) v3(199.43,78.77) v3(200.14,128.03) v3(200.14,127.14) v3(201.02,128.04) v3(205.14,81.03) v3(205.17,82.79) v3(205.57,81.77) v3(205.57,80.04) v3(205.66,18.18) v3(208.23,103.45) v3(208.8,17.62) v3(208.8,16.48) v3(210.66,88.21) v3(210.73,83.68) v3(210.95,78.18) v3(211.05,21.98) v3(211.22,79.93) v3(211.22,79.51) v3(211.75,82.1) v3(211.76,82.54) v3(213.13,18.04) v3(213.4,89.67) v3(213.46,97.74) v3(214.13,98.81) v3(215.01,20.51) v3(215.2,97.67) v3(216.52,97.67) v3(216.72,83.45) v3(218.31,21.42) v3(219.05,86.25) v3(219.05,85.36) v3(219.06,84.48) v3(219.96,81.78) v3(221.07,98.05) v3(222.82,102.81) v3(224.62,84.15) v3(224.64,59.27) v3(224.8,80.34) v3(225.18,60.36) v3(226.06,76.91) v3(226.06,75.7) v3(233.49,108.19) v3(233.87,107.25) v3(238.3,13.78) v3(240.65,15) v3(241.12,61.69) v3(242.04,61.7) v3(242.93,61.7) v3(247.17,11.63) v3(252.08,32.06) v3(252.33,36.45) v3(252.33,35.84) v3(252.33,34.66) v3(252.33,34.05) v3(252.56,32.62) v3(253.8,12.86) v3(254.32,21.6) v3(255.14,31.42) v3(255.78,31.42) v3(256.17,41.33) v3(256.4,40.88) v3(258.74,50.56) v3(259.69,53.81) v3(260.22,42.43) v3(261.32,42.19) v3(262.12,21.72) v3(263.02,33.09) v3(263.83,20.34) v3(264.53,21.47) v3(268.8,33.47) v3(268.97,32.46) v3(268.98,29.36) v3(269.93,27.69) v3(271.78,18.85) v3(274.51,17.27) v3(275.6,26.3) v3(276.1,12.25) v3(276.16,27.55) v3(277.74,34.76) v3(277.81,30.99) v3(278.06,25.47) v3(278.64,36.65) v3(278.64,35.77) v3(279.59,36.63) v3(280.48,37.61) v3(280.73,25.47) v7(2.65,24.52) v7(4.08,12.07) v7(4.3,11.59) v7(5.09,12.07) v7(5.35,11.56) v7(7.94,10.47) v7(7.94,9.46) v7(12.24,93.8) v7(12.24,92.91) v7(12.18,90.06) v7(15.67,91.48) v7(18.88,60.31) v7(18.92,17.11) v7(19.39,60.29) v7(20.55,79.83) v7(20.82,18.41) v7(22.59,76.02) v7(22.78,15.28) v7(23.11,71.04) v7(23.52,74.68) v7(23.64,32.01) v7(24.68,16.58) v7(25.25,69.85) v7(25.76,16.68) v7(26.53,60.03) v7(27.66,17.98) v7(28.18,53.98) v7(28.54,49.4) v7(28.82,85.03) v7(29.07,53.98) v7(30.64,39.12) v7(30.64,38.23) v7(32.51,42.74) v7(32.5,38.82) v7(32.46,28.46) v7(34.83,30.16) v7(35.22,39.73) v7(36.26,43.89) v7(36.64,30.16) v7(36.99,39.73) v7(39.66,38.82) v7(40.52,39.76) v7(40.74,41.82) v7(40.98,49.96) v7(41.62,36.61) v7(42.48,32.78) v7(43.85,49.79) v7(44.5,37.41) v7(45.81,37.55) v7(46.86,42.84) v7(49.95,38.2) v7(55.4,38.3) v7(57.35,34.11) v7(57.89,37.85) v7(58.1,28.08) v7(59.88,36.13) v7(61.99,39.05) v7(63.26,38.77) v7(65.32,34.11) v7(66.59,30.95) v7(69.28,32.33) v7(69.57,30.76) v7(70.52,30.95) v7(75.37,32.6) v7(75.47,37.12) v7(75.53,36.15) v7(76.29,32.24) v7(76.6,36.65) v7(77.74,37.17) v7(77.74,36.13) v7(86.85,37.17) v7(86.85,36.18) v7(87.82,32.7) v7(89.11,37.17) v7(89.11,36.15) v7(94.02,39.99) v7(93.99,37.42) v7(95.06,39.99) v7(95.08,37.42) v7(101.05,24.35) v7(101.64,29.48) v7(101.66,28.57) v7(107.3,54.44) v7(111.06,123.1) v7(116.3,19.32) v7(116.95,78.19) v7(117.16,21.99) v7(119.8,19.32) v7(122.49,21.99) v7(123.06,121.75) v7(123.97,121.75) v7(126.63,121.75) v7(128.01,122.04) v7(129.92,116.71) v7(131.38,18.85) v7(131.63,18.37) v7(132.07,96.32) v7(132.98,96.32) v7(135.63,23.1) v7(135.82,21.98) v7(137.27,81.27) v7(138.24,81.27) v7(139.83,23.1) v7(142.56,12.83) v7(142.56,11.97) v7(142.92,111.07) v7(142.92,110.18) v7(144.56,12.83) v7(144.59,11.95) v7(145.81,23.3) v7(145.85,22.16) v7(153.47,20.07) v7(154.94,111.31) v7(154.91,110.4) v7(157.64,12.56) v7(158.74,12.58) v7(162.62,21.53) v7(164.99,22.26) v7(165.92,22.25) v7(166.81,22.25) v7(166.81,13.84) v7(167.78,20.45) v7(169.12,14.57) v7(170.09,21.65) v7(172.93,21.65) v7(175.83,22.56) v7(176.78,22.56) v7(179.54,110.57) v7(179.57,111.39) v7(179.72,54.26) v7(180.53,110.85) v7(181.5,111.42) v7(181.49,110.5) v7(183.12,111.42) v7(183.09,110.5) v7(184.11,110.87) v7(185.08,111.39) v7(185.1,110.47) v7(193.65,63.15) v7(196.19,71.02) v7(199.77,22.56) v7(200.72,22.56) v7(203.82,95.93) v7(204.15,19.93) v7(204.57,90.23) v7(204.6,88.58) v7(215.64,21.8) v7(220.28,13.43) v7(222.25,73.85) v7(222.41,16.75) v7(222.9,16.76) v7(223.26,73.85) v7(223.26,72.85) v7(223.33,16.75) v7(224.42,12.52) v7(225.74,12.53) v7(226.06,21.66) v7(227.15,15.87) v7(227.28,74.56) v7(227.89,22.93) v7(236.22,21.96) v7(239.61,16.7) v7(248.47,11.89) v7(254.42,44.18) v7(254.49,46.59) v7(255.14,17.4) v7(255.56,123.1) v7(255.79,47.25) v7(256.3,45.35) v7(256.32,43.04) v7(256.93,10.6) v7(257.19,10.17) v7(257.39,10.6) v7(257.64,10.19) v7(257.83,17.4) v7(258.02,46.64) v7(258.13,44) v7(258.78,17.4) v7(259.73,17.4) v7(260.68,17.4) v7(261.64,17.4) v7(262.59,17.4) v7(273.49,18.02) v7(273.57,15.45) v7(275.17,16.87) v7(275.42,14.49) v7(275.91,18.93) v7(276.95,15.45) v7(277.02,18.02) v7(278.42,40.57) v7(278.88,41.38) v7(279.16,30.55) v7(279.92,41.82) v7(281.62,32.2) v7(281.62,31.4) v7(281.62,29) v7(281.62,28.2) v7(281.62,25.8) v7(281.62,20.2) v7(281.62,17.8) v8(7.48,23.99) v8(34.15,94.19) v8(45.96,18.65) v8(78.95,30.82) v8(95.67,17) v8(112.99,103.54) v8(121.68,76.74) v8(125,24.09) v8(125.46,75.14) v8(134.33,77.2) v8(136.21,115.5) v8(138.54,79.1) v8(142.81,124.24) v8(156.07,120.1) v8(157.41,119.92) v8(164.17,121.88) v8(179.74,123.02) v8(184.29,108.97) v8(241.21,65.77) v8(242.78,68.28) v9(14.92,12.96) v9(16.27,13.7) v9(17.71,12.91) v9(30.28,17.41) v9(30.28,16.77) v9(30.92,17.41) v9(30.92,16.77) v9(31.55,17.41) v9(31.55,16.77) v9(32.19,17.41) v9(32.19,16.77) v9(35.7,17.48) v9(35.7,16.85) v9(40.98,16.55) v9(41.49,17.54) v9(41.69,16.65) v9(42.08,17.28) v9(42.33,16.65) v9(42.48,18.55) v9(42.51,17.89) v9(42.58,19.95) v9(42.61,19.27) v9(42.71,17.28) v9(42.96,16.65) v9(43.14,18.55) v9(43.14,17.89) v9(43.22,19.95) v9(43.3,19.27) v9(43.35,17.28) v9(43.6,16.65) v9(43.78,18.55) v9(43.78,17.89) v9(43.85,19.95) v9(43.93,19.29) v9(44.44,18.66) v9(44.49,19.95) v9(44.57,19.32) v9(44.92,18.22) v9(45.23,20.46) v9(46.62,20.49) v9(46.7,19.16) v9(46.77,18.15) v9(48.3,32.91) v9(48.3,31.89) v9(48.77,32.37) v9(49.31,32.78) v9(49.31,31.89) v9(57.59,16.64) v9(57.97,17.28) v9(58.23,16.64) v9(58.74,17.28) v9(58.86,16.64) v9(59.5,17.28) v9(59.5,16.64) v9(72.81,21.22) v9(72.81,20.33) v9(72.81,19.06) v9(72.81,17.79) v9(72.81,16.65) v9(72.94,23) v9(72.94,22.11) v9(73.7,23) v9(73.7,22.11) v9(74.46,23) v9(74.46,22.11) v9(74.59,21.35) v9(74.59,20.21) v9(74.59,19.06) v9(74.59,17.79) v9(74.59,16.65) v9(75.22,23) v9(75.22,22.11) v9(75.22,21.35) v9(75.22,20.21) v9(75.22,19.06) v9(75.22,17.79) v9(75.22,16.65) v9(75.91,23) v9(75.91,22.11) v9(75.86,21.35) v9(75.86,20.21) v9(75.86,19.06) v9(75.86,17.79) v9(75.86,16.65) v9(78.91,28.21) v9(78.97,29.31) v9(79.54,28.84) v9(80.05,28.21) v9(80.11,29.31) v9(92.05,16.07) v9(92.05,15.43) v9(92.69,16.07) v9(92.69,15.43) v9(93.37,16.07) v9(93.37,15.43) v9(94.01,16.07) v9(94.01,15.43) v9(94.64,16.07) v9(94.64,15.43) v9(95.28,16.07) v9(95.28,15.43) v9(95.93,16.07) v9(95.93,15.44) v9(96.57,16.07) v9(96.57,15.44) v9(97.22,16.09) v9(97.22,15.45) v9(98.46,11.09) v9(99.1,11.09) v9(99.73,11.09) v9(100.37,11.09) v9(101,11.09) v9(101.64,11.09) v9(102.27,11.09) v9(102.91,11.09) v9(103.54,11.09) v9(104.18,11.09) v9(111.43,74.82) v9(111.51,77.36) v9(111.51,76.72) v9(111.51,76.09) v9(111.51,75.45) v9(111.81,74.31) v9(112.18,77.36) v9(112.18,76.72) v9(112.18,76.09) v9(112.18,75.45) v9(112.19,74.82) v9(112.52,105.1) v9(112.57,74.31) v9(112.94,77.36) v9(112.94,76.72) v9(112.94,76.09) v9(112.94,75.45) v9(112.95,74.82) v9(113.07,105.42) v9(113.09,104.78) v9(113.33,74.28) v9(113.7,77.36) v9(113.7,76.72) v9(113.7,76.09) v9(113.7,75.45) v9(113.79,105.42) v9(113.79,104.78) v9(114.29,103.53) v9(114.47,105.42) v9(114.47,104.79) v9(114.47,77.36) v9(114.47,76.72) v9(114.47,76.09) v9(114.47,75.45) v9(115.23,77.36) v9(115.23,76.72) v9(115.23,76.09) v9(115.23,75.45) v9(115.31,104.3) v9(115.35,105.55) v9(115.35,103.62) v9(115.82,76.97) v9(115.99,106.57) v9(115.99,105.8) v9(115.99,105.04) v9(115.99,104.28) v9(115.99,103.62) v9(116.12,76.09) v9(116.12,75.45) v9(116.37,77.48) v9(116.75,106.57) v9(116.75,105.8) v9(116.75,105.04) v9(116.75,104.28) v9(116.75,103.62) v9(117.51,106.57) v9(117.51,105.8) v9(117.51,105.04) v9(117.51,104.28) v9(117.51,103.62) v9(118.28,106.57) v9(118.28,105.8) v9(118.28,105.04) v9(118.28,104.28) v9(118.28,103.62) v9(119.04,106.57) v9(119.04,105.8) v9(119.04,105.04) v9(119.04,104.28) v9(119.04,103.62) v9(123.64,117.21) v9(123.64,115.81) v9(124.4,116.45) v9(125.29,117.21) v9(125.29,115.81) v9(125.53,17.83) v9(127.65,13.86) v9(127.65,13.22) v9(127.7,12.59) v9(127.98,14.41) v9(128.31,13.86) v9(128.31,13.22) v9(128.31,12.2) v9(128.69,12.71) v9(129.07,98.76) v9(129.12,13.19) v9(129.09,12.2) v9(129.54,12.71) v9(129.77,99.39) v9(129.77,98.76) v9(129.92,12.2) v9(130.01,95.51) v9(130.24,12.77) v9(130.57,12.23) v9(130.94,12.77) v9(131.1,96.57) v9(131.68,80.73) v9(131.68,79.97) v9(131.68,79.21) v9(131.68,78.51) v9(131.68,77.81) v9(131.68,77.05) v9(132.44,78.51) v9(132.44,77.81) v9(132.44,77.05) v9(133.15,78.52) v9(133.15,77.76) v9(133.15,77) v9(141.77,122.95) v9(141.77,121.93) v9(142.41,122.44) v9(143.04,122.95) v9(143.04,121.93) v9(156.15,120.82) v9(156.78,124.29) v9(156.78,123.66) v9(156.78,123) v9(156.78,122.36) v9(156.78,120.84) v9(156.97,126.75) v9(157.11,125.74) v9(157.11,125.11) v9(157.42,120.82) v9(157.65,126.76) v9(157.75,125.74) v9(157.75,125.11) v9(158.08,120.97) v9(158.3,126.75) v9(158.41,125.74) v9(158.41,125.11) v9(158.41,124.47) v9(158.41,123.84) v9(158.41,123.2) v9(158.43,122.57) v9(158.41,121.81) v9(158.71,121.17) v9(158.94,126.75) v9(159.04,125.74) v9(159.04,125.11) v9(159.04,124.47) v9(159.04,123.84) v9(159.04,123.2) v9(159.04,121.81) v9(159.07,122.57) v9(159.57,126.75) v9(159.68,125.74) v9(159.68,125.11) v9(159.68,124.47) v9(159.68,123.84) v9(159.68,123.2) v9(159.7,122.57) v9(159.68,121.81) v9(162.98,124.47) v9(163.61,124.47) v9(164.25,125.3) v9(164.88,125.3) v9(164.88,122.44) v9(165.14,121.81) v9(165.27,123.71) v9(165.27,123.08) v9(165.52,125.3) v9(165.52,122.44) v9(165.9,123.71) v9(165.9,123.08) v9(166.28,122.31) v9(166.66,123.58) v9(166.66,122.95) v9(166.92,122.31) v9(167.3,123.58) v9(167.3,122.95) v9(167.55,122.31) v9(167.93,123.58) v9(167.93,122.95) v9(168.19,122.31) v9(168.57,123.58) v9(168.57,122.95) v9(169.2,123.58) v9(169.2,122.95) v9(169.38,125.11) v9(169.46,124.47) v9(169.84,123.84) v9(169.84,123.2) v9(170.02,125.11) v9(170,122.59) v9(170.03,121.93) v9(170.09,124.47) v9(170.47,123.84) v9(170.47,123.2) v9(170.65,122.59) v9(170.65,125.11) v9(170.73,124.47) v9(170.66,121.93) v9(172,125.23) v9(172,124.35) v9(172,123.71) v9(172,123.08) v9(171.99,122.41) v9(172.63,124.35) v9(172.63,123.71) v9(172.63,123.08) v9(172.63,122.41) v9(173.27,124.35) v9(173.27,123.71) v9(173.27,123.08) v9(173.26,122.41) v9(173.9,124.35) v9(173.9,123.71) v9(173.9,123.08) v9(173.9,122.41) v9(175.3,124.22) v9(175.3,123.58) v9(175.3,122.95) v9(175.93,124.22) v9(175.93,123.58) v9(175.93,122.95) v9(177.84,124.22) v9(177.84,123.2) v9(177.84,122.57) v9(178.09,125.7) v9(178.09,125.07) v9(178.47,124.47) v9(178.47,123.84) v9(178.47,123.2) v9(178.47,122.57) v9(178.73,125.7) v9(178.73,125.07) v9(179.11,124.47) v9(179.11,123.84) v9(179.11,123.2) v9(179.11,122.57) v9(179.79,124.47) v9(179.79,123.81) v9(184.21,122.18) v9(184.52,121.62) v9(185.02,123.02) v9(185.66,123.02) v9(186.29,123.05) v9(186.31,121.42) v9(186.96,122.99) v9(186.96,121.39) v9(187.59,122.99) v9(188.53,124.66) v9(188.53,124.02) v9(188.56,125.29) v9(189.29,125.29) v9(189.29,124.66) v9(189.29,124.02) v9(190.05,125.29) v9(190.05,124.66) v9(190.05,124.02) v9(190.82,125.29) v9(241.8,66.36) v9(241.82,65.72) v9(242.47,67) v9(242.47,66.37) v9(242.45,65.72) v9(243.12,67.65) v9(243.12,67.02) v9(243.12,66.38) v9(243.09,65.73) v9(243.75,67.65) v9(243.76,67) v9(243.76,66.37) v9(243.79,65.73) v9(244.39,67.32) v9(244.39,66.66) v9(244.39,66.03) v9(253.28,74.87) v9(253.28,74.23) v9(253.92,74.88) v9(253.92,74.22) v9(254.56,74.88) v9(254.56,74.22) v9(255.19,74.88) v9(255.19,74.22) v9(277.63,10.93) v9(280.96,10.9)
